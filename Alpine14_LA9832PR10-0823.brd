# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D43: length 50.7
  IN3 w0.076: 136.88,55.73 136.28,55.73 135.97,55.42 130.72,55.42 130.16,54.85 129.46,54.85 127.28,52.68 126.08,52.68 v2(125.73,52.32)
  IN3 w0.102: 136.88,55.73 139.39,55.73 141.47,57.81 158.34,57.81 158.47,57.94 158.47,58.46 158.6,58.59 158.88,58.59 159.01,58.46 159.01,57.94 159.13,57.81 159.39,57.81 159.51,57.94 159.51,58.46 159.64,58.59 159.9,58.59 160.02,58.46 160.02,56.93 160.15,56.81 160.4,56.81 160.53,56.93 160.53,57.42 160.66,57.55 162.53,57.55 162.63,57.45 162.63,56.89 162.74,56.79 163.04,56.79 163.14,56.89 163.14,57.34 163.27,57.47 163.63,57.47 163.76,57.34 163.76,56.94 163.88,56.81 164.23,56.81 164.36,56.94 164.36,57.4 v2(164.74,57.78)
  BOTTOM w0.076: UC1.AP25 125.4,52.64 v2(125.73,52.32)
  BOTTOM w0.102: v2(164.74,57.78) 164.29,57.33 163.8,57.33 163.58,57.55 JDIMM2.157
DDR_B_D44: length 53.2
  IN3 w0.076: 136.88,53.23 136.59,53.23 135.81,52.44 135.81,52.31 135.54,52.04 128.28,52.04 126.93,50.69 124.97,50.69 124.79,50.87 124.23,50.87 123.34,51.76 122.82,51.76 122.4,52.18 v2(122.4,52.19)
  IN3 w0.102: v2(167.78,54.73) 166.77,53.71 163.22,53.71 162.92,53.41 159.95,53.41 158.75,54.6 148.25,54.6 148.12,54.73 148.12,55.03 147.92,55.23 142.63,55.23 140.63,53.23 136.88,53.23
  BOTTOM w0.076: UC1.AK26 122.8,51.78 122.4,52.18 v2(122.4,52.19)
  BOTTOM w0.102: v2(167.78,54.73) 168.26,54.25 JDIMM2.146
DDR_B_D45: length 52.7
  IN3 w0.076: 136.88,53.53 136.4,53.53 136.29,53.42 135.77,53.42 135.52,53.18 129.19,53.18 126.86,50.85 125.09,50.85 124.64,51.3 v2(124.38,51.3)
  IN3 w0.102: v2(166.26,54.73) 166.26,54.17 166.11,54.02 163.1,54.02 162.79,53.71 160.08,53.71 158.88,54.91 150.69,54.91 150.54,55.06 150.54,55.52 150.45,55.61 150.12,55.61 150.03,55.52 150.03,54.98 149.96,54.91 149.6,54.91 149.52,54.98 149.52,55.52 149.43,55.61 149.11,55.61 149.01,55.52 149.01,55.01 148.91,54.91 148.65,54.91 148.55,55.01 148.55,55.47 148.44,55.57 142.28,55.57 140.24,53.53 136.88,53.53
  BOTTOM w0.076: v2(124.38,51.3) 124.1,51.58 UC1.AM26
  BOTTOM w0.102: JDIMM2.149 163.72,55.15 163.87,55.3 165.69,55.3 v2(166.26,54.73)
DDR_B_D46: length 53.1
  IN3 w0.076: 136.88,56.34 136.42,56.34 135.83,55.75 130.59,55.75 130.05,55.21 129.35,55.21 127.15,53.01 125.95,53.01 125.78,52.84 123.7,52.84 v2(123.13,52.27)
  IN3 w0.102: 136.88,56.34 139.13,56.34 141.21,58.42 156.49,58.42 156.66,58.6 156.66,59.1 156.94,59.38 160.02,59.38 160.85,58.54 169.16,58.54 169.31,58.39 v2(169.31,57.78)
  BOTTOM w0.076: v2(123.13,52.27) 122.8,52.59 UC1.AK25
  BOTTOM w0.102: JDIMM2.160 169.45,58.45 169.31,58.31 v2(169.31,57.78)
DDR_B_D47: length 53.5
  IN3 w0.076: 136.88,56.04 136.35,56.04 135.9,55.59 130.66,55.59 130.12,55.05 129.42,55.05 127.21,52.84 126.01,52.84 125.85,52.68 124.1,52.68 v2(123.78,52.35)
  IN3 w0.102: 136.88,56.04 139.26,56.04 141.34,58.12 156.86,58.12 156.96,58.22 156.96,58.97 157.06,59.07 157.37,59.07 157.47,58.97 157.47,58.22 157.57,58.12 157.88,58.12 157.98,58.22 157.98,58.97 158.08,59.07 159.89,59.07 160.78,58.18 167.38,58.18 v2(167.78,57.78)
  BOTTOM w0.076: v2(123.78,52.35) 123.45,52.68 UC1.AL25
  BOTTOM w0.102: JDIMM2.158 169.97,57.85 169.26,57.14 168.42,57.14 v2(167.78,57.78)
DDR_B_D48: length 52.9
  IN3 w0.076: 136.52,58.49 136.02,58 135.52,57.5 129.5,57.5 128.37,56.37 127.92,56.37 127.36,55.81 127.36,55.36 126.98,54.98 126.42,54.98 v2(126.4,54.99)
  IN3 w0.102: 136.52,58.49 136.52,58.54 137.03,59.04 137.75,59.04 141.11,62.4 151.85,62.4 151.95,62.5 151.95,63.09 152.07,63.21 152.33,63.21 152.46,63.09 152.46,62.5 152.56,62.4 152.86,62.4 152.96,62.5 152.96,63.09 153.09,63.21 153.34,63.21 153.47,63.09 153.47,62.5 153.57,62.4 153.88,62.4 153.98,62.5 153.98,63.09 154.11,63.21 154.36,63.21 154.49,63.09 154.49,62.5 154.59,62.4 165.81,62.4 166.12,62.7 167.38,62.7 v2(167.78,63.11)
  BOTTOM w0.076: v2(126.4,54.99) 126.4,55.05 126.05,55.4 UC1.AR21
  BOTTOM w0.102: v2(167.78,63.11) 168.25,62.65 JDIMM2.174
DDR_B_D49: length 53
  IN3 w0.076: 137.03,57.82 136.58,57.82 135.76,57 130.73,57 129.6,55.87 129.08,55.87 127.32,54.12 v2(126.38,54.12)
  IN3 w0.102: 137.03,57.82 138.47,57.82 140.5,59.85 141.11,59.85 141.24,59.97 141.24,60.78 141.37,60.91 141.59,60.91 141.72,60.78 141.72,59.97 141.85,59.85 142.1,59.85 142.23,59.97 142.23,61.02 142.36,61.15 142.61,61.15 142.74,61.02 142.74,59.97 142.86,59.85 143.12,59.85 143.25,59.97 143.25,61.02 143.37,61.15 143.63,61.15 143.75,61.02 143.75,59.97 143.88,59.85 144.13,59.85 144.26,59.97 144.26,61.02 144.39,61.15 144.63,61.15 144.76,61.02 144.76,60.39 144.89,60.27 145.14,60.27 145.24,60.36 145.24,60.67 145.37,60.8 164.32,60.8 164.74,60.38 v2(164.74,60.06)
  BOTTOM w0.076: v2(126.38,54.12) 126.05,54.44 UC1.AR22
  BOTTOM w0.102: v2(164.74,60.06) 164.33,59.66 163.76,59.66 163.47,59.95 JDIMM2.165
DDR_B_D50: length 55.3
  IN3 w0.076: v2(123.78,55.07) 123.78,55.09 124.11,55.43 125.94,55.43 126.03,55.51 126.89,55.51 127.03,55.66 127.03,55.94 127.94,56.86 128.29,56.86 129.88,58.45 132.85,58.45
  IN3 w0.102: 132.85,58.45 135.69,58.45 136.9,59.66 137.51,59.66 141.03,63.19 151.09,63.19 151.72,63.82 158.13,63.82 158.26,63.7 158.26,63.14 158.38,63.01 158.64,63.01 158.77,63.14 158.77,63.7 158.89,63.82 159.15,63.82 159.27,63.7 159.27,63.14 159.4,63.01 159.65,63.01 159.78,63.14 159.78,63.7 159.91,63.82 160.14,63.82 160.27,63.7 160.27,63.14 160.4,63.01 160.65,63.01 160.78,63.14 160.78,63.67 160.91,63.8 162.06,63.8 162.18,63.67 162.18,63.14 162.31,63.01 162.56,63.01 162.69,63.14 162.69,63.7 162.82,63.82 163.76,63.82 163.86,63.72 163.86,63.65 163.99,63.52 164.24,63.52 164.37,63.65 164.37,64 164.49,64.13 164.99,64.13 165.11,64 165.11,63.24 164.99,63.11 v2(164.74,63.11)
  BOTTOM w0.076: UC1.AL21 123.45,55.4 v2(123.78,55.07)
  BOTTOM w0.102: v2(164.74,63.11) 164.29,62.67 163.8,62.67 163.52,62.95 JDIMM2.175
DDR_B_D51: length 56
  IN3 w0.076: v2(124.43,54.12) 124.43,54.1 124.94,53.58 127.26,53.58 129.22,55.54 129.74,55.54 130.87,56.67 135.9,56.67 136.38,57.15 136.88,57.15
  IN3 w0.102: 136.88,57.15 138.67,57.15 140.75,59.24 149.05,59.24 149.18,59.36 149.18,60.06 149.3,60.19 149.56,60.19 149.68,60.06 149.68,59.36 149.81,59.24 150.06,59.24 150.19,59.36 150.19,60.09 150.29,60.19 150.6,60.19 150.7,60.09 150.7,59.36 150.83,59.24 151.08,59.24 151.21,59.36 151.21,60.09 151.31,60.19 151.61,60.19 151.72,60.09 151.72,59.36 151.84,59.24 152.1,59.24 152.22,59.36 152.22,60.09 152.32,60.19 162.84,60.19 163.68,59.35 167.07,59.35 v2(167.78,60.06)
  BOTTOM w0.076: UC1.AM22 124.1,54.44 v2(124.43,54.12)
  BOTTOM w0.102: JDIMM2.164 168.2,59.65 v2(167.78,60.06)
DDR_B_D52: length 55.2
  IN3 w0.076: v2(125.08,54.12) 125.43,53.76 127.2,53.76 129.15,55.71 129.67,55.71 130.8,56.84 135.83,56.84 136.46,57.46 136.88,57.46
  IN3 w0.102: v2(166.26,60.06) 165.85,59.66 163.81,59.66 162.97,60.49 148.7,60.49 148.6,60.39 148.6,59.64 148.5,59.54 148.19,59.54 148.09,59.64 148.09,60.39 147.99,60.49 147.68,60.49 147.58,60.39 147.58,59.64 147.48,59.54 147.17,59.54 147.07,59.64 147.07,60.39 146.97,60.49 146.67,60.49 146.56,60.39 146.56,59.64 146.46,59.54 146.16,59.54 146.06,59.64 146.06,60.39 145.96,60.49 145.65,60.49 145.55,60.39 145.55,59.64 145.45,59.54 145.14,59.54 145.04,59.64 145.04,59.83 144.91,59.96 144.66,59.96 144.53,59.83 144.53,59.64 144.43,59.54 140.63,59.54 138.54,57.46 136.88,57.46
  BOTTOM w0.076: UC1.AN22 124.75,54.44 v2(125.08,54.12)
  BOTTOM w0.102: JDIMM2.163 165.55,59.35 v2(166.26,60.06)
DDR_B_D53: length 53.7
  IN3 w0.076: 135.82,58.15 135.82,58.03 135.45,57.66 129.43,57.66 128.3,56.53 127.85,56.53 127.2,55.88 127.2,55.59 126.96,55.35 126.09,55.35 125.82,55.07 v2(125.73,55.07)
  IN3 w0.102: 135.82,58.15 135.93,58.26 137.03,59.35 137.63,59.35 140.98,62.71 151.46,62.71 151.58,62.83 151.58,63.25 151.85,63.52 154.75,63.52 154.88,63.39 154.88,62.83 155.01,62.71 155.26,62.71 155.39,62.83 155.39,63.39 155.51,63.52 155.77,63.52 155.9,63.39 155.9,62.83 156.02,62.71 156.28,62.71 156.4,62.83 156.4,63.39 156.53,63.52 156.78,63.52 156.91,63.39 156.91,62.83 157.04,62.71 157.3,62.71 157.43,62.83 157.43,63.39 157.55,63.52 157.81,63.52 157.93,63.39 157.93,62.83 158.06,62.71 165.69,62.71 166.09,63.11 v2(166.26,63.11)
  BOTTOM w0.076: v2(125.73,55.07) 125.4,55.4 UC1.AP21
  BOTTOM w0.102: JDIMM2.177 165.82,63.55 v2(166.26,63.11)
DDR_B_D54: length 56.2
  IN3 w0.076: 134.75,58.72 134.66,58.63 132.78,58.63 132.77,58.61 129.81,58.61 128.22,57.02 127.87,57.02 126.87,56.01 126.87,55.73 126.82,55.68 125.96,55.68 125.93,55.65 123.71,55.65 123.13,55.07 v2(123.13,55.04)
  IN3 w0.102: v2(169.31,63.11) 168.85,63.57 167.92,63.57 167.82,63.67 167.82,64.33 167.72,64.43 167.41,64.43 167.31,64.33 167.31,63.67 167.21,63.57 166.91,63.57 166.81,63.67 166.81,64.33 166.7,64.43 166.4,64.43 166.3,64.33 166.3,63.67 166.2,63.57 165.89,63.57 165.79,63.67 165.79,64.33 165.69,64.43 164.37,64.43 164.06,64.13 151.6,64.13 150.96,63.49 140.91,63.49 137.38,59.97 136.78,59.97 135.53,58.72 134.75,58.72
  BOTTOM w0.076: UC1.AK21 122.8,55.37 v2(123.13,55.04)
  BOTTOM w0.102: JDIMM2.176 169.45,63.25 v2(169.31,63.11)
DDR_B_D55: length 56.5
  IN3 w0.076: 136.88,56.85 136.31,56.85 135.97,56.51 130.93,56.51 129.81,55.38 129.28,55.38 127.33,53.42 124.87,53.42 124.6,53.69 123.49,53.69 123.13,54.05 v2(123.13,54.12)
  IN3 w0.102: 136.88,56.85 138.8,56.85 140.88,58.93 152.75,58.93 152.85,59.03 152.85,59.25 152.97,59.38 153.23,59.38 153.36,59.25 153.36,59.03 153.46,58.93 153.76,58.93 153.86,59.03 153.86,59.78 153.96,59.88 154.27,59.88 154.37,59.78 154.37,59.03 154.47,58.93 154.78,58.93 154.88,59.03 154.88,59.78 154.98,59.88 155.29,59.88 155.39,59.78 155.39,59.03 155.49,58.93 155.79,58.93 155.9,59.03 155.9,59.78 156,59.88 160.23,59.88 161.06,59.05 168.29,59.05 v2(169.31,60.06)
  BOTTOM w0.076: v2(123.13,54.12) 122.8,54.44 UC1.AK22
  BOTTOM w0.102: JDIMM2.166 169.5,60.25 v2(169.31,60.06)
DDR_B_D56: length 53.4
  IN3 w0.076: v2(125.08,56.02) 125.45,56.39 126.78,56.39 127.74,57.35 128.08,57.35 129.68,58.94 132.63,58.94 132.65,58.97 133.15,58.97
  IN3 w0.102: v2(167.78,65.65) 167.38,65.25 163.81,65.25 163.44,65.62 160.66,65.62 160.56,65.51 160.56,65.07 160.43,64.94 160.18,64.94 160.05,65.07 160.05,65.51 159.95,65.62 159.64,65.62 159.54,65.51 159.54,65.07 159.41,64.94 159.16,64.94 159.03,65.07 159.03,65.51 158.93,65.62 158.63,65.62 158.52,65.51 158.52,65.07 158.4,64.94 151.26,64.94 150.62,64.3 140.57,64.3 137.04,60.78 136.86,60.78 135.89,59.8 134.28,59.8 133.45,58.97 133.15,58.97
  BOTTOM w0.076: UC1.AN20 124.75,56.35 v2(125.08,56.02)
  BOTTOM w0.102: v2(167.78,65.65) 168.99,64.45 JDIMM2.180
DDR_B_D57: length 52.4
  IN3 w0.076: 133.91,59 133.7,58.79 132.71,58.79 132.7,58.78 129.74,58.78 128.15,57.19 127.8,57.19 126.65,56.04 v2(126.38,56.04)
  IN3 w0.102: v2(169.31,65.65) 169.31,65.07 169.18,64.94 164.07,64.94 163.94,64.81 163.94,64.76 163.81,64.64 163.54,64.64 163.41,64.76 163.41,65.21 163.31,65.31 163.01,65.31 162.9,65.21 162.9,64.76 162.78,64.64 162.52,64.64 162.4,64.76 162.4,65.21 162.29,65.31 161.99,65.31 161.89,65.21 161.89,64.76 161.76,64.64 161.51,64.64 161.38,64.76 161.38,64.91 161.25,65.04 161,65.04 160.87,64.91 160.87,64.76 160.75,64.64 151.39,64.64 150.75,64 140.7,64 137.17,60.47 136.94,60.47 135.46,59 133.91,59
  BOTTOM w0.076: UC1.AR20 126.05,56.36 126.38,56.04 v2(126.38,56.04)
  BOTTOM w0.102: JDIMM2.182 169.61,65.05 169.31,65.35 v2(169.31,65.65)
DDR_B_D58: length 54.6
  IN3 w0.076: 133.69,62.41 133.48,62.2 132.38,62.2 130.45,60.27 129.13,60.27 128.38,59.52 127.22,59.52 126.93,59.24 126.93,58.5 126.75,58.32 124.32,58.32 123.03,57.04 v2(123.03,56.89)
  IN3 w0.102: v2(166.26,69.08) 165.55,69.79 161.15,69.79 161.07,69.71 160.55,69.71 159.81,68.98 156.59,68.98 155.33,67.71 149.21,67.71 148.56,67.06 139.42,67.06 135.6,63.24 133.8,63.24 133.69,63.12 133.69,62.41
  BOTTOM w0.076: v2(123.03,56.89) 123.03,57.13 UC1.AK18
  BOTTOM w0.102: v2(166.26,69.08) 164.93,67.75 JDIMM2.191
DDR_B_D59: length 53.8
  IN3 w0.076: 133.88,62.88 133.88,62.35 133.56,62.03 132.45,62.03 130.52,60.1 129.2,60.1 128.43,59.33 127.26,59.33 127.1,59.17 127.1,58.44 126.82,58.16 124.39,58.16 123.61,57.38 v2(123.61,56.89)
  IN3 w0.102: v2(164.74,69.08) 164.74,69.42 164.67,69.49 163.49,69.49 163.39,69.39 163.39,68.77 163.26,68.65 163.01,68.65 162.88,68.77 162.88,69.39 162.78,69.49 162.47,69.49 162.37,69.39 162.37,68.77 162.24,68.65 161.99,68.65 161.86,68.77 161.86,69.39 161.76,69.49 161.28,69.49 161.2,69.41 161.2,69.31 161.07,69.18 160.45,69.18 160.32,69.05 160.32,68.77 160.22,68.67 156.72,68.67 155.46,67.41 149.33,67.41 148.68,66.76 139.55,66.76 135.84,63.05 134.05,63.05 133.88,62.88
  BOTTOM w0.076: v2(123.61,56.89) 123.45,57.04 UC1.AL18
  BOTTOM w0.102: JDIMM2.193 164.01,68.35 v2(164.74,69.08)
DDR_B_D60: length 55.1
  IN3 w0.076: 133.75,61.87 132.52,61.87 130.59,59.93 129.26,59.93 127.67,58.34 127.32,58.34 126.97,57.99 124.71,57.99 123.96,57.25 123.96,56.62 123.77,56.43 123.53,56.43 v2(123.13,56.02)
  IN3 w0.102: v2(167.78,69.08) 167.38,68.67 165.79,68.67 165.45,68.34 165.29,68.34 165.16,68.47 165.16,68.55 165.03,68.68 164.78,68.68 164.65,68.55 164.65,68.47 164.52,68.34 164.26,68.34 164.12,68.48 164.12,68.57 164.02,68.67 163.72,68.67 163.62,68.57 163.62,68.44 163.51,68.34 156.82,68.34 155.58,67.1 149.46,67.1 148.81,66.45 139.67,66.45 135.76,62.54 135.2,62.54 134.96,62.3 134.19,62.3 133.75,61.87
  BOTTOM w0.076: UC1.AK20 122.8,56.35 v2(123.13,56.02)
  BOTTOM w0.102: v2(167.78,69.08) 168.82,68.05 JDIMM2.192
DDR_B_D61: length 53.9
  IN3 w0.076: 133.17,61.1 131.99,61.1 130.66,59.77 129.33,59.77 127.74,58.18 127.39,58.18 127.04,57.83 124.78,57.83 124.13,57.18 124.13,56.32 v2(124.43,56.02)
  IN3 w0.102: 133.17,61.1 134.2,61.1 135.32,62.22 135.87,62.22 139.8,66.15 148.94,66.15 149.59,66.8 155.71,66.8 156.94,68.02 165.71,68.02 166,68.31 169.13,68.31 169.31,68.49 v2(169.31,69.08)
  BOTTOM w0.076: UC1.AM20 124.1,56.35 v2(124.43,56.02)
  BOTTOM w0.102: v2(169.31,69.08) 169.74,68.65 JDIMM2.194
DDR_B_D62: length 51
  IN3 w0.076: 132.73,59.27 132.56,59.11 129.61,59.11 128.01,57.52 127.67,57.52 127.13,56.97 v2(126.38,56.97)
  IN3 w0.102: 132.73,59.27 133.48,59.27 134.27,60.06 135.88,60.06 140.43,64.61 150.49,64.61 151.13,65.25 158.09,65.25 158.22,65.37 158.22,66.34 158.35,66.47 158.6,66.47 158.73,66.34 158.73,66.18 158.83,66.08 159.13,66.08 159.24,66.18 159.24,66.34 159.36,66.47 159.62,66.47 159.74,66.34 159.74,66.05 159.87,65.92 160.12,65.92 160.25,66.05 160.25,66.34 160.38,66.47 160.63,66.47 160.76,66.34 160.76,66.05 160.89,65.92 161.14,65.92 161.27,66.05 161.27,66.34 161.39,66.47 161.65,66.47 161.78,66.34 161.78,66.05 161.9,65.92 162.16,65.92 162.28,66.05 162.28,66.34 162.41,66.47 162.66,66.47 162.79,66.34 162.79,66.05 162.92,65.92 163.17,65.92 163.3,66.05 163.3,66.34 163.43,66.47 163.68,66.47 163.81,66.34 163.81,66.19 163.93,66.06 164.19,66.06 164.32,66.19 164.32,66.34 164.44,66.47 164.72,66.47 164.85,66.34 164.85,65.76 v2(164.74,65.65)
  BOTTOM w0.076: v2(126.38,56.97) 126.05,57.3 UC1.AR18
  BOTTOM w0.102: v2(164.74,65.65) 164.23,65.14 163.82,65.14 163.61,65.35 JDIMM2.183
DDR_B_D63: length 51.9
  IN3 w0.076: v2(125.73,56.97) 126.08,57.33 127.25,57.33 127.6,57.68 127.95,57.68 129.54,59.27 132.41,59.27 132.6,59.46 133.24,59.46
  IN3 w0.102: v2(166.26,65.65) 166.26,66.56 166.05,66.78 157.88,66.78 157.78,66.67 157.78,65.65 157.67,65.55 157.37,65.55 157.27,65.65 157.27,66.11 157.14,66.24 156.88,66.24 156.76,66.11 156.76,65.65 156.66,65.55 151.01,65.55 150.37,64.91 140.3,64.91 135.64,60.25 134.03,60.25 133.24,59.46
  BOTTOM w0.076: v2(125.73,56.97) 125.4,57.3 UC1.AP18
  BOTTOM w0.102: JDIMM2.181 165.36,64.75 v2(166.26,65.65)
DDR_B_DQS0: length 54.7
  IN3 w0.076: v2(125.08,31.36) 124.97,31.24 124.97,30.6 125.48,30.08 127.33,30.08 127.6,29.82 128.61,29.82 128.62,29.83 128.81,29.83 132.57,26.06 132.59,26.06 132.61,26.05
  IN3 w0.102: 132.61,26.05 137.82,20.84 156.06,20.84 156.5,20.39 156.62,20.39 156.95,20.71 157.32,20.71 157.65,20.39 157.65,20.01 157.36,19.72 157.36,19.51 159.99,16.88 161.4,16.88 161.9,16.39 164.06,16.39 164.67,17 165.65,17 165.89,16.76 165.89,16.18 v2(166.08,15.98)
  BOTTOM w0.076: UC1.AN58 124.75,31.68 v2(125.08,31.36)
  BOTTOM w0.102: v2(166.08,15.98) 165.81,16.25 165.81,16.54 165.52,16.83 163.97,16.83 163.94,16.8 163.77,16.8 163.72,16.75 JDIMM2.29
DDR_B_DQS1: length 55.4
  IN3 w0.076: v2(125.08,33.26) 124.88,33.26 124.76,33.38 124.76,33.55 124.88,33.67 126.89,33.67 127.8,32.76 128.66,32.76 129.55,31.86 130.32,31.86 134.49,27.69 135.07,27.69 135.08,27.68 135.22,27.68 135.88,27.02 136.5,27.02 137.03,26.5
  IN3 w0.102: 137.03,26.5 137.97,25.56 140.35,25.56 140.49,25.41 140.49,25.13 140.68,24.94 141.2,24.94 141.4,25.14 141.4,25.55 141.47,25.62 141.85,25.62 141.94,25.53 141.94,25.14 142.14,24.94 142.66,24.94 142.85,25.13 142.85,25.55 142.92,25.62 143.25,25.62 143.34,25.53 143.34,25.13 143.54,24.93 144.17,24.93 144.85,24.25 159.15,24.25 160.47,22.93 161.54,22.93 162.64,21.83 163.85,21.83 164.36,22.34 165.86,22.34 165.98,22.22 165.98,21.68 165.86,21.56 v2(165.63,21.56)
  BOTTOM w0.076: v2(125.08,33.26) 124.75,33.59 UC1.AN55
  BOTTOM w0.102: v2(165.63,21.56) 165.88,21.56 166.01,21.44 166.01,21.3 165.81,21.1 164.7,21.1 164.45,21.35 164.45,21.7 164.22,21.92 163.83,21.92 163.6,22.15 JDIMM2.47
DDR_B_DQS2: length 78.8
  IN3 w0.076: v2(123.73,41.78) 123.73,41.63 123.59,41.49 123.3,41.49 123.22,41.42 122.86,41.42 121.04,39.6 121.04,32.41 120.43,31.8 120.43,31.22 120.6,31.06
  IN3 w0.102: 120.6,31.06 120.6,28.98 120.95,28.63 122.91,28.63 125.31,26.22 128.56,22.98 130.24,22.98 136.99,16.23 155.29,16.23 160.41,11.1 162.42,11.1 162.54,10.99 162.54,10.11 162.78,9.87 163.32,9.87 163.55,10.09 163.55,11 163.67,11.13 164,11.13 164.12,11.01 164.12,10.12 164.39,9.86 164.91,9.86 165.16,10.11 165.16,11.1 165.35,11.29 166.9,11.29 167.03,11.16 167.03,10.65 v2(166.84,10.46)
  BOTTOM w0.076: UC1.AL42 123.45,42.05 v2(123.73,41.78)
  BOTTOM w0.102: JDIMM2.12 169.71,11.65 169.48,11.42 167.47,11.42 167.07,11.02 167.07,10.68 166.86,10.46 v2(166.84,10.46)
DDR_B_DQS3: length 54.5
  IN3 w0.076: v2(123.75,37.02) 123.75,37.31 123.85,37.41 124.5,37.41 125.43,36.48 126.47,36.48 127.22,35.73 128.72,35.73 129.42,35.03 131.26,35.03 136.07,30.22 137.03,30.22
  IN3 w0.102: v2(167.08,27.17) 167.08,27.17 167.24,27.32 167.24,27.58 166.99,27.82 151.64,27.82 151.43,28.03 151.43,28.41 151.35,28.49 150.94,28.49 150.87,28.42 150.87,28.05 150.65,27.83 150.09,27.83 149.87,28.05 149.87,28.39 149.7,28.57 145.59,28.57 145.14,29.01 139.47,29.01 138.26,30.22 137.03,30.22
  BOTTOM w0.076: v2(123.75,37.02) 123.45,37.31 UC1.AL49
  BOTTOM w0.102: JDIMM2.64 169.44,27.25 168.75,27.93 167.61,27.93 167.37,27.69 167.37,27.46 v2(167.08,27.17)
DDR_B_DQS4: length 54.2
  IN3 w0.076: 136.88,51.04 136.87,51.04 136.86,51.06 136.41,51.06 136.34,50.98 131.05,50.98 130.23,50.16 129.3,50.16 128.98,49.83 127.76,49.83 127.25,49.32 125.66,49.32 125.25,48.91 124.84,48.91 124.5,49.25 124.5,49.48 123.98,49.99 123.98,50.18 v2(123.79,50.36)
  IN3 w0.102: 136.88,51.04 141.67,51.04 142.33,51.71 158.62,51.71 159.31,51.03 163.43,51.03 164.44,50.02 165.44,50.02 166.22,49.23 167.32,49.23 167.57,49.48 167.57,49.94 167.37,50.14 166.63,50.14 166.5,50.28 166.5,50.57 v2(166.64,50.72)
  BOTTOM w0.076: UC1.AM28 124.1,50.7 123.79,50.39 v2(123.79,50.36)
  BOTTOM w0.102: JDIMM2.137 165.99,51.55 166.35,51.19 166.35,51.01 v2(166.64,50.72)
DDR_B_DQS5: length 52.1
  IN3 w0.076: v2(124.43,52.32) 124.53,52.21 124.53,51.91 124.69,51.76 127.07,51.76 129.1,53.79 130.12,53.79 130.53,54.19 130.53,54.53 130.93,54.93 136.57,54.93 136.79,54.71 137.01,54.71 137.03,54.7
  IN3 w0.102: v2(168.17,56.29) 167.99,56.12 167.99,55.97 167.99,55.93 167.71,55.65 163.57,55.65 163.27,55.34 160.1,55.34 158.66,56.78 141.89,56.78 139.81,54.7 137.03,54.7
  BOTTOM w0.076: UC1.AM25 124.1,52.64 v2(124.43,52.32)
  BOTTOM w0.102: JDIMM2.154 169.85,56.65 169.52,56.31 169.52,56.27 168.99,55.74 167.99,55.74 167.93,55.81 167.93,56.03 168.16,56.25 v2(168.17,56.29)
DDR_B_DQS6: length 54.1
  IN3 w0.076: 136.67,58.16 136.65,58.16 135.66,57.17 129.64,57.17 128.51,56.04 128.06,56.04 127.69,55.67 127.69,54.88 127.28,54.47 124.83,54.47 124.61,54.69 124.61,54.89 v2(124.43,55.07)
  IN3 w0.102: 136.67,58.16 136.84,58.16 137.01,58.33 138.06,58.33 141.4,61.66 145.53,61.66 145.81,61.38 146.77,61.38 147.07,61.68 147.85,61.68 148.15,61.38 149.05,61.38 149.34,61.66 152.04,61.66 152.29,61.4 152.78,61.4 153.04,61.66 153.35,61.66 153.62,61.4 154.17,61.4 154.45,61.68 154.74,61.68 155.01,61.4 155.57,61.4 155.81,61.63 156.17,61.63 156.41,61.4 156.96,61.4 157.22,61.65 157.55,61.65 157.81,61.4 158.36,61.4 158.62,61.65 158.95,61.65 159.21,61.4 159.76,61.4 160.02,61.66 160.34,61.66 160.6,61.4 161.15,61.4 161.41,61.65 161.74,61.65 162,61.4 164.44,61.4 165.08,60.76 166.19,60.76 166.47,61.03 166.47,61.41 v2(166.64,61.59)
  BOTTOM w0.076: UC1.AM21 124.1,55.4 v2(124.43,55.07)
  BOTTOM w0.102: v2(166.64,61.59) 166.44,61.79 166.44,61.89 166.04,62.3 164.88,62.3 164.33,61.75 JDIMM2.171
DDR_B_DQS7: length 52.9
  IN3 w0.076: v2(124.49,56.97) 124.67,57.15 124.67,57.4 124.94,57.66 127.11,57.66 127.46,58.01 127.81,58.01 129.4,59.6 130.73,59.6 132.04,60.92 133.29,60.92 133.33,60.87 133.35,60.87
  IN3 w0.102: v2(168.17,67.18) 168,67.34 168,67.63 167.83,67.79 166.35,67.79 166.07,67.51 157.14,67.51 155.92,66.29 149.96,66.29 149.3,65.63 140,65.63 136.2,61.83 135.19,61.83 134.24,60.87 133.35,60.87
  BOTTOM w0.076: v2(124.49,56.97) 124.1,57.36 UC1.AM18
  BOTTOM w0.102: v2(168.17,67.18) 167.9,66.91 167.9,66.71 167.97,66.64 169.36,66.64 169.57,66.85 JDIMM2.188
DDR_B_DQS#0: length 54.9
  IN3 w0.076: v2(124.43,31.36) 124.58,31.36 124.8,31.13 124.8,30.53 125.41,29.92 127.26,29.92 127.53,29.65 128.61,29.65 128.62,29.64 128.73,29.64 132.45,25.93 132.45,25.91 132.46,25.9
  IN3 w0.102: v2(165.32,15.98) 165.53,15.98 165.68,16.13 165.68,16.67 165.56,16.79 164.76,16.79 164.15,16.18 161.81,16.18 161.32,16.67 159.9,16.67 157.15,19.43 157.15,19.81 157.44,20.1 157.44,20.3 157.24,20.51 157.03,20.51 156.71,20.18 156.42,20.18 155.97,20.63 137.73,20.63 132.46,25.9
  BOTTOM w0.076: UC1.AM58 124.1,31.68 v2(124.43,31.36)
  BOTTOM w0.102: v2(165.32,15.98) 165.61,16.28 165.61,16.46 165.44,16.63 164.06,16.63 163.58,16.15 JDIMM2.27
DDR_B_DQS#1: length 55.7
  IN3 w0.076: v2(124.43,33.26) 124.6,33.43 124.6,33.62 124.81,33.84 126.95,33.84 127.87,32.92 128.73,32.92 129.62,32.03 130.39,32.03 134.56,27.85 135.07,27.85 135.08,27.86 135.3,27.86 135.96,27.21 136.61,27.21 137.03,26.79
  IN3 w0.102: 137.03,26.79 138.05,25.77 140.43,25.77 140.7,25.5 140.7,25.22 140.76,25.15 141.12,25.15 141.19,25.22 141.19,25.63 141.39,25.83 141.94,25.83 142.15,25.62 142.15,25.22 142.22,25.15 142.58,25.15 142.64,25.22 142.64,25.64 142.83,25.83 143.34,25.83 143.55,25.61 143.55,25.22 143.63,25.14 144.25,25.14 144.94,24.46 159.24,24.46 160.56,23.14 161.63,23.14 162.72,22.04 163.76,22.04 164.27,22.55 165.95,22.55 166.19,22.31 166.19,21.77 v2(166.39,21.56)
  BOTTOM w0.076: UC1.AM55 124.1,33.59 v2(124.43,33.26)
  BOTTOM w0.102: JDIMM2.45 163.61,21.55 163.78,21.72 164.14,21.72 164.25,21.61 164.25,21.27 164.62,20.9 165.89,20.9 166.21,21.21 166.21,21.38 v2(166.39,21.56)
DDR_B_DQS#2: length 79
  IN3 w0.076: v2(123.65,40.83) 123.88,41.05 123.88,41.25 123.8,41.33 123.37,41.33 123.29,41.26 122.93,41.26 121.2,39.53 121.2,32.34 120.6,31.74 120.6,31.31 120.77,31.13 120.77,31.08 120.79,31.06 120.79,31.06
  IN3 w0.102: 120.79,31.06 120.79,29.06 121.03,28.82 122.98,28.82 125.77,26.03 125.8,26.03 128.64,23.19 130.33,23.19 137.08,16.44 155.37,16.44 160.5,11.31 162.51,11.31 162.75,11.07 162.75,10.2 162.87,10.07 163.23,10.07 163.34,10.18 163.34,11.09 163.59,11.34 164.09,11.34 164.33,11.1 164.33,10.21 164.47,10.07 164.83,10.07 164.96,10.19 164.96,11.19 165.26,11.5 166.99,11.5 167.24,11.25 167.24,10.6 167.37,10.46 v2(167.6,10.46)
  BOTTOM w0.076: UC1.AL43 123.65,41.12 v2(123.65,40.83)
  BOTTOM w0.102: JDIMM2.10 169.67,11.05 169.5,11.22 167.56,11.22 167.27,10.93 167.27,10.59 167.4,10.46 v2(167.6,10.46)
DDR_B_DQS#3: length 54.9
  IN3 w0.076: v2(123.78,37.97) 123.78,37.68 123.88,37.57 124.57,37.57 125.5,36.64 126.53,36.64 127.29,35.89 128.79,35.89 129.49,35.2 131.32,35.2 136.09,30.43 136.56,30.43
  IN3 w0.102: 136.56,30.43 138.35,30.43 139.56,29.22 145.23,29.22 145.67,28.77 149.78,28.77 150.08,28.48 150.08,28.14 150.18,28.04 150.56,28.04 150.66,28.14 150.66,28.51 150.85,28.7 151.44,28.7 151.64,28.49 151.64,28.11 151.72,28.03 167.08,28.03 167.45,27.66 167.45,27.36 167.64,27.17 v2(167.84,27.17)
  BOTTOM w0.076: UC1.AL48 123.45,38.29 v2(123.78,37.97)
  BOTTOM w0.102: JDIMM2.62 169.65,26.65 169.52,26.79 169.52,26.9 169.37,27.05 169.35,27.05 168.67,27.73 167.69,27.73 167.57,27.61 167.57,27.43 v2(167.84,27.17)
DDR_B_DQS#4: length 54.2
  IN3 w0.076: v2(124.44,50.36) 124.37,50.44 124.28,50.44 124.14,50.3 124.14,50.06 124.66,49.54 124.66,49.32 124.9,49.07 125.18,49.07 125.59,49.48 127.18,49.48 127.7,50 128.91,50 129.23,50.32 130.16,50.32 130.98,51.15 136.27,51.15 136.36,51.23 137.01,51.23 137.03,51.25
  IN3 w0.102: v2(165.88,50.72) 165.97,50.8 166.09,50.8 166.24,50.66 166.24,50.55 166.29,50.5 166.29,50.19 166.55,49.94 167.28,49.94 167.36,49.86 167.36,49.56 167.23,49.44 166.31,49.44 165.52,50.22 164.52,50.22 163.51,51.24 159.39,51.24 158.71,51.92 142.24,51.92 141.58,51.25 137.03,51.25
  BOTTOM w0.076: v2(124.44,50.36) 124.58,50.36 124.75,50.54 UC1.AN28
  BOTTOM w0.102: v2(165.88,50.72) 166.15,50.99 166.15,51.1 165.9,51.35 164.04,51.35 163.93,51.24 163.93,51.04 163.83,50.95 JDIMM2.135
DDR_B_DQS#5: length 52.2
  IN3 w0.076: v2(125.08,52.32) 124.93,52.32 124.7,52.09 124.7,51.98 124.75,51.92 127,51.92 129.03,53.95 130.05,53.95 130.36,54.26 130.36,54.59 130.86,55.09 136.68,55.09 136.87,54.89 137.01,54.89 137.03,54.91
  IN3 w0.102: v2(167.41,56.29) 167.59,56.29 167.78,56.1 167.78,56.06 167.78,56.02 167.62,55.85 163.48,55.85 163.18,55.55 160.18,55.55 158.75,56.98 141.8,56.98 139.73,54.91 137.03,54.91 137.03,54.91
  BOTTOM w0.076: v2(125.08,52.32) 125.08,52.61 124.98,52.71 UC1.AN25
  BOTTOM w0.102: JDIMM2.152 169.59,56.05 169.08,55.54 167.91,55.54 167.73,55.72 167.73,56.01 167.48,56.25 v2(167.41,56.29)
DDR_B_DQS#6: length 54.3
  IN3 w0.076: 136.67,58.35 136.67,58.35 136.66,58.35 136.65,58.33 136.6,58.33 135.6,57.33 129.57,57.33 128.44,56.2 127.99,56.2 127.53,55.74 127.53,54.95 127.21,54.64 124.89,54.64 124.77,54.76 124.77,54.98 124.92,55.13 125.01,55.13 v2(125.08,55.07)
  IN3 w0.102: v2(165.88,61.59) 166.12,61.59 166.26,61.45 166.26,61.12 166.1,60.96 165.17,60.96 164.53,61.6 162.09,61.6 161.83,61.86 161.33,61.86 161.07,61.6 160.69,61.6 160.42,61.87 159.94,61.87 159.67,61.6 159.29,61.6 159.03,61.86 158.53,61.86 158.27,61.6 157.9,61.6 157.64,61.86 157.13,61.86 156.88,61.6 156.5,61.6 156.26,61.84 155.72,61.84 155.48,61.6 155.1,61.6 154.82,61.88 154.36,61.88 154.08,61.6 153.7,61.6 153.44,61.87 152.95,61.87 152.69,61.61 152.38,61.61 152.12,61.87 149.25,61.87 148.97,61.59 148.23,61.59 147.93,61.89 146.98,61.89 146.68,61.59 145.9,61.59 145.61,61.87 141.31,61.87 137.98,58.54 136.92,58.54 136.73,58.34 136.68,58.34 136.67,58.35
  BOTTOM w0.076: UC1.AN21 124.75,55.4 v2(125.08,55.07)
  BOTTOM w0.102: v2(165.88,61.59) 165.98,61.48 166.09,61.48 166.24,61.63 166.24,61.81 165.95,62.09 164.97,62.09 164.42,61.55 163.8,61.55 163.71,61.46 163.71,61.24 163.62,61.15 JDIMM2.169
DDR_B_DQS#7: length 53
  IN3 w0.076: 133.34,60.68 133.35,60.69 ; 133.29,60.68 133.22,60.75 132.11,60.75 130.79,59.44 129.47,59.44 127.88,57.85 127.53,57.85 127.18,57.5 125,57.5 124.84,57.33 124.84,57.07 124.93,56.97 v2(125.14,56.97)
  IN3 w0.102: 133.35,60.69 134.35,60.69 135.3,61.64 136.3,61.64 140.09,65.42 149.39,65.42 150.05,66.08 156.01,66.08 157.22,67.3 166.15,67.3 166.44,67.58 167.75,67.58 167.79,67.54 167.79,67.36 167.61,67.18 v2(167.4,67.18) ; 133.29,60.68 133.34,60.68
  BOTTOM w0.076: UC1.AN18 125.14,56.98 v2(125.14,56.97)
  BOTTOM w0.102: v2(167.4,67.18) 167.69,66.89 167.69,66.63 167.88,66.44 169.43,66.44 169.62,66.25 JDIMM2.186
DDR_B_MA0: length 47.4
  IN3 w0.076: 134.63,43.02 134.36,42.75 126.79,42.75 126.59,42.96 126.06,42.96 v2(125.77,42.66)
  IN3 w0.152: v2(169.33,39.97) 168.87,40.43 161.9,40.43 161.64,40.17 145.44,40.17 142.58,43.02 134.63,43.02
  BOTTOM w0.076: v2(125.77,42.66) 125.4,43.03 UC1.AP40
  BOTTOM w0.152: JDIMM2.98 169.45,39.85 v2(169.33,39.97)
DDR_B_MA1: length 47.6
  IN3 w0.076: v2(126.44,42.6) 126.45,42.59 134.95,42.59
  IN3 w0.152: v2(164.03,39.98) 162.01,39.98 161.83,39.8 145.28,39.8 143.74,41.35 142.87,41.35 142.71,41.51 142.71,42.37 142.58,42.5 142.18,42.5 142.05,42.37 142.05,41.47 141.92,41.35 141.52,41.35 141.39,41.47 141.39,42.53 141.26,42.65 140.86,42.65 140.73,42.53 140.73,41.47 140.6,41.35 140.2,41.35 140.07,41.47 140.07,42.53 139.94,42.65 139.54,42.65 139.41,42.53 139.41,41.9 139.28,41.78 138.88,41.78 138.75,41.9 138.75,42.53 138.62,42.65 135.01,42.65 134.95,42.59
  BOTTOM w0.076: v2(126.44,42.6) 126.44,42.6 126.05,42.99 UC1.AR40
  BOTTOM w0.152: JDIMM2.97 163.6,39.55 v2(164.03,39.98)
DDR_B_MA2: length 50.1
  IN3 w0.152: v2(167.93,39.97) 168.12,39.79 168.12,38.91 167.99,38.78 167.68,38.78 167.28,39.18 163.12,39.18 162.05,38.12 161.36,38.12 161.15,38.33 159.91,38.33 159.79,38.45 159.79,38.94 159.66,39.06 144.98,39.06 143.43,40.61 139,40.61 138.51,41.1 136.62,41.1 136.22,41.51 126.76,41.51 126.59,41.34 125.8,41.34 125.68,41.47 v2(125.68,41.78)
  BOTTOM w0.076: v2(125.68,41.78) 125.4,42.05 UC1.AP42
  BOTTOM w0.152: JDIMM2.96 168.66,39.25 v2(167.93,39.97)
DDR_B_MA3: length 48.6
  IN3 w0.076: v2(126.33,41.78) 126.36,41.78 127.01,42.42 132.72,42.42 132.92,42.23
  IN3 w0.152: v2(165.55,39.98) 165.55,39.68 165.43,39.55 162.26,39.55 162.14,39.42 162.14,38.72 162.01,38.59 161.6,38.59 161.48,38.72 161.48,39.31 161.35,39.43 160.94,39.43 160.82,39.31 160.82,38.82 160.69,38.7 160.28,38.7 160.16,38.82 160.16,39.31 160.03,39.43 145.13,39.43 143.59,40.98 139.15,40.98 138.38,41.75 138.38,42.1 138.25,42.23 135.89,42.23 135.63,41.98 133.17,41.98 132.92,42.23
  BOTTOM w0.076: v2(126.33,41.78) 126.05,42.05 UC1.AR42
  BOTTOM w0.152: JDIMM2.95 165.17,38.95 165.55,39.33 v2(165.55,39.98)
DDR_B_MA4: length 54.3
  IN3 w0.152: v2(167.18,38.35) 167.18,38.68 167.05,38.81 163.27,38.81 161.92,37.46 159.55,37.46 159.42,37.59 159.42,38.57 159.29,38.7 158.89,38.7 158.76,38.57 158.76,37.59 158.63,37.46 158.22,37.46 158.1,37.59 158.1,38.57 157.97,38.7 157.56,38.7 157.44,38.57 157.44,37.59 157.31,37.46 156.9,37.46 156.78,37.59 156.78,38.57 156.65,38.7 144.83,38.7 143.28,40.24 138.85,40.24 138.35,40.74 136.62,40.74 136.09,41.27 126.9,41.27 126.77,41.14 126.77,40.01 126.64,39.88 v2(126.21,39.88)
  BOTTOM w0.076: v2(126.21,39.88) 126.05,40.04 UC1.AR45
  BOTTOM w0.152: JDIMM2.92 169.62,38.05 168.79,38.88 167.71,38.88 v2(167.18,38.35)
DDR_B_MA5: length 52.5
  IN3 w0.152: v2(125.55,39.88) 125.42,39.75 125.42,39.5 125.55,39.37 126.99,39.37 127.12,39.5 127.12,40.85 127.25,40.97 135.98,40.97 136.58,40.37 138.2,40.37 138.7,39.87 143.13,39.87 144.67,38.33 152.32,38.33 152.45,38.2 152.45,37.22 152.57,37.1 152.98,37.1 153.11,37.22 153.11,38.2 153.23,38.33 153.64,38.33 153.77,38.2 153.77,37.22 153.89,37.1 154.3,37.1 154.43,37.22 154.43,38.2 154.55,38.33 154.96,38.33 155.09,38.2 155.09,37.22 155.21,37.1 155.62,37.1 155.75,37.22 155.75,38.2 155.88,38.33 156.28,38.33 156.41,38.2 156.41,37.22 156.54,37.1 162.07,37.1 163.42,38.44 164.04,38.44 v2(164.13,38.35)
  BOTTOM w0.076: v2(125.55,39.88) 125.4,40.03 UC1.AP45
  BOTTOM w0.152: JDIMM2.91 163.98,37.75 164.13,37.9 v2(164.13,38.35)
DDR_B_MA6: length 57.3
  IN3 w0.076: v2(128.77,38.91) 128.77,38.68 128.9,38.55 129.74,38.55 129.87,38.68 129.87,39.35
  IN3 w0.152: 129.87,39.35 129.87,39.69 129.99,39.82 134.46,39.82 135.15,39.14 142.82,39.14 144.37,37.59 147.62,37.59 147.75,37.46 147.75,36.49 147.87,36.36 162.38,36.36 163.57,37.55 170.4,37.55 170.52,37.68 170.52,38.09 170.4,38.22 169.49,38.22 169.36,38.34 169.36,38.75 169.49,38.88 170.4,38.88 170.52,39.01 170.52,40.45 170.4,40.58 169.89,40.58 169.76,40.45 169.76,39.67 169.63,39.54 168.83,39.54 168.7,39.42 v2(168.7,38.35)
  BOTTOM w0.076: UC1.AW46 128.51,39.17 128.77,38.92 v2(128.77,38.91)
  BOTTOM w0.152: JDIMM2.90 169.6,37.45 v2(168.7,38.35)
DDR_B_MA7: length 56.9
  IN3 w0.152: v2(130.24,38.9) 130.24,39.35 130.43,39.54 134.24,39.54 135.01,38.77 142.67,38.77 144.22,37.22 147.25,37.22 147.38,37.1 147.38,36.12 147.51,35.99 162.53,35.99 163.72,37.18 167.42,37.18 167.55,37.05 167.55,36.54 167.67,36.41 168.08,36.41 168.21,36.54 168.21,37.05 168.34,37.18 170.77,37.18 170.89,37.31 170.89,37.81 171.02,37.94 171.51,37.94 171.64,37.81 171.64,37.42 171.88,37.18 171.88,35.97 171.75,35.84 171.4,35.84 171.27,35.97 171.27,36.35 171.14,36.48 170.77,36.48 170.65,36.35 170.65,35.97 170.52,35.84 170.15,35.84 170.02,35.97 170.02,36.39 169.9,36.52 169.34,36.52 169.21,36.39 169.21,36.06 169.09,35.94 v2(168.7,35.94)
  BOTTOM w0.076: UC1.AY46 129.83,39.32 v2(130.24,38.9)
  BOTTOM w0.152: v2(168.7,35.94) 169.02,36.25 JDIMM2.86
DDR_B_MA8: length 55.9
  IN3 w0.152: v2(129.43,38.91) 129.43,39.23 129.3,39.36 128.72,39.36 128.6,39.49 128.6,39.93 128.72,40.06 131.09,40.06 131.21,40.19 131.21,40.58 131.37,40.73 131.72,40.73 131.87,40.58 131.87,40.25 132.03,40.1 132.95,40.1 133.1,40.25 133.1,40.58 133.25,40.73 133.61,40.73 133.76,40.58 133.76,40.19 133.89,40.06 134.31,40.06 134.44,40.19 134.44,40.53 134.57,40.66 134.92,40.66 135.05,40.53 135.05,39.69 135.25,39.49 136.5,39.49 136.62,39.61 136.62,39.87 136.75,40 138.05,40 138.54,39.5 142.98,39.5 144.52,37.96 147.99,37.96 148.12,37.83 148.12,36.85 148.24,36.73 148.65,36.73 148.78,36.85 148.78,37.83 148.9,37.96 149.31,37.96 149.44,37.83 149.44,36.85 149.56,36.73 149.97,36.73 150.1,36.85 150.1,37.83 150.22,37.96 150.63,37.96 150.76,37.83 150.76,36.85 150.88,36.73 151.29,36.73 151.42,36.85 151.42,37.83 151.54,37.96 151.95,37.96 152.08,37.83 152.08,36.85 152.2,36.73 162.23,36.73 163.42,37.92 165.53,37.92 165.66,38.05 v2(165.66,38.35)
  BOTTOM w0.076: v2(129.43,38.91) 129.16,38.65 UC1.AY47
  BOTTOM w0.152: v2(165.66,38.35) 164.46,37.15 JDIMM2.89
DDR_B_MA9: length 58.5
  IN3 w0.152: v2(164.13,35.94) 164.04,35.94 163.09,34.99 163.09,34.28 162.96,34.15 162.56,34.15 162.43,34.28 162.43,34.76 162.3,34.89 161.9,34.89 161.77,34.76 161.77,34.28 161.64,34.15 161.24,34.15 161.11,34.28 161.11,34.76 160.98,34.89 160.58,34.89 160.45,34.76 160.45,34.28 160.32,34.15 159.92,34.15 159.79,34.28 159.79,34.76 159.66,34.89 159.26,34.89 159.13,34.76 159.13,34.28 159,34.15 158.59,34.15 158.47,34.28 158.47,34.76 158.34,34.89 157.93,34.89 157.81,34.76 157.81,34.28 157.68,34.15 157.27,34.15 157.15,34.28 157.15,34.76 157.02,34.89 156.61,34.89 156.49,34.76 156.49,34.28 156.36,34.15 155.95,34.15 155.83,34.28 155.83,34.76 155.7,34.89 155.29,34.89 155.17,34.76 155.17,34.28 155.04,34.15 154.63,34.15 154.51,34.28 154.51,34.76 154.38,34.89 142.32,34.89 142.19,35.01 142.19,35.5 142.06,35.63 139.67,35.63 139.55,35.75 139.55,37.54 139.42,37.66 139.01,37.66 138.89,37.54 138.89,35.75 138.76,35.63 138.35,35.63 138.23,35.75 138.23,36.94 138.1,37.07 137.69,37.07 137.57,36.94 137.57,35.75 137.44,35.63 137.03,35.63 136.9,35.75 136.9,36.92 136.78,37.05 136.37,37.05 136.24,36.92 136.24,36.36 136.12,36.24 135.71,36.24 135.58,36.36 135.58,36.92 135.46,37.05 134.82,37.05 133.72,38.15 132.14,38.15 131.96,38.33 127.68,38.33 127.48,38.53 v2(127.48,38.88)
  BOTTOM w0.076: UC1.AU46 127.48,39.1 v2(127.48,38.88)
  BOTTOM w0.152: v2(164.13,35.94) 164.13,36.19 164,36.31 163.87,36.31 163.5,35.95 JDIMM2.85
DDR_B_MA10: length 62.1
  IN3 w0.076: v2(122.91,45.09) 122.91,44.82 123.02,44.71 126.05,44.71 126.1,44.76
  IN3 w0.152: 126.1,44.76 126.18,44.85 126.18,45.05 126.31,45.18 126.74,45.18 126.87,45.05 126.87,44.8 127.04,44.62 134.24,44.62 134.71,45.09 135.66,45.09 136.4,45.83 149.65,45.83 149.78,45.7 149.78,42.98 149.91,42.85 150.31,42.85 150.44,42.98 150.44,45.7 150.57,45.83 150.98,45.83 151.1,45.7 151.1,43.57 151.23,43.44 151.64,43.44 151.76,43.57 151.76,45.7 151.89,45.83 152.3,45.83 152.42,45.7 152.42,43.57 152.55,43.44 152.96,43.44 153.08,43.57 153.08,45.7 153.21,45.83 153.62,45.83 153.74,45.7 153.74,42.98 153.87,42.85 159.75,42.85 160.18,43.28 v2(160.28,43.28)
  BOTTOM w0.076: v2(122.91,45.09) 122.8,45.19 UC1.AK36
  BOTTOM w0.152: v2(160.28,43.28) 160.28,42.92 159.86,42.5 159.86,41.79 159.99,41.66 160.5,41.66 160.63,41.79 160.63,42.15 161.02,42.55 JDIMM2.107
DDR_B_MA11: length 59.3
  IN3 w0.152: v2(167.18,35.94) 167.18,36.69 167.05,36.81 163.88,36.81 162.68,35.62 147.14,35.62 147.01,35.75 147.01,36.73 146.88,36.85 146.48,36.85 146.35,36.73 146.35,35.75 146.22,35.62 145.82,35.62 145.69,35.75 145.69,36.73 145.56,36.85 145.16,36.85 145.03,36.73 145.03,35.75 144.9,35.62 144.5,35.62 144.37,35.75 144.37,36.73 144.24,36.85 143.84,36.85 143.71,36.73 143.71,35.75 143.58,35.62 143.05,35.62 142.92,35.75 142.92,37.99 142.8,38.12 142.39,38.12 142.26,37.99 142.26,36.49 142.14,36.36 141.73,36.36 141.6,36.49 141.6,38.27 141.48,38.4 134.97,38.4 134.07,39.3 131.63,39.3 131.48,39.14 v2(131.48,38.88)
  BOTTOM w0.076: UC1.AV47 128.16,38.2 131.02,38.2 131.48,38.66 v2(131.48,38.88)
  BOTTOM w0.152: JDIMM2.84 169.45,35.65 169.33,35.52 169.33,35.07 169.2,34.94 167.31,34.94 167.18,35.07 v2(167.18,35.94)
DDR_B_MA12: length 54.3
  IN3 w0.152: v2(165.66,35.94) 165.91,36.19 165.91,36.32 165.78,36.45 164.03,36.45 162.84,35.25 142.68,35.25 142.56,35.38 142.56,35.87 142.43,36 141.36,36 141.24,36.12 141.24,37.9 141.11,38.03 140.7,38.03 140.58,37.9 140.58,36.12 140.45,36 140.04,36 139.91,36.12 139.91,37.9 139.79,38.03 137.22,38.03 137.09,37.9 137.09,37.62 136.97,37.49 134.72,37.49 134.59,37.62 134.59,38.38 134.46,38.51 133.63,38.51 133.5,38.64 133.5,38.93 133.37,39.06 132.92,39.06 132.79,38.93 132.79,38.64 132.66,38.51 132.23,38.51 132.1,38.64 v2(132.1,38.9)
  BOTTOM w0.076: v2(132.1,38.9) 132.1,38.22 131.92,38.03 127.91,38.03 127.5,38.44 UC1.AU47
  BOTTOM w0.152: v2(165.66,35.94) 166.09,35.5 166.09,34.98 165.81,34.7 165.23,34.7 164.57,35.35 JDIMM2.83
DDR_B_MA13: length 63.1
  IN3 w0.076: 127.23,47.67 126.9,47.34 125.13,47.34 125.06,47.4 123.45,47.4 123.27,47.59 122.07,47.59 121.95,47.46 121.95,45.75 122.07,45.62 122.6,45.62 122.73,45.75 122.73,46.35 122.86,46.47 123.29,46.47 123.41,46.6 123.41,46.85 123.29,46.98 v2(123.1,46.98)
  IN3 w0.152: 127.23,47.67 159.45,47.67 159.57,47.54 159.57,46.02 159.7,45.89 160.11,45.89 160.23,46.02 160.23,47.54 160.36,47.67 160.77,47.67 160.89,47.54 160.89,46.07 161.02,45.94 161.43,45.94 161.55,46.07 161.55,47.52 161.68,47.64 162.09,47.64 162.64,47.09 162.64,46.97 162.21,46.55 162.21,45.45 162.34,45.32 162.75,45.32 162.88,45.45 162.88,46.19 163,46.32 163.41,46.32 163.54,46.19 163.54,45.45 163.66,45.32 163.9,45.32 164.03,45.45 v2(164.03,45.51)
  BOTTOM w0.076: UC1.AK33 122.88,47.56 123.11,47.56 123.17,47.5 123.17,47.06 v2(123.1,46.98)
  BOTTOM w0.152: v2(164.03,45.51) 164.05,45.51 164.5,45.96 164.86,45.96 164.99,46.09 164.99,46.55 164.86,46.68 164.22,46.68 163.7,46.15 JDIMM2.119
DDR_B_MA14: length 59.6
  IN3 w0.152: v2(126.25,38.97) 126.7,38.97 127.58,38.09 131.84,38.09 132.01,37.91 133.5,37.91 136.15,35.26 141.42,35.26 142.16,34.52 154.01,34.52 154.14,34.39 154.14,33.91 154.26,33.79 163.33,33.79 163.46,33.91 163.46,34.73 164.24,35.51 166.21,35.51 166.36,35.35 166.36,34.87 166.48,34.74 166.89,34.74 167.02,34.87 167.02,35.35 167.17,35.51 167.53,35.51 167.68,35.35 167.68,34.92 167.81,34.79 168.21,34.79 168.34,34.92 168.34,35.35 168.47,35.47 171.65,35.47 171.77,35.35 171.77,34.01 171.65,33.89 171.17,33.89 171.04,34.01 171.04,34.65 170.91,34.78 169.21,34.78 v2(168.7,34.27)
  BOTTOM w0.076: v2(126.25,38.97) 126.25,39.22 UC1.AR46
  BOTTOM w0.152: JDIMM2.80 168.89,34.45 v2(168.7,34.27)
DDR_B_MA15: length 60.1
  IN3 w0.076: 130.39,37.28 130.02,37.65 129.49,37.65 129.26,37.42 129.26,37.11 129.04,36.9 127.53,36.9 127.15,37.28 127.15,38.12 126.66,38.61 126.05,38.61 v2(125.69,38.98)
  IN3 w0.152: v2(167.18,34.27) 167.18,33.63 167.31,33.51 169.71,33.51 169.83,33.63 169.83,34.28 169.96,34.41 170.44,34.41 170.57,34.28 170.57,32.93 170.44,32.81 166.97,32.81 166.07,33.71 164.63,33.71 163.78,32.86 140.88,32.86 139.41,34.33 136.12,34.33 133.17,37.28 130.39,37.28
  BOTTOM w0.076: v2(125.69,38.98) 125.4,39.26 UC1.AP46
  BOTTOM w0.152: v2(167.18,34.27) 167.7,33.75 169.41,33.75 169.52,33.85 JDIMM2.78
DDR_B_RAS#: length 62.7
  IN3 w0.076: 132.51,46.07 132.32,45.88 126.68,45.88 126.55,45.75 124.76,45.75 124.43,46.09 v2(124.43,46.09)
  IN3 w0.152: 132.51,46.07 132.59,46.07 132.78,46.26 133.78,46.26 134.45,46.93 157.36,46.93 157.49,46.8 157.49,45.72 157.62,45.6 158.68,45.6 158.81,45.47 158.81,44.71 158.94,44.58 165.73,44.58 166.01,44.3 167.78,44.3 167.91,44.17 167.91,43.94 168.04,43.82 168.44,43.82 168.57,43.94 168.57,44.83 168.7,44.96 169.1,44.96 169.23,44.83 169.23,44.2 169.36,44.07 169.76,44.07 169.89,44.2 169.89,47.11 170.02,47.23 170.42,47.23 170.55,47.11 170.55,42.51 170.42,42.38 169.82,42.38 169.69,42.51 169.69,43.29 169.57,43.41 v2(169.36,43.41)
  BOTTOM w0.076: UC1.AM35 124.1,46.42 v2(124.43,46.09)
  BOTTOM w0.152: JDIMM2.110 169.4,43.45 v2(169.36,43.41)
DDR_B_WE#: length 61.9
  IN3 w0.076: 126.65,44.38 126.49,44.54 122.07,44.54 121.95,44.67 121.95,45.33 122.07,45.46 122.96,45.46 123.09,45.58 v2(123.09,46.07)
  IN3 w0.152: 126.65,44.38 131.96,44.38 132.2,44.14 133.35,44.14 133.6,44.38 134.34,44.38 134.81,44.85 135.76,44.85 136.37,45.46 144,45.46 144.13,45.33 144.13,44.75 144.26,44.62 144.66,44.62 144.79,44.75 144.79,45.33 144.92,45.46 145.32,45.46 145.45,45.33 145.45,44.22 145.58,44.09 145.98,44.09 146.11,44.22 146.11,45.33 146.24,45.46 146.64,45.46 146.77,45.33 146.77,44.89 146.9,44.76 147.31,44.76 147.43,44.89 147.43,45.33 147.56,45.46 147.97,45.46 148.09,45.33 148.09,44.36 148.22,44.23 148.63,44.23 148.75,44.36 148.75,45.33 148.88,45.46 149.29,45.46 149.41,45.33 149.41,43.6 149.29,43.48 148.67,43.48 148.54,43.35 148.54,42.61 148.67,42.48 150.7,42.48 150.82,42.61 150.82,42.95 150.95,43.07 152.85,43.07 152.98,42.95 152.98,42.61 153.11,42.48 159.94,42.48 160.2,42.74 163.36,42.74 v2(164.03,43.41)
  BOTTOM w0.076: UC1.AK35 122.8,46.35 v2(123.09,46.07)
  BOTTOM w0.152: JDIMM2.113 163.89,44.35 164.12,44.58 164.3,44.58 164.66,44.22 164.66,44.04 v2(164.03,43.41)
DDR_CKE0_DIMMA: length 60.2
  IN1 w0.076: v2(127.51,40.49) 127.53,40.49 127.91,40.87 130.87,40.87 132.94,38.8 132.94,37.86 132.98,37.82 132.98,37.23 135.81,34.39 137.03,34.39
  IN1 w0.14: v2(178.73,31.8) 178.31,32.23 169.24,32.23 168.84,31.82 163.74,31.82 162.12,33.44 143.51,33.44 142.56,34.39 137.03,34.39
  BOTTOM w0.076: v2(127.51,40.49) 127.51,40.64 UC1.AU43
  BOTTOM w0.152: JDIMM1.73 178.19,32.35 v2(178.73,31.8)
DDR_CKE1_DIMMA: length 60.8
  IN1 w0.076: 137.03,33.47 136.45,33.47 132.81,37.11 132.81,37.75 132.77,37.79 132.77,38.73 131.38,40.13 129.16,40.13 v2(128.81,40.48)
  IN1 w0.14: v2(180.26,31.8) 179.83,31.38 163.53,31.38 161.91,33 143.34,33 142.87,33.47 137.03,33.47
  BOTTOM w0.076: v2(128.81,40.48) 128.81,40.49 128.51,40.79 UC1.AW43
  BOTTOM w0.152: JDIMM1.74 181.11,32.65 v2(180.26,31.8)
DDR_CKE2_DIMMB: length 45.2
  IN3 w0.152: v2(129.64,37.28) 129.92,37 133.04,37 136.57,33.47 139.44,33.47 140.61,32.3 160.25,32.3 160.73,31.82 161.61,31.82 161.77,31.97 161.77,32.13 161.92,32.29 162.22,32.29 162.38,32.13 162.38,31.97 162.53,31.82 162.83,31.82 162.99,31.97 162.99,32.13 163.14,32.29 163.44,32.29 163.6,32.13 163.6,31.97 163.75,31.82 164.08,31.82 164.27,32.01 164.27,32.56 164.85,33.14 165.5,33.14 165.66,32.99 v2(165.66,32.25)
  BOTTOM w0.076: v2(129.64,37.28) 129.18,37.74 UC1.AY49
  BOTTOM w0.152: v2(165.66,32.25) 165.21,32.69 164.31,32.69 163.97,32.35 JDIMM2.73
DDR_CKE3_DIMMB: length 46.6
  IN3 w0.152: v2(167.18,32.25) 166.25,31.32 160.61,31.32 160.2,31.74 140.38,31.74 139.21,32.91 136.67,32.91 133.04,36.54 v2(132.46,36.54)
  BOTTOM w0.076: UC1.AU50 127.5,36.53 128.26,36.53 128.27,36.52 128.36,36.48 128.41,36.46 128.62,36.46 128.77,36.53 128.9,36.53 129.01,36.48 129.06,36.46 129.96,36.46 130.04,36.54 v2(132.46,36.54)
  BOTTOM w0.152: JDIMM2.74 168.9,32.65 168.8,32.76 167.69,32.76 v2(167.18,32.25)
DDR_CS0_DIMMA#: length 64
  IN1 w0.076: 136.75,47.12 135.59,47.12 135.57,47.11 133.44,47.11 132.57,47.98 127.62,47.98 127.06,48.54 126.31,48.54 125.65,47.88 v2(125.65,46.92)
  IN1 w0.14: v2(181.74,45.49) 181.74,46.23 181.51,46.46 178.14,46.46 177.56,47.03 176.6,47.03 175.43,48.21 171.49,48.21 171.08,47.8 162.86,47.8 162.18,48.48 159.63,48.48 159.21,48.9 145.92,48.9 144.14,47.12 136.75,47.12
  BOTTOM w0.076: UC1.AP33 125.4,47.17 v2(125.65,46.92)
  BOTTOM w0.152: JDIMM1.114 182.58,44.65 v2(181.74,45.49)
DDR_CS1_DIMMA#: length 64.3
  IN1 w0.076: v2(126.46,48.09) 126.74,47.82 132.5,47.82 133.37,46.94 135.47,46.94 135.71,46.7 136.75,46.7
  IN1 w0.14: v2(180.22,45.49) 180.22,45.91 180.09,46.04 177.96,46.04 177.39,46.61 175.73,46.61 175.32,47.03 175.32,47.66 175.19,47.79 174.8,47.79 174.67,47.66 174.67,47.03 174.55,46.9 174.28,46.9 174.15,47.03 174.15,47.66 174.03,47.79 171.66,47.79 171.25,47.38 162.68,47.38 162.01,48.06 159.46,48.06 159.04,48.48 146.09,48.48 144.32,46.7 136.75,46.7
  BOTTOM w0.076: v2(126.46,48.09) 126.16,48.39 UC1.AR32
  BOTTOM w0.152: JDIMM1.121 177.05,46.75 177.67,46.13 179.58,46.13 v2(180.22,45.49)
DDR_CS2_DIMMB#: length 50.7
  IN3 w0.076: 127.15,48.25 126.59,47.69 125.24,47.69 125.2,47.73 124,47.73 v2(123.8,47.93)
  IN3 w0.152: 127.15,48.25 135.89,48.25 136.29,48.66 162.47,48.66 164.23,46.91 168.32,46.91 168.6,46.63 v2(168.6,45.51)
  BOTTOM w0.076: v2(123.8,47.93) 124.1,48.24 UC1.AM32
  BOTTOM w0.152: v2(168.6,45.51) 168.6,44.89 168.84,44.65 JDIMM2.114
DDR_CS3_DIMMB#: length 50.9
  IN3 w0.076: v2(123.23,47.94) 123.6,47.57 125.13,47.57 125.2,47.5 126.69,47.5 127.13,47.95
  IN3 w0.152: 127.13,47.95 136.13,47.95 136.41,48.23 162.29,48.23 164.05,46.47 164.36,46.47 164.5,46.34 164.5,46.1 164.61,45.99 165.05,45.99 165.17,46.12 165.17,46.35 165.3,46.47 165.73,46.47 165.86,46.35 165.86,45.81 v2(165.55,45.51)
  BOTTOM w0.076: v2(123.23,47.94) 122.8,48.37 UC1.AK32
  BOTTOM w0.152: JDIMM2.121 163.51,46.75 163.99,47.23 165.2,47.23 165.55,46.88 v2(165.55,45.51)
DDR_PG_CTRL: length 121.7
  TOP w0.102: v2(190.6,31.68) 190.65,31.68 v1(191.03,32.05) 191.43,32.45 191.43,33.34 R34.2 190.85,34.43 190.79,34.5 U5.2
  IN2 w0.102: v2(190.6,31.68) 190.09,31.17 190.09,16.5 186.73,13.14 186.73,6.09 184.47,3.84 176.71,3.84 175.59,2.72 139.8,2.72 138.85,3.67 130.97,3.67 129.78,4.87 v2(129.78,5.74)
  IN3 w0.102: v2(125.98,18.36) 125.98,17.17 129.78,13.38 v2(129.78,5.74)
  BOTTOM w0.076: UC1.AV61 127.59,29.44 127.52,29.37 127.52,29.1 127.54,29.08 127.54,28.4
  BOTTOM w0.102: v2(125.98,18.36) 125.98,19.82 130.99,24.82 130.99,26.32 129.56,27.75 128.19,27.75 127.54,28.4
DDR_XDP_SMBCLK_R1: length 4.4
  TOP w0.102: JXDP1.53 135.65,13.67 v3(135.29,14.02) 135.04,14.28 133.96,14.28 133.73,14.51 133.73,14.81 RC112.2
DDR_XDP_SMBDAT_R1: length 4.6
  TOP w0.102: RC111.2 133.96,14.71 133.96,14.6 134.05,14.51 135.13,14.51 135.52,14.12 135.88,13.76 135.88,13.73 136.15,13.46 JXDP1.51
DDR_XDP_WAN_SMBCLK: length 357.7
  TOP w0.102: R2598.2 108.95,104.55 108.95,104.33 v2(108.77,104.15) ; RC112.1 133.78,16.34 133.78,16.48 133.73,16.53 133.23,16.53 133,16.75 133,17 v2(132.83,17.18) ; v2(112.62,93.65) 112.82,93.86 113.38,93.86 113.8,93.43 113.8,91.58 115,90.38 118.56,90.38 121.3,87.64 121.3,84.3 120.9,83.91 120.9,82.39 v2(120.66,82.15) 120.66,82.6 120.26,83 QC1.1 ; U15.4 162.6,126.54 R123.2 163.41,126.53 163.8,126.93 163.8,128.52 164.07,128.78 170.52,128.78 170.76,128.54 174.38,128.54 175.46,127.46 183.24,127.46 191.43,119.27 194.23,119.27 v2(194.41,119.09)
  IN1 w0.097: v2(175.93,74.12) 175.75,74.3 175.75,74.87 175.46,75.17 173.96,75.17 173.59,75.53 173.59,79.19 174.41,80 176.12,80 177.04,80.92 177.04,83.21 177.55,83.71 179.01,83.71 184.76,89.46 184.76,94.3 187.43,96.97 187.43,103.66 190.44,106.68 190.44,109.44 192.12,111.12 192.12,118.36 193.08,119.31 194.2,119.31 v2(194.41,119.09) 194.59,119.27 195.96,119.27 196.19,119.5 204.75,119.5 209.07,123.82 215.24,123.82 220.45,129.02 220.45,131.18 221.23,131.97 221.23,134.51 230.89,144.17 231.25,144.17 v2(231.43,143.98)
  IN3 w0.102: v2(112.62,93.65) 112.42,93.86 111.89,93.86 111.42,94.33 111.42,95.37 108.95,97.83 108.95,103.98 v2(108.77,104.15) ; v2(120.66,82.15) 120.84,81.97 120.84,81.72 121.09,81.47 121.69,81.47 122.02,81.8 130.68,81.8 131.67,82.8 133.46,82.8 134.54,81.72 137.9,81.72 138.73,82.55 140.34,82.55 141.04,83.25 148.49,83.25 150.7,81.04 153.8,81.04 154.32,80.53 154.32,78.91 154.87,78.36 157.6,78.36 158.37,77.59 158.37,75.79 158.88,75.29 158.88,74.06 159.42,73.52 162.13,73.52 163.56,74.94 170.84,74.94 172.35,73.44 175.52,73.44 175.78,73.7 175.78,73.97 v2(175.93,74.12)
  BOTTOM w0.102: R218.2 223.21,143.78 226.64,143.78 227.02,144.16 231.25,144.16 v2(231.43,143.98) ; v2(132.83,17.18) 133.03,17.38 133.03,17.61 133.55,18.13 138.25,18.13 158.14,38.02 158.14,69.66 160.93,72.44 165.19,72.44 166.71,70.92 169.2,70.92 169.33,71.05 JDIMM2.202 171.89,71.05 171.97,71.12 171.97,71.94 174.83,74.8 175.52,74.8 175.75,74.57 175.75,74.3 v2(175.93,74.12) 175.75,73.94 175.75,73.75 175.88,73.63 176.11,73.63 176.78,74.3 176.78,74.71 177.1,75.03 180.61,75.03 181.77,73.87 181.77,71.11 182.05,70.83 182.57,70.83 182.79,71.05 JDIMM1.202
DDR_XDP_WAN_SMBDAT: length 356.9
  TOP w0.102: U15.6 160.24,128.2 160.49,128.45 R122.2 162.89,129.01 170.61,129.01 170.85,128.77 174.48,128.77 175.56,127.69 183.34,127.69 191.53,119.5 194.23,119.5 v2(194.41,119.68) ; QC1.4 121.69,81.7 v2(121.24,82.15) 121.13,82.26 121.13,83.81 121.53,84.2 121.53,87.74 118.66,90.61 115.1,90.61 114.03,91.67 114.03,93.53 113.47,94.09 112.82,94.09 v2(112.62,94.29) ; RC111.1 134.01,16.34 134.01,16.58 133.83,16.75 133.33,16.75 133.23,16.85 133.23,17 v2(133.41,17.18) ; R2597.2 109.18,104.55 109.18,104.33 v2(109.36,104.15)
  IN1 w0.097: v2(231.43,144.57) 231.25,144.39 230.8,144.39 221.01,134.6 221.01,132.06 220.22,131.27 220.22,129.12 215.15,124.04 208.98,124.04 204.66,119.72 196.09,119.72 195.87,119.5 194.59,119.5 v2(194.41,119.68) 194.26,119.53 192.98,119.53 191.9,118.45 191.9,111.21 190.22,109.53 190.22,106.77 187.2,103.76 187.2,97.06 184.54,94.39 184.54,89.56 178.92,83.94 177.46,83.94 176.82,83.3 176.82,81.02 176.03,80.22 174.31,80.22 173.37,79.28 173.37,75.44 173.87,74.94 175.36,74.94 175.53,74.78 175.53,74.3 v2(175.35,74.12)
  IN3 w0.102: v2(109.36,104.15) 109.18,103.98 109.18,97.93 111.64,95.46 111.64,94.43 111.99,94.09 112.42,94.09 v2(112.62,94.29) ; v2(121.24,82.15) 121.07,81.97 121.07,81.82 121.18,81.7 121.6,81.7 121.93,82.03 130.58,82.03 131.57,83.02 133.55,83.02 134.63,81.94 137.8,81.94 138.64,82.78 140.25,82.78 140.94,83.48 148.58,83.48 150.79,81.27 153.9,81.27 154.54,80.62 154.54,79.01 154.96,78.59 157.7,78.59 158.6,77.69 158.6,75.89 159.1,75.38 159.1,74.15 159.51,73.75 162.04,73.75 163.46,75.17 170.93,75.17 172.44,73.66 175.42,73.66 175.55,73.79 175.55,73.92 v2(175.35,74.12)
  BOTTOM w0.102: v2(133.41,17.18) 133.26,17.33 133.26,17.52 133.64,17.9 138.35,17.9 158.37,37.92 158.37,69.56 161.03,72.22 165.09,72.22 166.62,70.69 169.07,70.69 169.31,70.45 JDIMM2.200 171.84,70.45 172.2,70.81 172.2,71.84 174.93,74.58 175.42,74.58 175.52,74.47 175.52,74.3 v2(175.35,74.12) 175.52,73.94 175.52,73.66 175.78,73.4 176.2,73.4 177.01,74.2 177.01,74.62 177.19,74.8 180.51,74.8 181.54,73.77 181.54,71.02 181.96,70.6 182.6,70.6 182.75,70.45 JDIMM1.200 ; R219.2 223.44,144.01 226.54,144.01 226.92,144.39 231.25,144.39 v2(231.43,144.57)
