# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LANCLK_REQ#_R: length 2.6
  TOP w0.102: U21.48 175.17,136.44 v1(174.61,135.87) 174.1,135.37 R169.2
LCD_CBL_DET#: length 86.8
  TOP w0.102: v2(97.57,133.47) 97.12,133.92 JLVDS1.14
  IN3 w0.102: v2(107.35,98.67) 107.73,99.05 107.73,107.47 106.73,108.47 106.73,112.36 99.16,119.93 99.16,131.88 v2(97.57,133.47)
  BOTTOM w0.076: UC1.J3 111.8,66.17 111.8,66.69 111.56,66.92 111.39,66.92 111.22,67.09 111.22,67.16 110.48,67.91 110.48,68.61 110.12,68.96 110.12,69.84
  BOTTOM w0.102: v2(107.35,98.67) 108.94,97.08 114.08,97.08 116.24,94.92 116.24,91.69 113.83,89.27 112.71,89.27 110.34,86.9 110.34,84.07 111.23,83.18 111.23,78.6 v1(111.54,78.29) 112.01,77.82 112.01,75.28 112.62,74.67 112.81,74.67 112.89,74.59 RP9.8 112.89,73.55 110.12,70.78 110.12,69.84
LCD_ENVDD_CVT: length 38.6
  TOP w0.102: v2(107.86,114.86) 107.42,114.42 107.42,114.19 106.59,113.37 U52.20 ; U86.1 97.07,94.59 R110.1 96.05,93.91 95.5,93.36 v1(93.03,93.36) 92.21,93.36 v2(92.11,93.46)
  IN1 w0.097: v2(107.86,114.86) 106.46,113.47 106.46,112.39 104.49,110.42 102.02,110.42 98.53,106.93 97.64,106.93 96.37,105.66 96.37,104.54 94.43,102.61 94.02,102.61 92.33,100.92 92.33,94.53 92.11,94.31 92.11,93.47 v2(92.11,93.46)
LCD_TST: length 121.3
  TOP w0.102: JLVDS1.37 94.77,122.42 v2(94.4,122.8) ; R309.2 165.01,89.55 165.01,90.21 v2(165.01,90.22) 165.36,90.22 165.53,90.39 v1(165.53,90.68) 165.53,91.02 165.51,91.05 165.51,91.57 165.23,91.84 U37.A36
  IN2 w0.102: v2(94.4,122.8) 100.05,122.8 100.18,122.67 106.35,122.67 109.59,119.43 118.67,119.43 119.44,118.66 122.11,118.66 123.74,120.29 126.73,120.29 127.52,119.5 127.52,118.52 128.22,117.82 129.89,117.82 132.16,120.09 132.16,123.8 134.08,125.72 139.68,125.72 140.37,126.42 150.31,126.42 151.67,125.06 152.58,125.06 152.97,125.45 v2(152.97,126.1)
  IN3 w0.102: v2(165.01,90.22) 164.65,89.85 157.9,89.85 156.05,91.7 156.05,98.15 156.18,98.28 156.18,102.28 156.08,102.38 156.08,106.26 155.6,106.73 155.03,106.73 153.74,108.02 153.74,111.45 152.22,112.98 152.22,119.6 152.66,120.05 152.66,124.61 152.97,124.92 v2(152.97,126.1)
LCD_VCC_TEST_EN: length 96.1
  TOP w0.102: v2(103.54,101.08) 103.54,101.63 v1(103.44,101.73) ; v2(167.31,91.39) 167.31,92.06 U37.A40 ; v2(94.88,96.57) D76.3
  IN2 w0.102: v2(103.54,101.08) 104.05,100.58 104.05,97.34 103.54,96.83 95.13,96.83 v2(94.88,96.57)
  IN3 w0.102: v2(167.31,91.39) 166.91,90.98 166.91,89.56 165.16,87.82 165.16,87.07 163.54,85.45 163.54,84.79 162.48,83.73 157.91,83.73 156.82,84.83 152.07,84.83 149.8,87.1 141.34,87.1 140.71,87.73 136.28,87.73 135.56,87 130.59,87 129.84,87.75 119.72,87.75 v2(119.6,87.62)
  BOTTOM w0.102: v2(103.54,101.08) 103.77,101.08 104.08,100.77 107.03,100.77 109.89,97.91 114.46,97.91 117.19,95.18 118.72,95.18 119.6,94.3 v2(119.6,87.62)
LED_10_GRN#: length 102.7
  IN3 w0.102: v2(224.51,166.68) 225.84,166.68 228.38,169.22 235.56,169.22 236.26,169.92 244,169.92 244.83,170.74 267.56,170.74 267.88,170.43 288.28,170.43 293.55,165.15 304.2,165.15 304.46,164.9 v2(305.15,164.9)
  BOTTOM w0.102: JIO1.11 v2(305.15,164.9) ; v2(224.51,166.68) 223.47,165.64 223.47,161.37 224.78,160.05 225.27,160.05 227.94,157.39 227.94,155.09 v1(227.68,154.84) Q22.4
LED_10_GRN#_Q: length 68.4
  TOP w0.102: v2(178.95,151.02) 178.56,151.41 178.56,154.12 178.94,154.5 v1(178.94,156.04) 178.94,157.18 179.3,157.54 U23.41
  BOTTOM w0.102: Q22.3 226.29,152.79 226.57,153.07 226.57,154.86 222.14,159.29 221.29,159.29 218.73,161.85 201.14,161.85 199.81,160.52 199.81,158.17 198.98,157.34 193.65,157.34 193.39,157.09 193.39,156.33 193.65,156.07 193.65,155.44 193.46,155.25 193.2,155.25 189.56,151.6 179.46,151.6 178.95,151.09 v2(178.95,151.02)
LED_100_ORG#: length 129.8
  TOP w0.102: Q32.4 191.54,155.14 191.3,155.38 v2(190.88,155.38) ; v2(304.77,165.4) v1(305.44,165.4)
  IN3 w0.102: v2(304.77,165.4) 293.62,165.4 288.35,170.68 268.01,170.68 267.69,171 244.58,171 244.13,170.55 229.34,170.55 227.81,169.03 225.49,169.03 223.42,166.96 217.04,166.96 214.12,164.04 194.35,164.04 190.79,160.48 190.79,158.3 191.43,157.66 191.43,157.15 190.88,156.6 v2(190.88,155.38)
  BOTTOM w0.102: JIO1.9 v2(304.77,165.4)
LED_100_ORG#_Q: length 2.4
  TOP w0.102: Q32.3 191.21,157.04 v1(190.47,157.04) U23.18
LED_DET#: length 126.4
  TOP w0.102: v2(194.98,45.94) 195.26,45.94 198.16,43.04 198.16,30.03 194.75,26.62 194.75,23.07 190.92,19.23 190.28,17.2 190.28,14.98 190.66,14.6 190.66,8.75 188.26,6.35 JLED1.4 183.24,6.35 R478.1 ; U37.A34 164.23,91.58 v2(165.02,90.8)
  IN2 w0.102: v2(194.98,45.94) 194.98,46.68 190.43,51.22 190.43,52.73 188.58,54.58 188.58,57.95 187.43,59.11 186.22,59.11 184.19,61.14 184.19,69.44 187.87,73.13 187.87,73.82 188.57,74.52 188.57,86.29 189.27,86.99 189.27,87.43 v2(188.82,87.88)
  BOTTOM w0.102: v2(188.82,87.88) 188.06,88.64 v1(187.03,88.64) 186.41,88.64 186.13,88.91 169.05,88.91 168.38,89.59 166.23,89.59 v2(165.02,90.8)
LED_SATA_DIAG_OUT#: length 168
  TOP w0.102: U37.A10 v2(166.73,103.81) ; v2(192.06,34.03) 192.06,31.87 189.43,29.24 189.43,25.28 188.35,24.2 188.35,15.42 186.57,13.63 177.35,13.63 175.92,12.2 175.92,5.72 v1(176.3,5.34) 176.57,5.07 D24.1
  IN2 w0.102: v2(192.06,34.03) 189.94,36.15 189.94,39.91 187.82,42.03 187.82,48.56 183.54,52.84 183.54,53.75 182.6,54.69 176.79,54.69 176.16,55.32 176.16,68.78 177.11,69.73 179.5,69.73 181.44,71.68 181.44,74.7 182.21,75.47 184.17,75.47 185,76.3 185,90.59 186.09,91.69 186.09,95.17 188.12,97.21 188.12,101.97 190.6,104.45 190.6,109.78 191.36,110.54 191.36,111.22 v2(190.9,111.69)
  BOTTOM w0.102: v2(190.9,111.69) 189.27,111.69 188.44,112.51 184.95,112.51 180.69,108.26 177.96,108.26 175.31,105.6 170.2,105.6 169.77,105.17 167.83,105.17 167.3,104.64 167.3,104.07 167.04,103.81 v2(166.73,103.81)
LED_WWAN_OUT#: length 6.5
  BOTTOM w0.102: JMINI2.42 220.39,148.7 220.57,148.52 v1(223.63,148.52) 224.4,148.52 R226.1 224.76,148.88 Q30.4
LG_3V: length 8.1
  TOP w1.016: 197.52,135.69 194.66,135.69 v1(193.81,136.54) 192.76,137.6 192.76,140.14
LG_5V: length 5.8
  IN1 w1.016: 194.03,145.09 198.98,145.09 199.55,145.66
  vias: v1(199.64,146.14) v2(192.32,144.33) v2(192.9,144.31) v2(199.87,146.68) v2(200.19,146.17)
LG_+VDDRP: length 1
  BOTTOM w0.254: PU700.6 38.57,32.04 38.71,32.19
  vias: v1(39.04,33.24)
LID_CL#: length 133.1
  TOP w0.102: JUDB1.19 89.92,78.55 89.44,79.02 89.44,79.51 88.44,80.51 v2(87.03,80.51) ; U47.2 192.32,90.86 192,91.18 192,91.56 191.55,92 190.79,92 188.59,94.2 183.91,94.2 183.21,93.5 179.72,93.5 178.99,92.78 v2(178.74,92.78) R325.1
  IN2 w0.102: v2(136.74,92.69) 136.63,92.57 133.96,92.57 133.32,91.94 128.18,91.94 127.23,92.89 122.36,92.89 121.41,91.94 117.52,91.94 116.73,91.15 94.69,91.15 93,89.46 90.46,89.46 86.59,85.59 86.59,80.95 v2(87.03,80.51)
  IN3 w0.102: v2(165.26,82.64) 166.22,82.64 169.94,86.36 169.94,88.47 171.8,90.34 173.86,90.34 175.4,91.88 176.39,91.88 177.29,92.78 v2(178.74,92.78)
  BOTTOM w0.102: v2(136.74,92.69) 136.74,91.6 138.91,89.42 149,89.42 150.59,87.83 150.59,87.33 152.35,85.58 156.52,85.58 157.65,84.45 162.57,84.45 v5(163.45,83.57) 163.84,83.18 164.73,83.18 v2(165.26,82.64)
LID_CL_SIO#: length 14.1
  TOP w0.102: U37.B54 171.6,94.59 v2(171.36,94.35) ; v1(179.45,94.3) 177.55,94.3 177.19,93.94 C337.1 ; R322.2 R325.2 C337.1 ; C337.1 176.66,93.67 176.48,93.84 v2(176.12,93.84)
  BOTTOM w0.102: v2(171.36,94.35) 171.46,94.35 171.81,94 171.81,92.82 172.73,91.9 174.78,91.9 175.58,92.7 175.58,93.45 175.97,93.84 v2(176.12,93.84)
LOM_ACTLED_YEL#: length 25.5
  TOP w0.102: U23.15 187.77,155.54 187.93,155.38 188.05,155.38 188.3,155.13 189.75,155.13 191.29,153.6 v1(191.29,152.82) 191.29,152.25 v2(191.24,152.2) ; U21.26 180.5,142.72 v2(180.89,143.11)
  IN2 w0.102: v2(191.24,152.2) 191.09,152.05 189.12,152.05 187.43,150.36 187.43,148.84 187.04,148.45 185.71,148.45 185.27,148.01 185.27,143.56 185.01,143.31 183.83,143.31 183.63,143.11 v2(180.89,143.11)
LOM_SPD10LED_GRN#: length 28
  TOP w0.102: v2(183.6,145.42) 183.31,145.13 182.35,145.13 182.03,144.81 U24.2 182.03,143.42 v1(181.75,143.14) 180.9,142.29 U21.25 ; U23.42 179.56,157.04 v2(179.42,156.9)
  IN2 w0.102: v2(183.6,145.42) 183.02,144.83 176.69,144.83 176.06,145.47 176.06,154.74 177.33,156.01 178.54,156.01 v2(179.42,156.9)
LOM_SPD100LED_ORG#: length 25.5
  TOP w0.102: U23.16 188.27,155.61 188.52,155.36 189.85,155.36 191.68,153.53 191.68,151.12 190.61,150.05 184.52,150.05 183.49,149.03 v1(183.49,148.33) 183.49,146.31 182.53,145.36 182.2,145.36 181.38,144.53 U24.1 181.38,144.06 181.14,143.82 180.57,143.82 180.1,143.35 180.1,142.21 180.1,142.21 U21.27
LP_CTL: length 5
  TOP w0.102: R55.1 v1(115.54,97.98) 115.54,98.35 116.82,99.63 117,99.63 117.51,100.14 117.51,100.55 U6.B2
LPC_LAD0: length 252
  TOP w0.102: U38.A30 150.93,106.56 151.54,107.17 v2(151.59,107.17) ; v2(163.07,108.22) 163.68,108.83 U25.26 163.68,111.44 v2(163.93,111.69) ; v2(160.56,96.85) 161.08,96.34 U37.A27
  IN1 w0.097: v2(217.27,137.91) 217.27,136.16 215.75,134.64 215.75,132.68 210.69,127.63 204.05,127.63 201.7,125.28 195.68,125.28 195.3,124.9 193.14,124.9 191.46,123.22 188.43,123.22 186.87,121.66 186.16,121.66 183.98,119.48 177.85,119.48 177.31,118.94 170.67,118.94 163.93,112.2 v2(163.93,111.69) ; v2(133.16,62.58) 133.38,62.8 133.38,65.64 135.67,67.94 135.67,68.32 136.44,69.08 136.63,69.08 138.09,70.54 138.09,71.3 141.6,74.82 145.39,74.82 145.54,74.67 154.94,74.67 155.54,75.26 155.54,81 153.75,82.8 153.75,84.42 154.81,85.48 154.81,88.34 156.51,90.04 158.88,90.04 161.69,92.85 161.69,94.97 161.33,95.34 161.13,95.34 160.79,95.67 160.79,96.62 v2(160.56,96.85)
  IN3 w0.102: v2(163.07,108.22) 162.43,108.22 161.98,107.76 161.98,107.3 161.74,107.06 160.68,107.06 159.81,106.2 159.81,103.3 160.83,102.28 160.83,100.69 162,99.52 162,96.89 161.54,96.43 160.98,96.43 v2(160.56,96.85) ; v2(278.48,161.22) 277.79,160.52 275.22,160.52 274.52,159.82 266.86,159.82 266.74,159.95 264.13,159.95 263.31,160.77 248.77,160.77 248.13,160.14 242.61,160.14 242.34,159.87 239.56,159.87 239.11,159.42 230.58,159.42 229.83,158.68 226,158.68 225.02,157.7 225.02,156.26 226.16,155.12 226.16,146.48 225.59,145.91 225.59,144.42 224.55,143.39 220.67,143.39 219.24,141.95 219.24,138.61 218.41,137.79 217.4,137.79 v2(217.27,137.91)
  BOTTOM w0.076: UC1.AU14 127.51,59.67 127.98,59.67 128.02,59.64 129.35,59.64 129.46,59.74 130.78,59.74 133.16,62.12 v2(133.16,62.58)
  BOTTOM w0.102: v2(278.48,161.22) 278.8,160.9 R234.2 ; v2(151.59,107.17) 151.84,106.92 152.9,106.92 154.04,105.78 155.8,105.78 156.09,106.07 v1(158.04,106.07) 161.51,106.07 163.07,107.63 v2(163.07,108.22)
LPC_LAD1: length 246.4
  TOP w0.102: U37.A26 161.2,96.84 v2(161.2,96.84) ; U38.B32 149.47,106.81 149.3,106.64 148.84,106.64 148.43,106.24 v2(148.42,106.24) ; v2(161.73,108.83) U25.23 161.73,110.88 162.03,111.18 162.74,111.18 v2(163.28,111.72)
  IN1 w0.076: v2(130.57,61.04) 130.57,61.6 132.1,63.14
  IN1 w0.097: v2(217.72,138.29) 217.72,137.6 217.59,137.47 217.59,136.05 216.06,134.52 216.06,132.67 210.78,127.38 204.31,127.38 201.89,124.96 195.74,124.96 193.68,122.9 188.62,122.9 187.06,121.34 186.28,121.34 184.12,119.18 177.97,119.18 177.4,118.61 170.77,118.61 164.38,112.22 164.38,111.5 164.12,111.24 163.76,111.24 v2(163.28,111.72) ; 132.1,63.14 133.06,64.09 133.06,65.71 135.42,68.06 135.42,68.38 136.37,69.33 136.45,69.33 137.77,70.65 137.77,71.37 139.16,72.76 139.16,79.65 140.75,81.25 141.25,81.25 145.13,85.13 153.96,85.13 154.54,85.71 154.54,88.39 156.42,90.26 158.79,90.26 160.71,92.18 160.71,95.44 160.16,95.99 160.16,97.02 160.41,97.27 160.77,97.27 v2(161.2,96.84)
  IN3 w0.102: v2(161.73,108.83) 161.09,108.19 161.09,107.91 159.51,106.32 159.51,103.17 160.53,102.15 160.53,100.57 161.69,99.4 161.69,97.34 v2(161.2,96.84) ; v2(277.79,161.22) 275.49,161.22 274.41,160.14 267.05,160.14 265.65,161.54 249.02,161.54 247.94,160.46 242.5,160.46 242.14,160.1 239.46,160.1 239.02,159.65 230.48,159.65 229.83,159 225.88,159 224.7,157.81 224.7,156.14 225.84,154.99 225.84,146.6 225.29,146.04 225.29,144.55 224.43,143.69 220.55,143.69 218.92,142.07 218.92,138.87 218.35,138.29 v2(217.72,138.29)
  BOTTOM w0.076: UC1.AW12 128.81,60.38 130.33,60.38 130.57,60.63 v2(130.57,61.04)
  BOTTOM w0.102: v2(148.42,106.24) 148.83,105.83 149.17,105.83 151.3,107.95 152.87,107.95 153.8,107.02 160.03,107.02 161.08,108.08 161.08,108.18 v2(161.73,108.83) ; R236.2 277.79,160.72 v2(277.79,161.22)
LPC_LAD2: length 254.8
  TOP w0.102: v2(152.02,109.28) 152.02,108.19 150.9,107.06 U38.A31 ; U37.B26 163.8,97.59 v2(164.31,98.1) ; v2(159.84,108.83) 159.78,108.9 U25.20 159.78,110.87 v2(161.2,112.29)
  IN1 w0.097: v2(164.31,98.1) 163.8,98.61 163.17,98.61 162.49,97.93 162.49,92.69 159.08,89.28 159.08,88.02 155.84,84.78 154.92,84.78 154.3,84.17 154.3,82.9 155.99,81.21 155.99,75.06 155.14,74.21 145.34,74.21 145.19,74.36 141.92,74.36 141.17,73.61 141.17,71.85 139.16,69.84 138.68,69.84 137.33,68.49 136.61,68.49 136.18,68.06 136.18,67.75 133.89,65.46 133.89,62.35 133.45,61.9 132.66,61.9 v2(132.04,62.52) ; v2(224.76,144.6) 224.76,144.07 220.32,139.63 220.32,139.31 218.22,137.21 218.22,135.82 216.7,134.29 216.7,132.64 210.84,126.79 206.48,126.79 205.28,125.59 203.77,125.59 202.5,124.32 195.87,124.32 193.91,122.36 189.02,122.36 187.36,120.7 186.54,120.7 184.35,118.52 178.45,118.52 177.94,118.01 176.86,118.01 176.25,117.4 172.24,117.4 170.94,116.11 169.12,116.11 164.88,111.88 164.88,111.18 164.44,110.74 163.27,110.74 161.72,112.29 v2(161.2,112.29)
  IN3 w0.102: v2(274.74,161.22) 273.98,160.46 267.16,160.46 265.83,161.79 253.34,161.79 253.21,161.92 248.89,161.92 247.75,160.77 242.32,160.77 241.87,160.32 239.37,160.32 238.92,159.88 230.39,159.88 229.83,159.33 225.78,159.33 224.38,157.93 224.38,156.01 225.53,154.87 225.53,148.39 224.76,147.63 v2(224.76,144.6) ; v2(164.31,98.1) 163.96,97.75 162.97,97.75 162.3,98.42 162.3,99.81 161.7,100.41 161.7,101.84 160.12,103.42 160.12,106.07 160.81,106.76 161.86,106.76 162.78,107.67 163.09,107.67 163.47,108.05 163.47,109.03 163.27,109.24 160.25,109.24 v2(159.84,108.83)
  BOTTOM w0.076: v2(132.04,62.52) 132.04,61.87 130.4,60.22 129.29,60.22 UC1.AY12
  BOTTOM w0.102: R240.2 v2(274.74,161.22) ; v2(152.02,109.28) 152.02,109.5 152.63,110.11 153.64,110.11 154.43,110.9 159.81,110.9 v2(161.2,112.29)
LPC_LAD3: length 253.3
  TOP w0.102: U38.B33 149.39,107.31 v2(149.13,107.05) ; v2(157.27,108.51) 157.83,109.06 U25.17 157.83,111.76 158.91,112.84 159.99,112.84 160.37,112.46 160.72,112.46 161.12,112.87 v2(161.72,112.87) ; U37.B25 163.6,98.09 v2(163.66,98.15)
  IN1 w0.097: v2(163.66,98.15) 163.6,98.15 162.79,97.33 162.79,92.67 159.38,89.27 159.38,88.01 156.53,85.15 156.53,84.26 155.85,83.58 155.45,83.58 154.99,83.13 154.99,82.54 156.22,81.31 156.22,74.93 155.27,73.98 145.24,73.98 145.08,74.13 142.12,74.13 141.47,73.49 141.47,71.73 138.51,68.76 138.51,67.86 138.09,67.44 136.26,67.44 134.15,65.33 134.15,62.22 133.34,61.42 v2(131.09,61.42) ; v2(161.72,112.87) 161.72,112.71 163.44,110.99 164.25,110.99 164.63,111.37 164.63,112.05 170.89,118.31 177.53,118.31 178.1,118.88 184.27,118.88 186.41,121.02 187.24,121.02 188.79,122.58 193.75,122.58 195.81,124.64 202.02,124.64 203.83,126.46 205.43,126.46 205.99,127.02 210.74,127.02 216.38,132.66 216.38,134.41 217.91,135.93 217.91,137.34 218.16,137.6 v2(218.16,138.74)
  IN3 w0.102: v2(218.16,138.74) 218.6,139.18 218.6,142.18 225.21,148.78 225.21,154.68 224.08,155.81 224.08,158.06 225.65,159.63 229.82,159.63 231.72,161.53 238.98,161.53 239.55,160.96 241.53,160.96 241.66,161.09 247.62,161.09 248.77,162.23 253.28,162.23 253.47,162.04 266.01,162.04 267.28,160.77 273.34,160.77 v2(273.79,161.22) ; v2(163.66,98.15) 163.1,98.15 162.61,98.64 162.61,99.94 162.01,100.54 162.01,101.97 160.42,103.55 160.42,105.58 161.3,106.46 161.99,106.46 162.9,107.37 163.22,107.37 163.78,107.93 163.78,109.16 163.39,109.54 158.31,109.54 v2(157.27,108.51)
  BOTTOM w0.076: UC1.AW11 128.79,61.12 129.68,61.12 129.98,61.42 v2(131.09,61.42)
  BOTTOM w0.102: v2(157.27,108.51) 156.4,107.63 154.06,107.63 153.13,108.56 151.04,108.56 149.53,107.05 v2(149.13,107.05) ; R239.2 v2(273.79,161.22)
LPC_LFRAME#: length 241.6
  TOP w0.102: v2(163.28,112.31) 162.45,111.48 161.76,111.48 161.08,110.8 U25.22 v2(161.08,108.83) ; v2(161.19,99.33) 161.2,99.34 U37.A21 ; U38.B31 149.41,106.31 149.34,106.24 v2(149.01,106.24)
  IN1 w0.097: v2(161.19,99.33) 162.2,98.31 162.2,92.72 158.85,89.37 158.85,88.11 155.74,85 154.68,85 154,84.32 154,82.87 155.76,81.11 155.76,75.16 155.04,74.44 145.44,74.44 145.29,74.59 141.76,74.59 140.88,73.71 140.88,72.06 139.04,70.22 138.66,70.22 137.23,68.79 136.53,68.79 135.93,68.19 135.93,67.81 133.56,65.44 133.56,62.4 133.32,62.16 133.03,62.16 v2(132.6,62.59) ; v2(214.6,134.1) 214.6,131.87 210.59,127.85 203.83,127.85 201.57,125.59 195.62,125.59 195.17,125.15 193.01,125.15 191.4,123.53 188.3,123.53 186.74,121.97 185.86,121.97 184.49,120.61 178.55,120.61 177.18,119.24 170.53,119.24 163.61,112.31 v2(163.28,112.31)
  IN3 w0.102: v2(214.6,134.1) 214.6,136.52 216.32,138.23 216.32,140.33 220.32,144.33 220.32,152.14 222.94,154.75 222.94,157.34 225.53,159.93 229.8,159.93 231.62,161.76 239.07,161.76 239.59,161.24 241.19,161.24 241.43,161.47 247.56,161.47 248.58,162.49 253.4,162.49 253.59,162.3 266.18,162.3 267.26,161.22 v2(272.83,161.22) ; v2(161.19,99.33) 160.2,100.32 160.2,102.05 159.2,103.04 159.2,106.45 160.18,107.43 160.18,107.94 v2(161.08,108.83)
  BOTTOM w0.076: v2(132.6,62.59) v1(132.6,62.07) 130.59,60.05 129.54,60.05 129.29,59.8 128.12,59.8 UC1.AV12
  BOTTOM w0.102: v2(149.01,106.24) 149.15,106.24 151.17,108.26 153,108.26 153.93,107.33 157.79,107.33 158.98,108.51 158.98,109.08 159.17,109.27 160.63,109.27 v2(161.08,108.83) ; R238.2 v2(272.83,161.22)
LX_DGPU:
  vias: v1(75.69,23)
M_CLK_DDR0: length 63.5
  IN1 w0.076: 136.69,42.12 136.68,42.12 136.67,42.13 135.57,42.13 132.98,44.73 131.98,44.73 131.76,44.94 131.76,45.18 v2(131.61,45.33)
  IN1 w0.097: v2(179.1,41.7) 179.1,40.98 178.66,40.55 177.28,40.55 177.03,40.8 177.03,41.09 176.9,41.22 176.55,41.22 176.42,41.09 176.42,40.8 176.17,40.55 175.72,40.55 175.47,40.8 175.47,40.92 175.33,41.06 170.33,41.06 169.66,40.38 163.89,40.38 162.43,41.85 158.24,41.85 157.6,41.2 142.72,41.2 142.54,41.38 142.54,41.58 142.41,41.71 142.18,41.71 142.06,41.58 142.06,41.44 141.81,41.19 141.4,41.19 141.15,41.44 141.15,41.71 141.01,41.85 140.81,41.85 140.67,41.71 140.67,41.47 140.4,41.2 140.03,41.2 139.76,41.47 139.76,42.02 139.66,42.12 136.69,42.12
  BOTTOM w0.076: v2(131.61,45.33) 131.73,45.2 131.73,44.58 131.65,44.5 127.79,44.5 127.76,44.53 127.76,44.69 UC1.AV37
  BOTTOM w0.102: v2(179.1,41.7) 178.91,41.7 178.6,41.39 178.6,41.01 178.25,40.67 177.16,40.67 177.08,40.75 JDIMM1.101
M_CLK_DDR1: length 61.8
  IN1 w0.076: 136.75,42.94 136.74,42.94 136.73,42.95 136.66,42.95 136.65,42.96 135.31,42.96 133.19,45.08 132.96,45.08 132.36,45.69 130.57,45.69 130.45,45.81 129.58,45.81 129.26,45.49 129.26,45.33 129.33,45.26 v2(129.49,45.26)
  IN1 w0.097: 136.75,42.94 140,42.94 140.27,42.67 142.84,42.67 142.98,42.52 142.98,42.29 143.25,42.03 143.62,42.03 143.89,42.29 143.89,42.49 144.01,42.61 144.24,42.61 144.37,42.49 144.37,42.27 144.62,42.02 145.02,42.02 145.27,42.27 145.27,42.46 145.4,42.59 145.77,42.59 145.89,42.46 145.89,42.22 146.09,42.03 157.27,42.03 157.91,42.67 162.77,42.67 164.17,41.27 169.39,41.27 170.3,42.18 177.65,42.18 178.11,42.64 180.41,42.64 180.89,42.16 180.89,41.98 v2(180.62,41.7)
  BOTTOM w0.076: v2(129.49,45.26) 129.49,45.51 129.38,45.62 UC1.AY36
  BOTTOM w0.102: JDIMM1.102 181.16,41.05 180.92,41.29 180.92,41.4 v2(180.62,41.7)
M_CLK_DDR2: length 53.5
  IN3 w0.076: 132.28,43.6 132.27,43.6 132.26,43.59 132.03,43.59 131.44,44.18 126.89,44.18 126.41,43.7 125.13,43.7 125.02,43.82 125.02,44.13 v2(125.08,44.19)
  IN3 w0.102: v2(165.93,41.89) 165.49,42.33 165.16,42.33 164.78,42.71 164.34,42.71 163.73,42.11 160.48,42.11 160.21,41.85 147.78,41.85 147.68,41.95 147.68,43.87 147.43,44.12 146.89,44.12 146.64,43.87 146.64,41.95 146.54,41.85 146.13,41.85 146.03,41.95 146.03,42.79 145.8,43.02 144.96,43.02 143.16,44.82 136.53,44.82 135.72,44.01 133.75,44.01 133.35,43.6 132.28,43.6
  BOTTOM w0.076: UC1.AN38 124.75,44.51 v2(125.08,44.19)
  BOTTOM w0.102: v2(165.93,41.89) 165.83,41.79 165.83,41.39 165.19,40.75 JDIMM2.101
M_CLK_DDR3: length 51.9
  IN3 w0.076: 133.73,43.17 133.72,43.16 133.72,43.15 133.72,43.15 133.69,43.12 126.94,43.12 126.71,43.35 124.53,43.35 124.36,43.53 123.66,43.53 123.52,43.67 123.52,43.9 v2(123.75,44.14)
  IN3 w0.102: v2(167.46,41.89) 167.71,41.64 167.71,41.42 167.58,41.28 161.5,41.28 161.24,41.02 145.79,41.02 142.85,43.96 136.55,43.96 136.12,43.53 134.08,43.53 133.73,43.17
  BOTTOM w0.076: UC1.AL38 123.45,44.44 v2(123.75,44.14)
  BOTTOM w0.102: JDIMM2.102 169.49,41.05 169.33,40.88 168.32,40.88 167.84,41.37 167.84,41.71 167.66,41.89 v2(167.46,41.89)
M_CLK_DDR#0: length 63.8
  IN1 w0.076: 136.69,42.33 136.68,42.33 136.67,42.32 135.65,42.32 133.39,44.58 133.06,44.92 132.05,44.92 131.95,45.02 131.95,45.23 132.05,45.33 v2(132.18,45.33)
  IN1 w0.097: v2(178.33,41.7) 178.52,41.7 178.88,41.34 178.88,41.07 178.58,40.76 177.37,40.76 177.24,40.89 177.24,41.18 176.99,41.43 176.46,41.43 176.21,41.18 176.21,40.89 176.09,40.76 175.8,40.76 175.68,40.89 175.68,41.01 175.42,41.27 170.24,41.27 169.57,40.59 163.98,40.59 162.52,42.06 158.16,42.06 157.51,41.41 142.81,41.41 142.75,41.47 142.75,41.67 142.5,41.92 142.1,41.92 141.84,41.67 141.84,41.53 141.72,41.4 141.49,41.4 141.36,41.53 141.36,41.8 141.1,42.06 140.72,42.06 140.46,41.8 140.46,41.55 140.32,41.41 140.12,41.41 139.98,41.55 139.98,42.11 139.75,42.33 136.69,42.33
  BOTTOM w0.076: v2(132.18,45.33) 132.12,45.33 131.92,45.14 131.92,44.5 131.75,44.33 127.69,44.33 127.57,44.45 127.57,44.73 127.48,44.82 127.29,44.82 UC1.AU37
  BOTTOM w0.102: JDIMM1.103 176.55,41.35 176.94,40.97 177.17,40.97 177.25,40.88 178.16,40.88 178.38,41.1 178.38,41.65 v2(178.33,41.7)
M_CLK_DDR#1: length 62
  IN1 w0.076: 136.75,43.15 135.39,43.15 133.27,45.27 133.04,45.27 132.44,45.88 130.65,45.88 130.53,46 129.5,46 129.07,45.57 129.07,45.49 v2(128.84,45.26)
  IN1 w0.097: 136.75,43.15 140.09,43.15 140.36,42.88 142.93,42.88 143.19,42.61 143.19,42.38 143.33,42.24 143.53,42.24 143.68,42.38 143.68,42.58 143.93,42.83 144.33,42.83 144.58,42.58 144.58,42.36 144.71,42.23 144.94,42.23 145.06,42.36 145.06,42.55 145.31,42.8 145.86,42.8 146.11,42.55 146.11,42.31 146.17,42.24 157.18,42.24 157.82,42.88 162.85,42.88 164.25,41.48 169.3,41.48 170.21,42.39 177.56,42.39 178.03,42.85 180.5,42.85 181.11,42.25 181.11,41.98 v2(181.38,41.7)
  BOTTOM w0.076: UC1.AW36 128.51,45.58 v2(128.84,45.26)
  BOTTOM w0.102: JDIMM1.104 182.86,41.65 182.47,41.27 181.25,41.27 181.14,41.38 181.14,41.46 v2(181.38,41.7)
M_CLK_DDR#2: length 53.8
  IN3 w0.076: v2(124.32,44.15) 124.46,44.29 124.66,44.29 124.72,44.23 124.72,44.04 124.83,43.94 124.83,43.74 125.05,43.51 126.49,43.51 126.97,43.99 131.36,43.99 131.95,43.4 132.26,43.4 132.27,43.39 132.28,43.39
  IN3 w0.102: v2(165.17,41.89) 165.17,42.02 165.11,42.08 165.11,42.08 165.07,42.12 164.69,42.5 164.43,42.5 163.82,41.89 160.57,41.89 160.3,41.63 147.69,41.63 147.47,41.86 147.47,43.78 147.34,43.91 146.98,43.91 146.86,43.78 146.86,41.86 146.63,41.63 146.04,41.63 145.81,41.86 145.81,42.7 145.71,42.8 144.87,42.8 143.07,44.61 136.62,44.61 135.81,43.79 133.84,43.79 133.44,43.39 132.28,43.39
  BOTTOM w0.076: UC1.AM38 124.36,44.58 124.45,44.49 124.45,44.28 v2(124.32,44.15)
  BOTTOM w0.102: JDIMM2.103 163.59,41.35 163.97,40.97 165.1,40.97 165.62,41.48 165.62,41.61 165.34,41.89 v2(165.17,41.89)
M_CLK_DDR#3: length 52.2
  IN3 w0.076: 133.88,43.02 133.79,42.93 126.86,42.93 126.63,43.16 124.45,43.16 124.28,43.34 123.58,43.34 123.33,43.59 123.33,43.8 123,44.13 v2(123,44.13)
  IN3 w0.102: v2(168.22,41.89) 167.93,41.6 167.93,41.33 167.67,41.06 161.59,41.06 161.33,40.8 145.7,40.8 142.76,43.74 136.64,43.74 136.21,43.31 134.17,43.31 133.88,43.02
  BOTTOM w0.076: v2(123,44.13) 123,44.41 UC1.AK38
  BOTTOM w0.102: v2(168.22,41.89) 168.06,41.73 168.06,41.46 168.41,41.1 169.24,41.1 169.79,41.65 JDIMM2.104
M_ODT0: length 6
  TOP w0.152: R29.2 186.98,43.23 v2(186.15,44.06)
  BOTTOM w0.152: v2(186.15,44.06) 184.96,45.25 JDIMM1.116
M_ODT1: length 6.1
  TOP w0.152: v2(186.22,45.71) 187.74,44.19 R30.2
  BOTTOM w0.152: v2(186.22,45.71) 185.71,46.22 185.24,46.22 185.01,46.45 JDIMM1.120
M_ODT2: length 20.4
  TOP w0.152: R31.2 186.97,47.23 184.72,47.23 184.53,47.43 176.08,47.43 174.09,45.44 v2(173.75,45.44)
  BOTTOM w0.152: JDIMM2.116 171.76,45.25 172.09,44.92 173.23,44.92 v2(173.75,45.44)
M_ODT3: length 20.8
  TOP w0.152: v2(172.22,45.44) 172.88,46.09 174.14,46.09 175.9,47.86 184.71,47.86 184.9,47.67 187.49,47.67 R33.2
  BOTTOM w0.152: v2(172.22,45.44) 172.22,45.96 171.73,46.45 JDIMM2.120
MASK_BASE_LEDS#: length 123.3
  TOP w0.102: v2(188.25,93.59) 188.7,93.59 v1(189.46,92.83) 190.78,91.51 U47.4 191.35,91.51 191.62,91.24 191.62,88.55 191.26,88.19 Q28.2 ; 192.38,155.69 v2(193.2,155.69) ; 192.38,155.69 192.19,155.5 Q32.5 ; 192.38,155.69 192.19,155.88 Q32.2
  IN2 w0.102: v2(190.8,115.44) 190.8,115.43 192.25,113.97 192.25,105.72 188.38,101.85 188.38,93.72 v2(188.25,93.59)
  IN3 w0.102: v2(193.2,155.69) 192.82,155.31 192.82,154.17 192,153.34 192,151.3 188.25,147.55 188.25,145.6 188.06,145.41 188.06,144.39 188.44,144.01 188.44,134.36 190.26,132.54 190.26,124.61 190.8,124.07 v2(190.8,115.44)
  BOTTOM w0.102: Q22.5 227.37,152.14 226.8,152.71 226.8,154.96 222.23,159.52 221.39,159.52 218.8,162.11 201.01,162.11 199.55,160.65 199.55,158.3 198.86,157.6 193.52,157.6 193.14,157.22 193.14,155.76 v2(193.2,155.69)
MASK_SATA_LED#: length 129.2
  TOP w0.102: v2(169.48,5.7) 169.48,4.52 170.45,3.55 Q24.5 ; v1(181.48,94.63) 181.48,94.53 182.06,93.95 v2(182.1,93.95) ; v2(167.76,101.4) 167.48,101.67 U37.B9
  IN2 w0.102: v2(182.1,93.95) 182.1,93 180.29,91.19 180.29,90.2 176.73,86.64 176.73,86.25 173.56,83.07 171.67,83.07 168.76,80.16 168.76,76.85 170.22,75.39 170.22,50.74 171.22,49.74 174.57,49.74 176.15,48.16 176.15,7.85 173.59,5.3 169.87,5.3 169.48,5.69 v2(169.48,5.7)
  BOTTOM w0.102: v2(167.76,101.4) 168.06,101.4 168.19,101.27 168.19,99.34 169.95,97.58 171.61,97.58 173.17,96.02 174.66,96.02 174.99,95.69 176.31,95.69 177.93,94.07 181.98,94.07 v2(182.1,93.95)
MCARD_PCIE_MSATA#: length 99.6
  TOP w0.102: U37.B3 170.48,101.51 v2(170.6,101.4)
  IN2 w0.102: v2(122.27,72.64) 121.97,72.94 121.97,74.01 121.72,74.26 121.72,76.31 121.56,76.46 121.56,77.82 121.91,78.17 121.91,80.04 123.14,81.27 126.91,81.27 128.03,82.39 128.03,84.08 128.62,84.67 131.76,84.67 133.77,82.67 136.16,82.67 137.2,83.71 143.72,83.71 144.16,83.28 147.87,83.28 149.16,84.57 149.16,85.78 152.18,88.8 154.92,88.8 155.61,89.49 156.34,89.49 156.51,89.32 161.92,89.32 162.36,88.88 166.95,88.88 167.17,88.66 173.7,88.66 176.99,91.94 176.99,94.8 178.76,96.58 v2(179.17,96.58)
  BOTTOM w0.076: UC1.AC1 119,68.29 117.93,69.36 117.93,69.84
  BOTTOM w0.102: v2(122.27,72.64) 122.27,73.06 RC12.1 121.98,73.32 121.51,72.85 121.51,72.75 120.83,72.06 119.63,72.06 119.21,71.65 v1(119.21,71.48) 117.93,70.2 117.93,69.84 ; v2(170.6,101.4) 171.04,100.96 171.04,100.52 171.22,100.35 171.53,100.35 172.24,99.64 172.24,99.33 173.33,98.24 177.51,98.24 v2(179.17,96.58)
MCARD_WWAN_PWREN: length 77.7
  TOP w0.102: U37.B42 166.98,93.68 v2(167.08,93.77) ; v1(207.1,137.02) 207.68,137.61 RC191.1 208.24,137.72 v2(208.89,137.72) 209.02,137.6 209.86,137.6 209.9,137.64 U51.5
  IN2 w0.102: v2(192.63,126.6) 191.16,126.6 185.14,120.58 185.14,113.98 183.55,112.39 183.55,110.67 180.69,107.81 180.69,104.64 178.62,102.57 178.62,100.13 177.74,99.24 175.75,99.24 174.51,98 173.17,98 172.45,97.28 172.45,94.13 171.66,93.34 167.51,93.34 v2(167.08,93.77)
  IN3 w0.102: v2(192.63,126.6) 192.63,127.25 196.95,131.56 207.11,131.56 208.34,132.8 208.34,137.18 v2(208.89,137.72)
MCP_TESTLOW1: length 8.5
  BOTTOM w0.076: 103.98,45.28 106.03,45.28 106.64,45.9 106.81,45.96 106.92,45.96 107.04,45.91 107.07,45.9 107.26,45.9 107.41,45.94 107.56,46.04 UC1.C35
  BOTTOM w0.102: 103.98,45.28 103.5,45.28 101.78,47 100.67,47 RC46.1
MCP_TESTLOW2: length 10.8
  BOTTOM w0.076: 100.94,48.02 100.94,48.02 101.64,48.72 v1(101.64,48.84) ; UC1.C34 107.72,46.65 107.54,46.48 107.54,46.3 107.34,46.1 107.23,46.07 107.1,46.07 107.04,46.09 107.03,46.1 106.95,46.13 106.78,46.13 106.55,46.04 105.98,45.47 103.95,45.47
  BOTTOM w0.102: 100.94,48.02 RC47.1 101.42,47.19 101.86,47.19 103.58,45.47 103.95,45.47
MCP_TESTLOW3: length 14.6
  TOP w0.102: v2(123.3,62.51) 123.93,63.14 126.81,63.14 127.29,62.67 129.96,62.67 130.93,63.64 v1(131.38,63.64) 131.57,63.83 132.14,63.83 132.33,64.02 132.84,64.02 134.85,66.03 134.86,66.03 RC50.1
  BOTTOM w0.076: v2(123.3,62.51) 123.3,62.6 UC1.AK8
MCP_TESTLOW4: length 16
  TOP w0.076: 137.03,66.53 RC52.1 136.1,66.53 135.61,66.03 135.48,66.03 v2(135.29,65.84)
  TOP w0.102: v1(137.45,66.67) 137.31,66.53 137.03,66.53
  IN2 w0.076: v2(135.29,65.84) 132.63,65.84 129.45,62.67 127.67,62.67 127.31,63.02 124.47,63.02 v2(123.96,62.52)
  BOTTOM w0.076: v2(123.96,62.52) 123.68,62.83 123.64,62.88 UC1.AL8
ME_FWP: length 64.7
  TOP w0.102: U37.A8 v2(167.73,103.81) 168.57,104.65 168.57,104.76 R326.1
  IN1 w0.097: v2(167.73,103.81) 167.73,102.74 168.19,102.29 168.19,100.03 168.34,99.88 168.34,93.18 166.91,91.74 166.91,88.05 166.99,87.96 166.99,87.32 v2(166.82,87.15)
  IN2 w0.102: v2(137.71,73.6) 141.32,73.6 141.96,74.24 153.54,74.24 155.98,76.67 155.98,80.89 153.77,83.1 153.77,84.82 154.53,85.59 154.53,86.43 154.95,86.85 157.27,86.85 157.82,87.4 161.49,87.4 161.83,87.06 164.05,87.06 164.22,86.88 166.56,86.88 v2(166.82,87.15)
  BOTTOM w0.102: RC9.1 138.1,73.19 137.71,73.59 v2(137.71,73.6)
ME_RESET#: length 3.6
  BOTTOM w0.102: UC2.2 103.29,80.53 RC76.1 102.79,80.47 102.77,80.5 RC81.2 102.27,79.93 v1(102.7,79.5)
ME_SUS_PWR_ACK: length 27.9
  TOP w0.102: U38.A8 144.89,98.06 144.83,98 144.83,96.96 v2(145.33,96.46)
  IN1 w0.097: v2(145.33,96.46) 145.33,95.62 143.99,94.29 142.85,94.29 142.38,93.82 142.38,93.6 139.52,90.74 139.52,90.74 135.15,86.37 v2(135.15,85.25)
  BOTTOM w0.102: RC94.1 133.62,77.09 RC70.2 134.21,77.64 v1(134.21,78.93) 134.21,84.31 v2(135.15,85.25)
ME_SUS_PWR_ACK_R: length 17
  BOTTOM w0.076: UC1.AV4 128.11,65.24 128.39,65.52 128.88,65.52 128.97,65.62 129.35,65.62 129.87,66.13 129.87,68.93 130.78,69.84
  BOTTOM w0.102: RC82.1 132.74,77.98 RC94.2 131.39,76.64 130.26,76.64 130.12,76.5 130.12,72.37 130.46,72.04 130.62,72.04 130.96,71.7 130.96,71.48 131.04,71.4 v1(131.04,71.17) 130.85,70.98 130.85,69.9 130.78,69.84
MEC_XTAL1: length 8.5
  TOP w0.102: U38.A61 138.71,101.56 v1(138.46,101.32) 138.04,100.89 138.04,98.28 137.35,97.59 136.46,97.59 C364.1 135.94,97.79 135.54,97.4 Y4.1
MEC_XTAL2: length 4.5
  TOP w0.102: C365.1 R378.1 135.86,95.1 135.66,94.9 Y4.2 v1(132.73,94.9)
MEC_XTAL2_R: length 7.2
  TOP w0.102: U38.A62 138.77,101.06 138.43,100.73 v1(138.43,99.31) 138.43,98.35 137.48,97.39 137.48,96.92 136.58,96.02 R378.2
MED_DET#: length 103.4
  TOP w0.102: R477.1 176.45,157.27 176.01,156.82 176.01,155.21 176.47,154.75 JMED1.3 177.99,154.75 178.21,154.54 178.21,150.63 178.75,150.08 181.33,150.08 181.54,150.3 190.16,150.3 v2(190.98,151.12) ; U37.B53 171.74,94.09 v2(171.4,93.75)
  IN3 w0.102: v2(190.98,151.12) 190.98,150.71 187.93,147.67 187.93,145.72 187.81,145.6 187.81,144.26 188.19,143.88 188.19,134.23 190.03,132.39 190.03,124.51 190.57,123.97 190.57,116.35 190.35,116.13 190.35,113.85 189.53,113.03 189.53,104.84 188.51,103.81 188.51,96.64 187.55,95.69 187.55,94.67 186.66,93.78 186.66,93.53 v2(185.46,92.32)
  BOTTOM w0.102: v2(185.46,92.32) 180.57,92.32 179.73,91.48 172.77,91.48 171.4,92.85 v2(171.4,93.75)
MEDIACARD_IRQ#: length 181.1
  TOP w0.102: RP10.6 115.87,84.26 116.12,84.51 117.07,84.51 117.57,85.02 v2(117.57,85.67) v1(117.57,86.59)
  IN2 w0.076: v2(118.11,64.11) 117.72,64.5 117.72,69.84
  IN2 w0.102: v2(117.57,85.67) 117.56,85.66 117.31,85.66 116.5,84.85 114.84,84.85 111.88,81.89 111.88,79.09 112.77,78.2 112.77,76.01 113.64,75.14 113.67,75.14 115.09,73.72 115.09,72.94 115.54,72.48 115.54,72.05 116.56,71.03 117.02,71.03 117.72,70.34 117.72,69.84 ; v2(7.69,27.99) 8.14,28.44 8.8,28.44 9.18,28.82 9.18,29.96 11.12,31.91 13.66,31.91 18.83,37.08 18.83,45.39 23.66,50.22 32.36,50.22 34.45,52.32 34.45,58.54 42.46,66.54 70.41,66.54 73.97,70.1 v2(75.77,70.1)
  IN3 w0.102: v2(75.77,70.1) 75.48,70.4 75.48,76.51 78.27,79.3 80.43,79.3 84.12,82.98 90.17,82.98 90.93,83.74 97.73,83.74 98.22,84.23 111.96,84.23 112.94,85.21 116.88,85.21 117.34,85.67 v2(117.57,85.67)
  BOTTOM w0.076: UC1.AB6 118.29,63.93 v2(118.11,64.11)
  BOTTOM w0.102: U27.16 8.17,27.51 v2(7.69,27.99)
MEDIACARD_PWREN: length 155.1
  TOP w0.102: v1(122.14,84.51) 121.91,84.28 v2(121.91,83.98)
  IN2 w0.102: v2(77.7,72.64) 77.7,70.79 76.3,69.4 74.03,69.4 70.23,65.6 42.66,65.6 35.15,58.09 35.15,52.25 32.61,49.71 23.91,49.71 19.34,45.14 19.34,36.82 13.97,31.45 12.45,31.45 9.69,28.69 9.69,28.07 v2(8.3,26.69)
  IN3 w0.102: v2(77.7,72.64) 77.63,72.7 77.63,75.34 78.68,76.38 82.14,76.38 84.22,78.46 92.24,78.46 93.03,79.26 97.24,79.26 97.83,78.66 102.31,78.66 103.49,79.84 110.3,79.84 111.31,80.85 114.21,80.85 115.09,81.73 117.39,81.73 119.25,83.58 121.51,83.58 v2(121.91,83.98)
  BOTTOM w0.102: v2(8.3,26.69) 8.33,26.71 U27.14 ; v2(121.91,83.98) 121.91,83.67 122.94,82.64 122.94,80.66 RC181.1
MEDIACARD_PWREN_R: length 34.6
  IN2 w0.076: 126.6,69.84 126.5,69.74 126.5,68.95 v2(126.28,68.72)
  IN2 w0.102: v2(130.17,83.94) 130.17,83.56 129.36,82.74 129.36,80.47 130.56,79.28 130.56,78.22 129.82,77.49 129.82,72.51 127.66,70.35 127.11,70.35 126.6,69.84
  BOTTOM w0.076: v2(126.28,68.72) 126.12,68.57 126.12,67.72 125.75,67.34 UC1.AP1
  BOTTOM w0.102: RC175.1 RC181.2 122.47,82.41 121.5,83.37 121.5,84.18 122.34,85.02 126.78,85.02 128.4,83.4 129.81,83.4 130.17,83.77 v2(130.17,83.94)
MEDIACARD_RST#: length 26.7
  IN2 w0.076: v2(120.97,64.11) 120.56,64.52 120.56,66.92 119.61,67.87 119.61,69.77 119.53,69.84
  IN2 w0.102: v2(116.12,82.8) 115.78,82.46 115.78,79.57 116.33,79.01 116.33,75.81 116.9,75.24 117.48,75.24 119.16,73.55 119.16,70.98 119.3,70.84 119.3,70.07 119.53,69.84
  BOTTOM w0.076: UC1.AG6 121.14,63.93 120.96,64.1 120.97,64.1 v2(120.97,64.11)
  BOTTOM w0.102: v2(116.12,82.8) 115.61,83.3 114.4,83.3 114.07,82.97 114.07,81.05 T191.1
MEM_SMBCLK: length 23
  TOP w0.102: v2(125.45,69.88) 125.11,69.54 122.88,69.54 122.61,69.82 122.61,71.36 121.45,72.51 121.45,73.65 120.62,74.48 120.62,75.05 121.16,75.58 121.16,78.12 122.53,79.49 122.53,80.26 v1(123.05,80.77) 123.29,81.02 RC28.2 123.29,82.22 122.51,83 QC1.6
  BOTTOM w0.076: 125.49,69.84 125.89,69.44 125.89,67.81 125.45,67.37 125.45,67.09 125.75,66.8 UC1.AP2
  BOTTOM w0.102: 125.49,69.84 v2(125.45,69.88)
MEM_SMBDATA: length 16.2
  TOP w0.102: QC1.3 119.91,81.62 RC30.2 119.91,78.93 120.93,77.92 120.93,75.68 120.4,75.14 120.4,74.38 121.22,73.56 121.22,72.42 122.38,71.26 122.38,69.3 v2(122.4,69.27)
  BOTTOM w0.076: UC1.AH1 122,68.87 v2(122.4,69.27)
MINI2CLK_REQ#: length 240.6
  IN2 w0.102: v2(116.15,73.56) 115.85,73.86 115.85,75.19 114.76,76.28 114.31,76.28 113.72,76.88 113.72,78.43 114.08,78.79 114.08,82.92 115.16,84 116.62,84 117.43,84.81 118.04,84.81 118.88,85.65 120.92,85.65 121.38,85.2 123.85,85.2 125.42,86.77 128.81,86.77 129.28,86.3 134.76,86.3 135.45,86.99 140.61,86.99 141.43,86.17 142.9,86.17 144.6,84.47 147.27,84.47 147.95,85.16 147.95,85.96 152.13,90.13 154.23,90.13 154.83,90.73 155.82,90.73 156.37,90.18 156.62,90.18 156.77,90.03 162.24,90.03 162.7,89.58 167.23,89.58 167.46,89.35 173.42,89.35 175.49,91.42 175.49,96.46 176.49,97.46 180.73,97.46 182.28,99.01 182.28,102.67 183.36,103.75 183.36,106.86 184.63,108.13 184.63,111.94 186.16,113.47 186.16,116.65 189.39,119.88 189.39,121.53 191.93,124.07 207.04,124.07 209.17,126.2 210.77,126.2 215.68,131.12 216.51,131.12 225.21,139.81 225.72,139.81 226.55,140.64 226.55,141.17 227.56,142.18 227.56,143.49 237.6,153.54 237.6,154.14 239.26,155.8 239.26,158.08 239.8,158.61 240.97,158.61 242.05,157.53 248.13,157.53 250.49,155.18 251.56,155.18 252.7,156.33 258.49,156.33 259.13,156.96 265.53,156.96 265.89,157.32 274.07,157.32 275.49,155.89 276.42,155.89 v2(276.66,155.65)
  IN3 w0.102: v2(118.39,73.4) 117.79,73.99 116.58,73.99 v2(116.15,73.56)
  BOTTOM w0.076: 113.28,69.84 113.28,69.5 113.76,69.03 UC1.N1
  BOTTOM w0.102: v2(118.39,73.4) 118.14,73.65 RP11.5 ; JMINI1.7 v2(276.66,155.65) ; 113.28,69.84 113.28,71.22 113.91,71.85 115.12,71.85 116.15,72.88 v2(116.15,73.56)
MINI_CARD_RST#: length 91.8
  TOP w0.102: v2(225.59,140.58) 225.17,140.58 v1(224.48,139.89) 220.7,136.11 R26.1 220.05,135.56 U30.4
  IN2 w0.102: v2(281.98,155.5) 281.36,156.12 275.65,156.12 274.22,157.55 265.73,157.55 265.4,157.22 258.99,157.22 258.36,156.58 253.78,156.58 252.26,158.11 242.12,158.11 240.98,159.25 239.79,159.25 238.81,158.27 238.81,155.99 237.15,154.33 237.15,153.73 227.05,143.63 227.05,142.32 225.59,140.86 v2(225.59,140.58)
  BOTTOM w0.102: v2(225.59,140.58) 223.04,140.58 222.92,140.7 JMINI2.22 ; JMINI1.22 285.86,150.16 281.98,154.04 v2(281.98,155.5)
MMICLK_REQ#: length 161.9
  IN2 w0.076: v2(115.22,68.31) 115.68,68.76 115.68,69.52 115.36,69.84
  IN2 w0.102: v2(111.41,77.53) 112.06,76.87 112.06,75.74 113.67,74.13 113.67,72.57 114.86,71.38 114.86,70.35 115.36,69.84 ; v2(76.36,70.1) 76.35,70.1 75.88,69.64 73.94,69.64 70.18,65.88 42.18,65.88 34.7,58.4 34.7,52.18 32.49,49.97 23.79,49.97 19.09,45.27 19.09,36.95 13.82,31.68 11.28,31.68 9.44,29.84 9.44,28.57 8.88,28.01 v2(8.3,28.01)
  IN3 w0.102: v2(114.91,77.52) 114.63,77.52 114.44,77.72 111.6,77.72 v2(111.41,77.53) 111.29,77.41 111.29,74.71 110.9,74.31 109.82,74.31 109.47,74.66 109.47,77.09 107.85,78.71 107.76,78.71 107.12,79.35 103.65,79.35 102.5,78.21 97.64,78.21 97.05,78.8 93.22,78.8 92.43,78.01 84.5,78.01 82.3,75.81 79.63,75.81 78.18,74.36 78.18,71.92 v2(76.36,70.1)
  BOTTOM w0.076: v2(115.22,68.31) 115.39,68.31 115.67,68.02 115.67,67.53 115.55,67.4 115.55,67.02 115.56,67.01 115.56,67.01 116,66.56 UC1.U2
  BOTTOM w0.102: U27.17 8.4,27.91 v2(8.3,28.01) ; RC55.2 114.29,78.15 v2(114.91,77.52) ; v2(76.36,70.1) v1(76.94,70.1)
MODC_EN: length 110.9
  TOP w0.102: v1(184.19,93.23) 184.23,93.27 v2(185.46,93.27) ; v2(168.76,101.4) 168.48,101.67 U37.B7
  IN2 w0.102: v2(185.46,93.27) 184.77,92.58 184.77,76.39 184.07,75.7 182.12,75.7 181.22,74.79 181.22,71.77 179.4,69.96 177.01,69.96 175.93,68.88 175.93,54.49 177.11,53.31 182.73,53.31 187.59,48.44 187.59,41.94 189.71,39.82 189.71,36 191.17,34.54 191.17,30.92 190.35,30.09 190.35,23.93 v2(190.79,23.49)
  BOTTOM w0.102: U29.4 v2(190.79,23.49) ; v2(168.76,101.4) 168.95,101.4 169.2,101.15 169.2,100.39 169.93,99.66 169.93,98.14 170.26,97.81 171.7,97.81 173.26,96.25 174.86,96.25 175.12,95.99 176.64,95.99 178,94.63 182.21,94.63 183.57,93.27 v2(185.46,93.27)
MPCIE_RST#: length 172.2
  TOP w0.102: v1(219.09,132.5) 218.92,132.67 U30.2 218.92,134.17 218.79,134.29 218.1,134.29 217.72,133.91 v2(217.72,133.28)
  IN2 w0.102: v2(117.99,71.2) 117.63,71.2 116.68,72.15 116.52,72.15 115.54,73.13 115.54,74.25 115.62,74.33 115.62,75.09 114.66,76.05 114.22,76.05 113.46,76.81 113.46,78.55 113.85,78.94 113.85,83.14 114.97,84.26 116.55,84.26 117.33,85.04 117.89,85.04 118.76,85.91 120.99,85.91 121.47,85.42 123.75,85.42 125.74,87.42 129.67,87.42 130.43,86.66 134.8,86.66 135.35,87.21 140.71,87.21 141.53,86.4 142.99,86.4 144.7,84.7 147.12,84.7 147.73,85.31 147.73,86.05 152.05,90.37 154.15,90.37 154.74,90.96 155.92,90.96 156.46,90.41 156.71,90.41 156.86,90.26 162.34,90.26 162.79,89.81 167.33,89.81 167.55,89.58 173.33,89.58 175.26,91.51 175.26,96.56 176.39,97.69 180.64,97.69 182.03,99.08 182.03,102.8 182.54,103.31 182.54,106.42 184.38,108.26 184.38,112.07 185.91,113.6 185.91,116.77 189.14,120.01 189.14,121.66 191.78,124.3 206.94,124.3 209.08,126.43 210.64,126.43 217.49,133.28 v2(217.72,133.28)
  BOTTOM w0.076: 116.3,69.84 116.3,68.79 116.4,68.7 116.4,67.57 UC1.V1
  BOTTOM w0.102: 116.3,69.84 116.3,70.24 116.95,70.88 117.68,70.88 v2(117.99,71.2) 118.1,71.2 119.48,72.57 120.34,72.57 120.59,72.83 120.59,76.05 RC138.2
MPHYP_PWR_EN: length 63.9
  TOP w0.102: v2(114.85,85.91) 113.59,87.16 113.03,87.16 112.57,86.7 109.82,86.7 108.96,87.56 106.27,87.56 105.57,86.86 104.75,86.86 104.37,86.48 103.35,86.48 102.01,85.13 v1(100.91,85.13) 95.91,85.13 v2(95.51,84.74) 95.51,83.47 95.35,83.3 Q143.2 ; U94.4 95.05,77.39 v2(94.18,76.52)
  BOTTOM w0.076: 116.57,69.84 116.57,69.83 116.57,67.8 117.05,67.32 117.05,67.02 117.5,66.57 UC1.Y2
  BOTTOM w0.102: v2(114.85,85.91) 115.35,86.41 116.31,86.41 116.54,86.18 118.89,86.18 120.87,84.2 120.87,83.65 119.73,82.52 119.73,78.59 121.52,76.8 121.52,76 RC170.1 121.54,75.07 121.54,73.8 RC169.1 121.07,72.76 120.62,72.32 119.55,72.32 118.44,71.21 118.44,71.03 118.06,70.65 117.04,70.65 116.57,70.18 116.57,69.84 ; v2(94.18,76.52) 94.31,76.65 94.31,77.3 94.23,77.38 94.23,81.04 95.51,82.32 v2(95.51,84.74)
MPHYP_PWR_EN#: length 3.7
  TOP w0.102: v1(98.91,83.95) R108.2 96.87,83.95 Q143.6 96.38,83.95 96.3,83.87 96.3,83.37 96.37,83.3 Q143.5
MSATA_DEVSLP: length 223
  IN1 w0.097: v2(223.24,151.38) 223.81,151.38 226.99,154.55 227.78,154.55 228.38,155.15 234.97,155.15 237.92,158.11 v2(239.9,158.11)
  IN2 w0.102: v2(116.7,72.87) 116.7,74.66 114.85,76.51 114.44,76.51 113.97,76.98 113.97,78.3 114.35,78.68 114.35,81.47 115.16,82.29 115.16,83.11 115.48,83.43 117.51,83.43 117.96,83.87 117.96,84.13 119.25,85.42 120.83,85.42 121.28,84.97 124.25,84.97 125.82,86.54 128.72,86.54 129.32,85.94 134.73,85.94 135.54,86.76 140.52,86.76 141.38,85.89 142.85,85.89 144.53,84.22 147.37,84.22 148.18,85.03 148.18,85.84 152.22,89.88 154.3,89.88 154.93,90.5 155.73,90.5 156.27,89.95 156.52,89.95 156.7,89.78 162.17,89.78 162.6,89.35 167.14,89.35 167.36,89.12 173.52,89.12 175.72,91.32 175.72,95.5 176.44,96.22 176.44,96.94 176.73,97.24 180.84,97.24 182.54,98.93 182.54,102.54 183.62,103.62 183.62,106.73 184.89,108 184.89,111.81 186.41,113.34 186.41,116.45 189.65,119.69 189.65,121.4 192.06,123.82 207.11,123.82 209.27,125.98 214.97,125.98 216.8,127.81 216.8,130.97 222.89,137.06 224.61,137.06 228.14,140.6 228.14,143.58 238.24,153.68 238.24,154.13 239.9,155.79 v2(239.9,158.11)
  BOTTOM w0.076: UC1.P2 114.05,67.02 114.05,67.53 114.19,67.67 114.19,68.82 113.61,69.4 113.61,69.84
  BOTTOM w0.102: v2(223.24,151.38) R480.1 221.41,150.75 220.16,149.5 JMINI2.44 ; v2(116.7,72.87) 116.46,72.87 115.07,71.48 v1(114.53,71.48) 113.86,71.48 113.61,71.23 113.61,69.84
MSCLK: length 27.1
  TOP w0.102: R395.2 149.06,124.63 149.06,124.21 v2(149.2,124.07) 149.2,123.91 149.44,123.66 v1(149.68,123.66) 149.99,123.66 150.25,123.92 150.25,124.1 150.4,124.26 JDEG1.6 ; v2(145.64,107.12) 145.58,107.18 145.58,107.18 145.14,107.61 U38.B43
  IN3 w0.102: v2(145.64,107.12) 145.2,107.56 145.2,108.08 144.12,109.16 144.12,110.17 142.67,111.62 142.67,118.48 143.48,119.3 143.48,120.38 146.91,123.81 146.91,123.97 147.17,124.22 149.05,124.22 v2(149.2,124.07)
MSDATA: length 29.4
  TOP w0.102: JDEG1.7 150.33,124.76 v2(149.8,124.22) 149.62,124.4 149.62,125.21 R398.2 ; R366.2 144.5,114.94 144.5,111.73 144.84,111.39 v1(144.84,111.19) 144.84,110.63 v2(144.82,110.61) 144.84,110.6 144.9,110.6 145.39,110.1 U38.A40
  IN3 w0.102: v2(144.82,110.61) 144,110.61 142.89,111.71 142.89,118.39 143.71,119.2 143.71,120.29 146.08,122.65 147.66,122.65 148.44,123.44 149.45,123.44 149.8,123.78 v2(149.8,124.22)
NB_PSID: length 53.5
  TOP w0.254: v2(114.69,128.1) PL3.1 ; v2(84.05,156.2) 84.25,156.4 84.25,157.27 PJPDC1.1
  IN3 w0.254: v2(84.05,156.2) 84.05,155.22 84.4,154.86 86.6,154.86 88.92,152.54 88.92,145.99 93.83,141.09 101.19,141.09 102.15,140.14 102.15,135.5 109.54,128.1 v2(114.69,128.1)
  BOTTOM w0.102: v1(83.08,156.01) 83.27,156.2 v2(84.05,156.2)
NB_PSID_TS5A63157: length 5.2
  TOP w0.254: PU1.3 124.42,123.07 124.16,123.33 123.47,123.33 122.95,122.81 PD5.1 122.22,122.81 PR9.2 PR8.2
Net_208: length 5.6
  BOTTOM w0.102: 127.87,28.59 127.87,28.48 128.41,27.94 129.69,27.94 131.35,26.27 131.35,25.2
Net_209: length 5.6
  BOTTOM w0.102: 130.65,25.2 130.65,26.33 129.49,27.49 128.17,27.49 127.21,28.46 127.21,28.59
Net_226: length 6.5
  BOTTOM w0.076: 127.85,29.24 128.2,28.89 128.2,28.42
  BOTTOM w0.102: 131.86,25.2 131.86,26.09 129.82,28.13 128.49,28.13 128.2,28.42
NVVDD_GND_SENSE: length 139.8
  IN1 w0.315: v2(33.95,48.12) 34.01,48.19 34.64,48.19 38.01,51.55 39.09,51.55 39.79,52.25 39.79,59.2 42.72,62.14 42.72,63.21 43.87,64.35 46.75,64.35 49.51,67.12 65.01,67.12 65.94,68.05 65.94,70.26 65.03,71.17 63.41,71.17 62.9,71.68 62.9,73.21 63.47,73.78 63.47,78.32 63.83,78.68 64.56,78.68 65.5,79.62 69.47,79.62 70.08,80.23 75.2,80.23 76.68,81.72 76.68,85.34 74.7,87.31 74.7,89.7 73.82,90.58 v2(73.82,91.05) ; v2(49.88,26.6) 49.92,26.56 49.92,25.29 49,24.38 46.8,24.38 46.29,23.86 35.99,23.86 34.3,25.54 32.46,25.54 v2(32.42,25.58)
  IN3 w0.338: v2(33.95,48.12) 33.95,45.65 27.19,38.9 27.19,28.77 27.09,28.66 27.09,27.3 28.76,25.62 32.36,25.62 32.41,25.58 32.42,25.58 v2(32.42,25.58)
  BOTTOM w0.267: PR615.1 53.82,27.55 52.36,26.09 v1(50.89,26.09) 50.14,26.09 49.88,26.34 v2(49.88,26.6) ; 73.7,91.05 v2(73.82,91.05)
  BOTTOM w0.3: UV1.F1 72.67,91.05 73.7,91.05
NVVDD_SENSE: length 137.4
  TOP w0.102: v2(33.95,48.76) v1(34.66,48.76)
  IN1 w0.315: v2(72.3,90.62) 73,90.62 74.14,89.47 74.14,87.08 76.12,85.1 76.12,81.95 74.96,80.79 69.85,80.79 69.24,80.18 65.27,80.18 64.33,79.24 63.6,79.24 62.91,78.55 62.91,74.01 62.34,73.44 62.34,71.45 63.18,70.61 64.8,70.61 65.38,70.03 65.38,68.29 64.78,67.68 49.28,67.68 46.52,64.92 43.63,64.92 42.16,63.44 42.16,62.37 39.23,59.44 39.23,52.48 38.86,52.11 37.78,52.11 34.41,48.75 33.96,48.75 v2(33.95,48.76) ; v2(50.52,26.6) 50.48,26.56 50.48,25.06 49.23,23.81 47.04,23.81 46.52,23.3 35.76,23.3 34.07,24.98 32.46,24.98 v2(32.42,24.95)
  IN3 w0.338: v2(33.95,48.76) 33.63,48.76 33.21,48.34 33.21,45.96 26.45,39.2 26.45,29.07 26.35,28.97 26.35,26.99 28.46,24.88 32.36,24.88 v2(32.42,24.95)
  BOTTOM w0.267: PR618.1 50.52,26.96 v2(50.52,26.6)
  BOTTOM w0.3: UV1.F2 72.3,90.62 v2(72.3,90.62)
O-USR: length 7.5
  BOTTOM w0.102: PR309.1 v1(57.25,14.59)
  BOTTOM w0.203: PU300.9 52.24,15.93 52.55,15.61 53.38,15.61 54.65,14.34 56.11,14.34 56.36,14.09 PR304.2
  BOTTOM w0.254: PR304.2 PR309.1
OCP-I: length 5.6
  BOTTOM w0.102: PR306.1 51.45,13.19 v1(51.45,11.61)
  BOTTOM w0.203: PR301.2 50.98,14.64 51.04,14.71 PU300.12
  BOTTOM w0.254: PR301.2 51.48,14.09 PR306.1
ODD_DA#: length 172.4
  TOP w0.102: v2(111.75,86.03) 111.31,86.03 v1(110.86,85.58) 110.4,85.12 RC137.2
  IN2 w0.076: v2(115.29,63.62) 114.81,64.1 114.81,66.29 113.76,67.33 113.76,68.93 113.13,69.56 112.86,69.84
  IN2 w0.102: v2(129.29,73.31) 129.59,73.61 129.59,79.87 129.13,80.33 129.13,82.85 128.93,83.05 v2(128.93,83.81) ; v2(111.75,86.03) 111.38,86.03 110.21,84.86 110.21,79.29 109.5,78.58 109.5,77.08 109.62,76.96 109.62,74.48 111.69,72.4 111.69,72.05 112.63,71.12 112.63,70.16 112.71,70.08 112.71,69.99 112.86,69.84
  IN3 w0.102: v2(129.29,73.31) 129.45,73.47 132.97,73.47 134.11,74.62 136.04,74.62 136.26,74.4 138.04,74.4 138.25,74.62 148.81,74.62 148.96,74.77 154.84,74.77 155.54,75.47 157.87,75.47 158.29,75.05 158.29,73.4 158.76,72.94 162.55,72.94 163.75,74.13 163.92,74.13 164.27,74.48 169.52,74.48 171.35,72.64 175.99,72.64 177.14,71.49 177.14,56.76 177.71,56.19 183.62,56.19 185.9,53.9 185.9,46.98 186.85,46.03 186.85,38.03 187.74,37.14 190.41,37.14 191.43,38.15 191.43,40.06 193.36,41.99 v2(194.86,41.99)
  BOTTOM w0.076: v2(115.29,63.62) 115.3,63.63 115.43,63.63 UC1.U6
  BOTTOM w0.102: v2(128.93,83.81) 128.93,85.28 124.37,89.84 123.1,89.84 122.53,89.27 122.53,86.34 122.22,86.03 120.12,86.03 119.29,86.86 117.39,86.86 116.98,87.27 115.2,87.27 114.68,86.74 112.45,86.74 v2(111.75,86.03) ; JSATA2.11 v2(194.86,41.99)
P33ALW: length 2.5
  TOP w0.254: PU701.18 126.5,140.67 126.78,140.96 127.91,140.96 PR553.1
P33ALW2: length 3.7
  TOP w0.254: PR550.2 127.23,134.03 v1(126.77,134.48) 126.26,134.99 125.32,134.99 125.03,135.28 PU701.9
P50ALW: length 2.9
  TOP w0.254: PU701.27 121.03,142.14 v1(120.32,142.85) 119.67,143.5 PR536.1
PANEL_BKEN_CVT: length 23.4
  TOP w0.102: v1(100.89,93.49) 100.81,93.56 100.81,94.05 100.86,94.09 U87.1 100.86,95.1 v2(101.19,95.43) ; U52.44 99.41,112.17 v2(99.31,112.07) ; R2586.1 v2(98.66,102.21)
  IN3 w0.102: v2(99.31,112.07) 100.11,111.27 100.11,108.2 99.16,107.24 99.16,105.08 98.66,104.58 v2(98.66,102.21) 98.8,102.21 102.21,98.8 102.21,96.45 v2(101.19,95.43)
PANEL_BKEN_EC: length 83.2
  TOP w0.102: U37.A35 164.73,91.67 v2(165.02,91.39) ; v2(102.97,100.64) 102.97,100.37 v1(102.75,100.16) 102.16,99.56 D80.3
  IN3 w0.102: v2(165.02,91.39) 165.45,90.95 165.45,90.09 163.66,88.3 163.66,86.87 162.54,85.74 162.54,85.21 161.98,84.65 158.37,84.65 157.28,85.74 152.47,85.74 150.06,88.15 143.88,88.15 143.39,88.64 135.63,88.64 134.92,87.93 130.99,87.93 130.25,88.67 121.17,88.67 121.12,88.71 118.79,88.71 v2(117.76,87.69)
  BOTTOM w0.102: v2(102.97,100.64) 103.89,100.64 104.08,100.45 106.97,100.45 109.77,97.65 114.27,97.65 116.75,95.18 116.75,88.73 117.76,87.72 v2(117.76,87.69)
PANEL_BKLEN: length 41.3
  TOP w0.102: v2(101.26,93.84) 101.51,94.09 U87.2
  IN2 w0.102: v2(98.46,85.56) 98.46,84.06 96.94,82.54 96.94,70.41 96.62,70.1 96.62,69.14 96.94,68.83 97.95,68.83 98.68,68.1 98.68,66.65 101.46,63.87 v2(101.61,63.87)
  BOTTOM w0.076: v2(101.61,63.87) 101.61,63.87 102.02,63.87 102.53,63.36 104.25,63.36 v1(104.35,63.26) 104.58,63.26 106.07,61.76 UC1.A9
  BOTTOM w0.102: v2(98.46,85.56) 98.46,89.08 100.56,91.18 100.56,93.14 v2(101.26,93.84)
PBAT_PRES#: length 165.2
  TOP w0.102: U37.B40 165.98,93.68 v2(166.08,93.78)
  TOP w0.254: PR4.2 92.89,169.59 v2(93.18,169.29) ; v2(125.58,128.71) 126.39,129.52 PD4.1 126.67,129.79 PR2.2 ; PU502.1 141.15,127.64 141.45,127.94 v2(141.58,127.94) ; v2(118.97,149.98) 119.68,149.98 119.95,150.25 PQ506.1
  IN1 w0.254: v2(119.37,141.85) 117.74,143.48 117.74,148.74 v2(118.97,149.98)
  IN2 w0.102: v2(141.58,127.94) 144.4,127.94 145.47,129.01 147.46,129.01 149.29,127.18 v2(152.18,127.18)
  IN2 w0.254: v2(125.58,128.71) 128.24,128.71 128.37,128.58 139.23,128.58 139.86,127.94 v2(141.58,127.94)
  IN3 w0.102: v2(166.08,93.78) 163.38,91.08 160.82,91.08 160.4,90.65 157.42,90.65 156.28,91.79 156.28,98.05 156.41,98.18 156.41,102.37 156.31,102.47 156.31,106.35 155.61,107.05 155.03,107.05 153.97,108.11 153.97,111.54 152.45,113.07 152.45,119.51 152.89,119.95 152.89,124.39 153.52,125.02 153.52,126.42 152.75,127.18 v2(152.18,127.18)
  IN3 w0.254: v2(119.37,141.85) 119.37,138.47 121.26,136.57 122.55,136.57 123.87,135.25 123.87,134.6 126.08,132.39 126.08,129.21 v2(125.58,128.71) ; v2(118.97,149.98) 117.24,148.25 115.97,148.25 114.78,147.06 114.78,146.04 112.69,143.95 105.07,143.95 104.3,144.71 104.3,147.69 102.72,149.28 97.89,149.28 96.94,150.23 96.94,151.77 93.02,155.69 91.79,155.69 90.45,157.04 90.45,166.56 v2(93.18,169.29)
