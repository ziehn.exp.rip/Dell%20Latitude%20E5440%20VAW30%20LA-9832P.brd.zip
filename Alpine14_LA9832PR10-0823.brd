# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS#7: length 63.9
  IN1 w0.097: v2(180.25,66.76) 180.44,66.95 180.44,67.05 180.3,67.18 179.29,67.18 178.6,66.49 175.64,66.49 175.25,66.09 163.71,66.09 163.36,65.74 151.52,65.74 150.39,64.6 141.57,64.6 137.22,60.25 136.81,60.25 136.58,60.02 135.5,60.02 135.23,59.75 135.23,58.34 135.23,58.33 135.23,58.19 v2(135.35,58.07)
  BOTTOM w0.076: v2(135.35,58.07) 135.09,57.8 135.09,57.47 134.45,56.83 130.82,56.83 130.04,56.05 130.01,56.05 130,56.06 129.55,56.06 129.31,56.3 129.1,56.3 128.93,56.22 128.74,56.22 128.58,56.3 128.1,56.3 127.94,56.45 127.76,56.45 UC1.AV18
  BOTTOM w0.102: v2(180.25,66.76) 180.57,66.44 180.57,66.21 180.74,66.03 182.03,66.03 182.46,66.47 182.73,66.47 182.95,66.25 JDIMM1.186
DDR_A_MA0: length 60.9
  IN1 w0.076: 137.03,40.16 136.78,40.16 135.47,41.47 135.3,41.47 132.7,44.06 131.7,44.06 131.51,44.26 130.6,44.26 130.39,44.46 128.04,44.46 127.38,45.13 v2(127.38,45.2)
  IN1 w0.14: 137.03,40.16 138.56,40.16 139.22,39.5 157.41,39.5 157.77,39.14 161.3,39.14 162.52,37.92 169.64,37.92 170.44,38.72 181.74,38.72 v2(182.52,39.5)
  BOTTOM w0.076: v2(127.38,45.2) 127.21,45.36 UC1.AU36
  BOTTOM w0.152: v2(182.52,39.5) 182.87,39.85 JDIMM1.98
DDR_A_MA1: length 61.7
  IN1 w0.076: 137.03,41.29 136.79,41.29 136.11,41.97 135.5,41.97 132.91,44.56 131.91,44.56 131.72,44.75 130.94,44.75 130.74,44.96 130.25,44.96 130.15,45.06 v2(130.15,45.25)
  IN1 w0.14: v2(178.71,39.5) 178.71,39.81 178.6,39.93 175.15,39.93 175.01,40.07 175.01,40.38 174.87,40.52 174.59,40.52 174.45,40.38 174.45,40.07 174.31,39.93 173.66,39.93 173.52,40.07 173.52,40.38 173.38,40.52 173.1,40.52 172.96,40.38 172.96,40.07 172.82,39.93 172.07,39.93 171.93,40.07 171.93,40.38 171.79,40.52 171.51,40.52 171.37,40.38 171.37,40.07 171.23,39.93 170.96,39.93 170.82,40.07 170.82,40.24 170.69,40.36 170.38,40.36 170.26,40.24 170.26,40.09 169.65,39.49 163.91,39.49 163.57,39.82 163.34,39.82 163.01,39.49 162.83,39.49 162.61,39.7 162.61,39.88 162.95,40.22 162.95,40.45 162.2,41.19 161.85,41.19 161.4,40.74 161.02,40.74 160.54,41.22 158.5,41.22 157.84,40.56 142.64,40.56 142.46,40.75 142.08,40.75 141.9,40.56 141.29,40.56 141.09,40.77 140.7,40.77 140.5,40.56 139.78,40.56 139.05,41.29 137.03,41.29
  BOTTOM w0.076: UC1.AY37 129.73,44.79 130.15,45.2 v2(130.15,45.25)
  BOTTOM w0.152: v2(178.71,39.5) 178.22,40 177.07,40 176.63,39.55 JDIMM1.97
DDR_A_MA2: length 62.9
  IN1 w0.076: v2(125.66,45.07) 125.67,45.08 126.42,45.08 127.02,45.67 127.47,45.67 127.73,45.41 127.73,45 128.11,44.63 130.48,44.63 130.69,44.42 131.58,44.42 131.77,44.23 132.77,44.23 135.36,41.64 135.62,41.64 136.74,40.51 137.03,40.51
  IN1 w0.14: v2(181,39.5) 180.57,39.08 170.29,39.08 169.99,38.78 162.17,38.78 161.45,39.49 157.92,39.49 157.56,39.85 139.38,39.85 138.72,40.51 137.03,40.51
  BOTTOM w0.076: v2(125.66,45.07) 126.05,44.68 UC1.AR38
  BOTTOM w0.152: JDIMM1.96 183.12,39.25 182.85,38.98 181.52,38.98 v2(181,39.5)
DDR_A_MA3: length 62.7
  IN1 w0.076: 137.03,40.94 136.76,40.94 135.9,41.8 135.43,41.8 132.84,44.4 131.84,44.4 131.65,44.59 130.83,44.59 130.62,44.79 128.18,44.79 127.9,45.07 127.9,45.48 127.54,45.84 126.95,45.84 126.57,45.46 125.49,45.46 v2(125.09,45.07)
  IN1 w0.14: 137.03,40.94 138.79,40.94 139.52,40.21 157.71,40.21 158.07,39.85 158.33,39.85 158.52,40.04 158.52,40.74 158.65,40.87 159.04,40.87 159.17,40.74 159.17,40.04 159.36,39.85 159.63,39.85 159.82,40.04 159.82,40.63 160.01,40.82 160.28,40.82 160.47,40.63 160.47,40.04 160.66,39.85 161.41,39.85 161.54,39.98 161.54,40.38 161.73,40.57 162,40.57 162.19,40.38 162.19,39.26 162.31,39.13 169.84,39.13 170.22,39.5 v2(177.19,39.5)
  BOTTOM w0.076: v2(125.09,45.07) 125.4,45.37 UC1.AP36
  BOTTOM w0.152: v2(177.19,39.5) 176.64,38.95 JDIMM1.95
DDR_A_MA4: length 64.4
  IN1 w0.076: v2(127.35,43.63) 127.88,44.16 130.4,44.16 130.47,44.09 131.44,44.09 131.63,43.9 132.63,43.9 134.8,41.74 134.8,40.34 135.28,39.86 135.55,39.86 136.27,39.14 137.03,39.14
  IN1 w0.14: 137.03,39.14 157.26,39.14 157.62,38.78 159.74,38.78 159.86,38.66 159.86,38.47 159.99,38.34 160.37,38.34 160.5,38.47 160.5,38.66 160.63,38.78 161.15,38.78 161.39,38.55 161.39,37.71 161.55,37.55 170.72,37.55 170.91,37.74 170.91,38.24 171.04,38.37 171.43,38.37 171.56,38.24 171.56,37.74 171.75,37.55 174.47,37.55 174.97,38.05 179.99,38.05 180.24,37.81 v2(180.24,37.22)
  BOTTOM w0.076: v2(127.35,43.63) 127.21,43.76 UC1.AU39
  BOTTOM w0.152: JDIMM1.92 181.07,38.05 v2(180.24,37.22)
DDR_A_MA5: length 62.4
  IN1 w0.076: v2(126.21,44.12) 126.21,44.06 127,43.27 127.49,43.27 127.73,43.51 127.73,43.74 127.98,43.99 130.34,43.99 130.4,43.93 131.37,43.93 131.56,43.73 132.57,43.73 134.63,41.67 134.63,40.28 136.13,38.77 137.01,38.77 137.03,38.79
  IN1 w0.14: v2(178.71,37.22) 178.23,37.7 177,37.7 176.48,37.18 160.36,37.18 159.21,38.33 157.57,38.33 157.16,38.75 137.39,38.75 137.35,38.79 137.03,38.79
  BOTTOM w0.076: v2(126.21,44.12) 126.46,44.38 126.46,44.88 126.05,45.29 UC1.AR36
  BOTTOM w0.152: v2(178.71,37.22) 178.18,37.75 JDIMM1.91
DDR_A_MA6: length 64.3
  IN1 w0.076: v2(130.03,43.63) 130.03,43.47 130.64,42.86 132.97,42.86 134.3,41.53 134.3,40.1 136.05,38.34 136.62,38.34 136.94,38.03 137.03,38.03
  IN1 w0.14: 137.03,38.03 152.18,38.03 152.37,37.84 152.37,36.66 152.56,36.47 152.83,36.47 153.02,36.66 153.02,37.84 153.21,38.03 153.47,38.03 153.66,37.84 153.66,36.66 153.85,36.47 181.02,36.47 v2(181.76,37.22)
  BOTTOM w0.076: v2(130.03,43.63) 129.32,42.92 128.16,42.92 UC1.AV40
  BOTTOM w0.152: JDIMM1.90 182.98,37.45 182.75,37.68 182.19,37.68 181.76,37.26 v2(181.76,37.22)
DDR_A_MA7: length 64.2
  IN1 w0.076: v2(128.81,43.63) 129.75,42.7 132.9,42.7 134.13,41.46 134.13,39.15 136.21,37.07 136.75,37.07
  IN1 w0.14: v2(180.24,35.44) 179.81,35.86 174.5,35.86 174.14,35.51 163.96,35.51 163.35,36.11 151.79,36.11 151.6,36.3 151.6,37.39 151.41,37.58 151.14,37.58 150.95,37.39 150.95,36.44 150.82,36.31 150.43,36.31 150.3,36.44 150.3,37.39 150.11,37.58 139.25,37.58 138.74,37.07 136.75,37.07
  BOTTOM w0.076: v2(128.81,43.63) 128.51,43.93 UC1.AW39
  BOTTOM w0.152: JDIMM1.86 181.05,36.25 v2(180.24,35.44)
DDR_A_MA8: length 62.8
  IN1 w0.076: v2(131.23,43.57) 132.5,43.57 134.46,41.6 134.46,40.17 136.12,38.51 136.7,38.51 136.81,38.39 137.03,38.39
  IN1 w0.14: 137.03,38.39 154.27,38.39 154.4,38.27 154.4,37.02 154.59,36.83 154.86,36.83 155.05,37.02 155.05,38.27 155.17,38.39 155.57,38.39 155.69,38.27 155.69,37.02 155.88,36.83 156.15,36.83 156.34,37.02 156.34,38.27 156.47,38.39 156.86,38.39 156.99,38.27 156.99,37.02 157.18,36.83 157.45,36.83 157.64,37.02 157.64,37.85 157.76,37.98 158.16,37.98 158.28,37.85 158.28,37.02 158.47,36.83 158.74,36.83 158.93,37.02 158.93,37.39 159.12,37.58 159.39,37.58 159.58,37.39 159.58,37.02 159.77,36.83 176.8,36.83 v2(177.19,37.22)
  BOTTOM w0.076: UC1.AY39 130.76,44.04 v2(131.23,43.57)
  BOTTOM w0.152: JDIMM1.89 177.12,37.15 v2(177.19,37.22)
DDR_A_MA9: length 65
  IN1 w0.076: v2(132.54,42) 133.04,42 133.8,41.23 133.8,38.24 135.69,36.36 136.75,36.36
  IN1 w0.14: 136.75,36.36 139.04,36.36 139.55,36.87 143.48,36.87 143.61,36.74 143.61,36.12 143.74,36 144.22,36 144.35,36.12 144.35,36.63 144.54,36.82 144.81,36.82 145,36.63 145,35.59 145.19,35.4 145.46,35.4 145.65,35.59 145.65,36.63 145.84,36.82 146.1,36.82 146.29,36.63 146.29,35.59 146.48,35.4 163.06,35.4 163.66,34.8 174.44,34.8 174.65,35.01 178.29,35.01 v2(178.71,35.44)
  BOTTOM w0.076: v2(132.54,42) 131.78,42.76 127.89,42.76 127.48,43.17 UC1.AU40
  BOTTOM w0.152: JDIMM1.85 178.2,35.95 v2(178.71,35.44)
DDR_A_MA10: length 63.4
  IN1 w0.076: v2(125.73,46.12) 126.07,45.77 126.65,45.77 127.05,46.17 130.6,46.17 130.72,46.04 132.5,46.04 133.11,45.44 133.41,45.44 134.99,43.85 136.75,43.85
  IN1 w0.14: v2(178.71,43.93) 178.29,43.51 177.79,43.51 177.3,43.01 170.37,43.01 169.54,43.84 161.12,43.84 161.11,43.85 158.51,43.85 158.16,43.5 157.56,43.5 156.92,42.86 153.36,42.86 153.36,43.27 153.2,43.43 150.71,43.43 150.53,43.62 150.53,43.72 150.4,43.85 150.07,43.85 149.94,43.72 149.94,42.99 149.81,42.86 149.42,42.86 149.29,42.99 149.29,43.66 149.1,43.85 145.26,43.85 145.13,43.72 145.13,43.51 145.01,43.38 144.61,43.38 144.48,43.51 144.48,43.72 144.36,43.85 143.87,43.85 143.74,43.72 143.74,43.56 143.61,43.43 143.22,43.43 143.09,43.56 143.09,43.72 142.97,43.85 142.48,43.85 142.35,43.72 142.35,43.63 142.22,43.5 141.83,43.5 141.7,43.63 141.7,43.72 141.58,43.85 136.75,43.85
  BOTTOM w0.076: v2(125.73,46.12) 125.4,46.44 UC1.AP35
  BOTTOM w0.152: v2(178.71,43.93) 177.33,42.55 JDIMM1.107
DDR_A_MA11: length 62.5
  IN1 w0.076: v2(128.8,42.06) 129.11,42.37 131.9,42.37 132.18,42.09 132.18,41.77 132.31,41.64 133.16,41.64 133.64,41.17 133.64,37.54 135.17,36 137.03,36
  IN1 w0.14: v2(181.76,35.44) 180.98,34.66 174.8,34.66 174.59,34.44 171.11,34.44 170.5,33.84 164.02,33.84 162.81,35.05 144.18,35.05 143.22,36 137.03,36
  BOTTOM w0.076: UC1.AW41 128.51,42.34 v2(128.8,42.06)
  BOTTOM w0.152: v2(181.76,35.44) 182.21,35.88 182.72,35.88 182.96,35.65 JDIMM1.84
DDR_A_MA12: length 62.9
  IN1 w0.076: 135.97,36.72 133.97,38.71 133.97,41.4 132.83,42.53 127.98,42.53 v2(127.51,42.07)
  IN1 w0.14: v2(177.19,35.44) 174.57,35.44 174.29,35.16 163.81,35.16 163.2,35.76 149.71,35.76 149.52,35.95 149.52,37.1 149.39,37.23 149,37.23 148.87,37.1 148.87,35.95 148.68,35.76 148.41,35.76 148.22,35.95 148.22,37.1 148.1,37.23 147.7,37.23 147.57,37.1 147.57,35.95 147.38,35.76 147.12,35.76 146.93,35.95 146.93,37.01 146.71,37.23 139.4,37.23 138.89,36.72 135.97,36.72
  BOTTOM w0.076: v2(127.51,42.07) 127.51,42.22 UC1.AU41
  BOTTOM w0.152: JDIMM1.83 177.1,35.35 v2(177.19,35.44)
DDR_A_MA13: length 62.9
  IN1 w0.076: 136.75,46.16 136.02,46.16 135.4,46.78 133.31,46.78 132.43,47.65 127.63,47.65 126.39,46.41 v2(126.39,46.14)
  IN1 w0.14: v2(172.99,46.7) 172.52,47.16 171.8,47.16 171.48,46.84 162.45,46.84 161.77,47.51 159.93,47.51 159.8,47.39 159.8,46.98 159.67,46.85 159.06,46.85 158.94,46.98 158.94,47.81 158.81,47.93 158.47,47.93 158.28,47.74 158.28,47.03 158.09,46.84 157.82,46.84 157.63,47.03 157.63,47.74 157.44,47.93 157.18,47.93 156.99,47.74 156.99,47.03 156.8,46.84 156.53,46.84 156.34,47.03 156.34,47.74 156.15,47.93 155.88,47.93 155.69,47.74 155.69,47.03 155.5,46.84 155.23,46.84 155.04,47.03 155.04,47.74 154.85,47.93 154.59,47.93 154.4,47.74 154.4,47.03 154.21,46.84 153.94,46.84 153.75,47.03 153.75,47.74 153.56,47.93 153.29,47.93 153.1,47.74 153.1,47.03 152.91,46.84 152.64,46.84 152.45,47.03 152.45,47.74 152.26,47.93 146.32,47.93 144.54,46.16 136.75,46.16
  BOTTOM w0.076: v2(126.39,46.14) 126.05,46.48 UC1.AR35
  BOTTOM w0.152: v2(172.99,46.7) 173.53,46.15 JDIMM1.119
DDR_A_MA14: length 63
  IN1 w0.076: 137.03,35.29 135.42,35.29 133.31,37.4 133.31,40.67 132.78,41.2 131.33,41.2 v2(130.58,41.95)
  IN1 w0.14: 137.03,35.29 142.93,35.29 143.89,34.34 162.52,34.34 163.73,33.13 174.27,33.13 175.09,33.95 179.7,33.95 v2(180.24,33.41)
  BOTTOM w0.076: UC1.AV42 128.16,41.35 129.98,41.35 v2(130.58,41.95)
  BOTTOM w0.152: JDIMM1.80 181.28,34.45 v2(180.24,33.41)
DDR_A_MA15: length 63.5
  IN1 w0.076: 136.75,35.65 135.29,35.65 133.47,37.47 133.47,40.73 132.85,41.36 131.69,41.36 v2(131.14,41.92)
  IN1 w0.14: 136.75,35.65 143.08,35.65 144.03,34.69 162.67,34.69 163.87,33.48 172.33,33.48 172.93,34.09 174.73,34.09 174.94,34.3 180.87,34.3 v2(181.76,33.41)
  BOTTOM w0.076: v2(131.14,41.92) 130.4,41.18 127.69,41.18 127.42,41.45 127.36,41.45 UC1.AU42
  BOTTOM w0.152: JDIMM1.78 182.21,33.85 v2(181.76,33.41)
DDR_A_RAS#: length 62
  IN1 w0.076: 136.75,44.92 136.08,44.92 134.72,46.28 133.1,46.28 132.23,47.15 129.87,47.15 129.51,46.79 v2(129.51,46.79)
  IN1 w0.14: v2(182.52,43.93) 181.74,44.71 176.65,44.71 176.59,44.65 170.38,44.65 170.09,44.94 162.41,44.94 162.28,45.07 162.28,45.64 162.15,45.77 161.75,45.77 161.62,45.64 161.62,45.07 161.5,44.94 159.48,44.94 158.65,45.77 149.51,45.77 149.34,45.6 149.34,45.04 149.21,44.92 148.79,44.92 148.67,45.04 148.67,45.64 148.54,45.77 148.15,45.77 148.02,45.64 148.02,45.04 147.89,44.92 147.5,44.92 147.37,45.04 147.37,45.64 147.24,45.77 146.85,45.77 146.72,45.64 146.72,45.11 146.53,44.92 136.75,44.92
  BOTTOM w0.076: UC1.AY34 129.16,47.14 v2(129.51,46.79)
  BOTTOM w0.152: JDIMM1.110 182.7,43.45 182.52,43.63 v2(182.52,43.93)
DDR_A_WE#: length 62.8
  IN1 w0.076: 136.75,45.27 135.96,45.27 134.79,46.45 133.17,46.45 132.3,47.31 129.34,47.31 128.81,46.79 v2(128.81,46.78)
  IN1 w0.14: 136.75,45.27 146.24,45.27 146.37,45.4 146.37,46 146.49,46.13 160.73,46.13 160.86,46.25 160.86,46.67 160.98,46.8 161.4,46.8 161.52,46.67 161.52,46.32 161.71,46.13 162.6,46.13 162.82,45.9 162.82,45.42 162.95,45.29 163.34,45.29 163.47,45.42 163.47,45.94 163.66,46.13 169.41,46.13 169.62,45.92 170.28,45.92 170.41,45.79 170.41,45.13 170.53,45.01 171.02,45.01 171.14,45.13 171.14,45.68 171.27,45.81 171.67,45.81 171.8,45.68 171.8,45.13 171.93,45.01 174.05,45.01 174.17,45.13 174.17,45.79 174.3,45.92 174.69,45.92 174.82,45.79 174.82,45.2 174.95,45.07 175.47,45.07 175.6,45.2 175.6,45.59 175.72,45.71 176.12,45.71 176.24,45.59 176.24,45.2 176.37,45.07 178.34,45.07 178.69,45.42 v2(178.69,45.49)
  BOTTOM w0.076: v2(128.81,46.78) 128.81,46.79 128.51,47.09 UC1.AW34
  BOTTOM w0.152: v2(178.69,45.49) 178.69,45.45 177.81,44.57 177.04,44.57 176.82,44.35 JDIMM1.113
DDR_B_BS0: length 62
  IN3 w0.076: 131.58,44.87 127.94,44.87 127.81,44.99 127.81,45.36 127.61,45.55 126.95,45.55 126.82,45.42 124.83,45.42 124.74,45.33 124.74,45.1 124.52,44.87 123.47,44.87 123.3,45.04 123.3,45.77 123.57,46.04 v2(123.73,46.04)
  IN3 w0.152: v2(165.55,43.41) 165.55,43.72 165.43,43.85 163.59,43.85 163.46,43.72 163.46,43.36 163.33,43.24 162.92,43.24 162.8,43.36 162.8,43.72 162.67,43.85 162.26,43.85 162.14,43.72 162.14,43.24 162.01,43.11 161.6,43.11 161.48,43.24 161.48,43.72 161.35,43.85 158.61,43.85 158.48,43.72 158.48,43.34 158.35,43.22 155.56,43.22 155.43,43.34 155.43,44.77 155.31,44.9 154.9,44.9 154.77,44.77 154.77,43.34 154.65,43.22 154.24,43.22 154.11,43.34 154.11,46.07 153.99,46.19 135.81,46.19 135.66,46.04 135.66,45.46 135.53,45.33 135.13,45.33 135,45.46 135,46.04 134.85,46.19 134.4,46.19 134.27,46.07 134.27,44.99 134.14,44.87 133.74,44.87 133.61,44.99 133.61,45.65 133.48,45.77 133.08,45.77 132.95,45.65 132.95,44.99 132.82,44.87 131.58,44.87
  BOTTOM w0.076: UC1.AL35 123.45,46.32 v2(123.73,46.04)
  BOTTOM w0.152: v2(165.55,43.41) 165.07,42.93 165.07,42.66 164.88,42.47 164.06,42.47 163.9,42.63 163.9,42.94 163.68,43.15 JDIMM2.109
DDR_B_BS1: length 62.4
  IN3 w0.076: v2(124.39,45.24) 124.22,45.24 124.09,45.37 124.09,45.58 124.22,45.71 124.57,45.71 124.69,45.59 126.74,45.59 126.87,45.72 132.64,45.72
  IN3 w0.152: 132.64,45.72 132.94,46.02 133.88,46.02 134.42,46.56 154.35,46.56 154.48,46.43 154.48,45.39 154.61,45.27 155.01,45.27 155.14,45.39 155.14,46.43 155.27,46.56 155.67,46.56 155.8,46.43 155.8,43.71 155.93,43.59 156.33,43.59 156.46,43.71 156.46,46.43 156.59,46.56 157,46.56 157.12,46.43 157.12,43.71 157.25,43.59 157.66,43.59 157.78,43.71 157.78,45.1 157.91,45.23 158.32,45.23 158.44,45.1 158.44,44.34 158.57,44.21 165.58,44.21 165.86,43.93 167.17,43.93 167.69,43.41 v2(167.84,43.41)
  BOTTOM w0.076: v2(124.39,45.24) 124.1,45.53 UC1.AM36
  BOTTOM w0.152: JDIMM2.108 169.5,42.85 169.28,42.63 168.17,42.63 167.84,42.96 v2(167.84,43.41)
DDR_B_BS2: length 58.1
  IN3 w0.152: v2(165.66,34.27) 165.66,35.01 165.53,35.14 164.39,35.14 163.83,34.57 163.83,33.7 163.55,33.42 153.9,33.42 153.77,33.54 153.77,34.02 153.64,34.15 153.24,34.15 153.11,34.02 153.11,33.54 152.98,33.42 152.58,33.42 152.45,33.54 152.45,34.02 152.32,34.15 151.91,34.15 151.79,34.02 151.79,33.54 151.66,33.42 151.25,33.42 151.13,33.54 151.13,34.02 151,34.15 150.59,34.15 150.47,34.02 150.47,33.54 150.34,33.42 149.93,33.42 149.81,33.54 149.81,34.02 149.68,34.15 149.27,34.15 149.15,34.02 149.15,33.54 149.02,33.42 148.61,33.42 148.49,33.54 148.49,34.02 148.36,34.15 147.95,34.15 147.83,34.02 147.83,33.54 147.7,33.42 147.29,33.42 147.16,33.54 147.16,34.02 147.04,34.15 146.63,34.15 146.5,34.02 146.5,33.54 146.38,33.42 145.97,33.42 145.84,33.54 145.84,34.02 145.72,34.15 145.31,34.15 145.18,34.02 145.18,33.54 145.06,33.42 144.65,33.42 144.52,33.54 144.52,34.02 144.4,34.15 143.99,34.15 143.86,34.02 143.86,33.57 143.74,33.44 143.33,33.44 143.2,33.57 143.2,34.02 143.08,34.15 142.67,34.15 142.54,34.02 142.54,33.54 142.42,33.42 141.59,33.42 141.46,33.54 141.46,34.7 141.33,34.83 140.93,34.83 140.8,34.7 140.8,34.39 140.67,34.26 140.27,34.26 140.14,34.39 140.14,34.76 140.01,34.89 136.04,34.89 133.26,37.67 131.82,37.67 131.65,37.85 128,37.85 v2(127.54,37.39)
  BOTTOM w0.076: v2(127.54,37.39) 127.54,37.47 UC1.AU49
  BOTTOM w0.152: JDIMM2.79 163.55,34.15 163.87,33.83 165.22,33.83 v2(165.66,34.27)
DDR_B_CAS#: length 62.8
  IN3 w0.076: v2(124.36,47.05) 124.22,47.05 123.8,46.63 123.8,46.46 123.92,46.34 124.1,46.34 124.25,46.49 126.59,46.49 127.04,46.05 128.82,46.05 128.93,46.16 128.93,46.31 128.82,46.42 127.3,46.42 127.05,46.68 127.05,47.17 127.18,47.3
  IN3 w0.152: 127.18,47.3 131.87,47.3 132.03,47.15 132.03,46.79 132.21,46.6 132.58,46.6 132.69,46.71 132.69,47.15 132.84,47.3 133.19,47.3 133.35,47.15 133.35,46.83 133.47,46.7 133.88,46.7 134.01,46.83 134.01,47.15 134.16,47.3 157.76,47.3 157.88,47.17 157.88,46.09 158.01,45.96 158.42,45.96 158.54,46.09 158.54,47.17 158.67,47.3 159.08,47.3 159.2,47.17 159.2,45.08 159.33,44.95 165.88,44.95 166.17,44.67 167.43,44.67 167.54,44.78 167.54,45.05 v2(167.08,45.51)
  BOTTOM w0.076: UC1.AM33 124.24,47.49 124.36,47.36 v2(124.36,47.05)
  BOTTOM w0.152: v2(167.08,45.51) 167.08,45.11 166.91,44.95 JDIMM2.115
DDR_B_D0: length 53.3
  IN3 w0.076: 133.55,25.9 133.04,26.41 132.68,26.41 128.09,31 126.23,31 125.88,31.36 v2(125.73,31.36)
  IN3 w0.102: v2(164.17,17.51) 164.17,17.22 163.86,16.91 163.05,16.91 162.91,17.05 162.91,17.78 162.78,17.9 162.54,17.9 162.42,17.78 162.42,17.21 162.29,17.08 162.02,17.08 161.89,17.21 161.89,17.81 161.8,17.9 161.42,17.9 161.33,18 160.8,18 160.49,18.32 160.34,18.32 159.9,17.87 159.72,17.87 159.54,18.05 159.54,18.23 159.98,18.67 159.98,18.82 159.77,19.03 159.62,19.03 159.18,18.59 159,18.59 158.82,18.77 158.82,18.95 159.26,19.39 159.26,19.54 159.05,19.75 158.9,19.75 158.46,19.31 158.28,19.31 158.1,19.49 158.1,19.67 158.54,20.11 158.54,20.26 157.46,21.34 138.11,21.34 133.55,25.9
  BOTTOM w0.076: v2(125.73,31.36) 125.4,31.68 UC1.AP58
  BOTTOM w0.102: JDIMM2.33 163.73,17.95 v2(164.17,17.51)
DDR_B_D1: length 53
  IN3 w0.076: 133.99,25.9 133.6,26.28 133.6,26.84 130.35,30.09 129.23,30.09 127.97,31.36 v2(126.38,31.36)
  IN3 w0.102: v2(165.7,17.51) 165.93,17.51 166.09,17.67 166.09,18.05 165.94,18.2 163.85,18.2 163.72,18.07 163.72,17.47 163.59,17.34 163.34,17.34 163.21,17.47 163.21,18.1 163.1,18.21 161.55,18.21 161.45,18.3 160.93,18.3 157.58,21.65 138.24,21.65 133.99,25.9
  BOTTOM w0.076: v2(126.38,31.36) 126.05,31.68 UC1.AR58
  BOTTOM w0.102: v2(165.7,17.51) 166.07,17.88 166.07,18.42 165.95,18.55 JDIMM2.35
DDR_B_D2: length 56
  IN3 w0.076: 130.85,25.9 127.98,28.78 125.54,28.78 124.09,30.22 123.83,30.22 122.85,31.21 122.85,31.57 123.15,31.87 123.99,31.87 v2(124.41,32.3)
  IN3 w0.102: v2(165.7,14.27) 165.13,14.84 164.25,14.84 164.19,14.9 160.05,14.9 155.44,19.51 137.24,19.51 130.85,25.9
  BOTTOM w0.076: UC1.AM57 124.1,32.61 v2(124.41,32.3)
  BOTTOM w0.102: v2(165.7,14.27) 165.02,14.95 JDIMM2.23
DDR_B_D3: length 57.6
  IN3 w0.076: v2(123.13,32.26) 123.12,32.25 123.12,32.07 122.69,31.64 122.69,31.14 122.91,30.92 123.77,30.06 124.03,30.06 125.47,28.61 127.64,28.61 130.35,25.9
  IN3 w0.102: 130.35,25.9 137.05,19.2 153.09,19.2 153.21,19.08 153.21,18.31 153.34,18.18 153.6,18.18 153.72,18.31 153.72,19.07 153.85,19.2 154.1,19.2 154.23,19.07 154.23,18.31 154.36,18.18 154.61,18.18 154.74,18.31 154.74,19.07 154.87,19.2 155.12,19.2 155.25,19.07 155.25,18.32 155.39,18.18 156.33,18.18 159.92,14.59 161.77,14.59 161.87,14.49 161.87,14.17 161.98,14.06 162.24,14.06 162.38,14.2 162.38,14.49 162.48,14.59 162.79,14.59 162.89,14.49 162.89,14.17 163,14.06 163.25,14.06 163.39,14.2 163.39,14.47 163.52,14.59 163.78,14.59 163.88,14.49 163.88,14.39 164,14.27 v2(164.17,14.27)
  BOTTOM w0.076: v2(123.13,32.26) 122.8,32.58 UC1.AK57
  BOTTOM w0.102: JDIMM2.21 164.1,14.35 v2(164.17,14.27)
DDR_B_D4: length 55.4
  IN3 w0.076: v2(123.82,31.37) 123.82,31.28 125.99,29.11 128.51,29.11 131.72,25.9
  IN3 w0.102: 131.72,25.9 137.49,20.12 155.69,20.12 159.64,16.17 161.11,16.17 161.77,15.51 164.44,15.51 164.5,15.45 168.28,15.45 168.75,14.99 v2(168.75,14.27)
  BOTTOM w0.076: UC1.AL58 123.69,31.81 123.82,31.68 v2(123.82,31.37)
  BOTTOM w0.102: v2(168.75,14.27) 169.12,14.65 JDIMM2.22
DDR_B_D5: length 56.8
  IN3 w0.076: 131.28,25.9 128.24,28.94 125.61,28.94 123.21,31.35 v2(123.21,31.36)
  IN3 w0.102: v2(167.22,14.27) 166.35,15.14 164.37,15.14 164.31,15.2 160.18,15.2 155.56,19.81 137.37,19.81 131.28,25.9
  BOTTOM w0.076: v2(123.21,31.36) 123.21,31.25 123.08,31.12 122.63,31.12 122.5,31.25 122.5,31.68 122.63,31.81 UC1.AK58
  BOTTOM w0.102: JDIMM2.24 168.2,15.25 v2(167.22,14.27)
DDR_B_D6: length 53.6
  IN3 w0.076: 134.85,25.9 134.1,26.65 134.1,26.85 130.5,30.45 129.38,30.45 127.9,31.93 126.73,31.93 v2(126.44,32.22)
  IN3 w0.102: 134.85,25.9 138.49,22.26 157.84,22.26 161.18,18.91 161.71,18.91 161.8,18.82 169.34,18.82 169.47,18.69 169.47,17.63 169.34,17.51 v2(168.75,17.51)
  BOTTOM w0.076: UC1.AR57 126.05,32.63 126.44,32.25 v2(126.44,32.22)
  BOTTOM w0.102: v2(168.75,17.51) 169.49,18.25 JDIMM2.34
DDR_B_D7: length 55.5
  IN3 w0.076: 134.42,25.9 133.86,26.46 133.86,26.86 130.45,30.27 129.31,30.27 127.81,31.77 125.63,31.77 125.08,32.31 v2(125.08,32.31)
  IN3 w0.102: v2(167.22,17.51) 167.22,17.85 167.35,17.97 168.07,17.97 168.2,18.1 168.2,18.39 168.07,18.51 161.68,18.51 161.58,18.61 161.05,18.61 157.71,21.95 138.36,21.95 134.42,25.9
  BOTTOM w0.076: v2(125.08,32.31) 124.75,32.63 UC1.AN57
  BOTTOM w0.102: v2(167.22,17.51) 168.57,18.85 JDIMM2.36
DDR_B_D8: length 54.1
  IN3 w0.076: 135.76,26.48 135.6,26.48 134.96,27.12 134.53,27.12 130.12,31.53 129.07,31.53 128.78,31.83 128.78,32.17 128.52,32.43 127.66,32.43 127.18,32.91 126.14,32.91 125.78,33.26 v2(125.73,33.26)
  IN3 w0.102: v2(164.49,20.05) 164.74,20.05 164.86,20.17 164.86,20.56 164.41,21.02 164.05,21.02 163.92,20.89 163.92,20.06 163.8,19.94 163.54,19.94 163.41,20.06 163.41,20.89 163.29,21.02 163.03,21.02 162.91,20.89 162.91,20.06 162.78,19.94 162.53,19.94 162.4,20.06 162.4,20.87 162.27,21 162.07,21 161.95,21.12 161.95,21.33 161.17,22.11 160.13,22.11 158.86,23.38 144.09,23.38 143.82,23.64 143.82,23.98 143.69,24.1 143.5,24.1 143.37,23.98 143.37,23.74 143.25,23.61 142.99,23.61 142.85,23.76 142.85,23.95 142.72,24.08 139.96,24.08 139.73,24.3 139.73,24.55 139.61,24.67 139.45,24.67 139.33,24.55 139.33,24.27 139.24,24.18 139.04,24.18 138.92,24.3 138.92,24.6 138.8,24.72 138.63,24.72 138.51,24.6 138.51,24.4 138.42,24.31 138.22,24.31 138.11,24.41 138.11,24.54 137.97,24.68 137.67,24.68 135.87,26.48 135.76,26.48
  BOTTOM w0.076: v2(125.73,33.26) 125.4,33.59 UC1.AP55
  BOTTOM w0.102: v2(164.49,20.05) 164.18,20.35 JDIMM2.41
DDR_B_D9: length 53.6
  IN3 w0.076: v2(126.38,33.26) 127.06,33.26 127.73,32.59 128.59,32.59 129.49,31.7 130.19,31.7 134.54,27.34 134.99,27.34 135.64,26.69 136.1,26.69
  IN3 w0.102: v2(169.06,20.05) 169.32,20.05 169.45,20.17 169.45,21 169.32,21.12 169.07,21.12 168.94,21 168.94,20.63 168.84,20.53 168.53,20.53 168.43,20.63 168.43,20.95 168.33,21.06 168.03,21.06 167.92,20.95 167.92,20.63 167.82,20.53 167.52,20.53 167.42,20.63 167.42,20.95 167.31,21.06 164.8,21.06 164.54,21.32 162.39,21.32 161.3,22.41 160.25,22.41 158.93,23.73 144.59,23.73 143.9,24.42 140.42,24.42 139.81,25.04 137.75,25.04 136.1,26.69
  BOTTOM w0.076: UC1.AR55 126.05,33.59 v2(126.38,33.26)
  BOTTOM w0.102: v2(169.06,20.05) 169.66,20.65 JDIMM2.42
DDR_B_D10: length 57
  IN3 w0.076: v2(124.43,34.21) 124.78,34.57 125.35,34.57 125.51,34.73 126.76,34.73 127.36,34.13 128.16,34.13 128.87,33.42 130.65,33.42 136.06,28 136.88,28
  IN3 w0.102: v2(167.54,23.09) 167.54,23.37 167.66,23.49 169.44,23.49 169.57,23.62 169.57,24.69 169.44,24.82 160.47,24.82 159.71,25.58 145.46,25.58 144.08,26.96 138.46,26.96 137.41,28 136.88,28
  BOTTOM w0.076: UC1.AM54 124.1,34.54 v2(124.43,34.21)
  BOTTOM w0.102: v2(167.54,23.09) 168.1,23.65 JDIMM2.52
DDR_B_D11: length 57.9
  IN3 w0.076: 136.88,28.31 135.99,28.31 130.72,33.58 129.17,33.58 127.86,34.9 125.44,34.9 125.28,34.73 124.71,34.73 124.55,34.57 123.48,34.57 123.11,34.2 v2(123.09,34.2)
  IN3 w0.102: 136.88,28.31 137.54,28.31 138.59,27.26 144.21,27.26 145.59,25.88 159.85,25.88 160.61,25.12 169.74,25.12 169.87,24.99 169.87,22.27 169.74,22.14 169.19,22.14 169.06,22.27 v2(169.06,23.09)
  BOTTOM w0.076: UC1.AK54 122.8,34.49 123.09,34.2 v2(123.09,34.2)
  BOTTOM w0.102: v2(169.06,23.09) 169.1,23.05 JDIMM2.50
DDR_B_D12: length 56.9
  IN3 w0.076: v2(123.78,33.26) 123.8,33.26 124.16,32.91 125.9,32.91 126.07,32.74 127.12,32.74 127.59,32.26 128.11,32.26 129,31.37 130.05,31.37 134.53,26.89 134.92,26.89 135.58,26.23 135.69,26.23 136.02,25.9
  IN3 w0.102: v2(166.01,20.05) 166.01,19.75 165.89,19.63 162.14,19.63 161.64,20.13 161.64,21.2 161.05,21.8 160.44,21.8 160.02,21.38 159.87,21.38 159.62,21.63 159.62,21.77 159.73,21.89 159.73,22.07 159.55,22.25 159.37,22.25 159.26,22.13 159.11,22.13 158.9,22.35 158.9,22.49 159.01,22.61 159.01,22.79 158.84,22.97 158.66,22.97 158.54,22.85 158.39,22.85 158.17,23.07 142.77,23.07 142.56,23.28 142.56,23.64 142.43,23.77 142.18,23.77 142.05,23.64 142.05,23.2 141.93,23.07 141.67,23.07 141.55,23.2 141.55,23.64 141.42,23.77 141.16,23.77 141.04,23.64 141.04,23.2 140.91,23.07 140.7,23.07 140.57,23.2 140.57,23.64 140.44,23.77 138.15,23.77 136.02,25.9
  BOTTOM w0.076: v2(123.78,33.26) 123.45,33.59 UC1.AL55
  BOTTOM w0.102: v2(166.01,20.05) 165.51,19.55 164.06,19.55 163.85,19.75 JDIMM2.39
DDR_B_D13: length 57.7
  IN3 w0.076: v2(123.13,33.21) 123.43,32.91 123.92,32.91 124.09,32.74 125.83,32.74 126,32.58 127.05,32.58 127.53,32.1 127.97,32.1 129.44,30.62 130.56,30.62 134.47,26.71 134.84,26.71 135.65,25.9
  IN3 w0.102: 135.65,25.9 135.65,25.84 138.03,23.47 139.08,23.47 139.21,23.34 139.21,22.89 139.34,22.77 139.59,22.77 139.72,22.89 139.72,23.34 139.84,23.47 140.1,23.47 140.23,23.34 140.23,22.86 140.32,22.77 158.05,22.77 159.74,21.07 160.15,21.07 160.57,21.5 160.75,21.5 160.93,21.32 160.93,21.17 160.62,20.87 160.62,20.72 162.01,19.33 167.31,19.33 167.54,19.55 v2(167.54,20.05)
  BOTTOM w0.076: UC1.AK55 122.8,33.54 v2(123.13,33.21)
  BOTTOM w0.102: v2(167.54,20.05) 168.22,19.36 169.2,19.36 169.89,20.05 JDIMM2.40
DDR_B_D14: length 54.6
  IN3 w0.076: v2(126.38,34.21) 126.81,34.21 127.94,33.09 130.52,33.09 136.21,27.4 136.88,27.4
  IN3 w0.102: v2(164.49,23.09) 164.49,23.57 164.61,23.7 166.19,23.7 166.32,23.82 166.32,24.08 166.19,24.21 164.11,24.21 163.98,24.08 163.98,23.03 163.85,22.9 163.6,22.9 163.47,23.03 163.47,24.08 163.34,24.21 163.09,24.21 162.96,24.08 162.96,23.03 162.84,22.9 162.58,22.9 162.46,23.03 162.46,24.08 162.33,24.21 162.07,24.21 161.95,24.08 161.95,23.78 161.82,23.65 160.77,23.65 159.46,24.97 145.21,24.97 143.83,26.35 138.21,26.35 137.16,27.4 136.88,27.4
  BOTTOM w0.076: UC1.AR54 126.05,34.54 v2(126.38,34.21)
  BOTTOM w0.102: v2(164.49,23.09) 164.23,23.35 JDIMM2.51
DDR_B_D15: length 56.3
  IN3 w0.076: 136.88,27.7 136.14,27.7 130.58,33.25 128.01,33.25 126.69,34.57 125.58,34.57 125.23,34.21 v2(125.08,34.21)
  IN3 w0.102: 136.88,27.7 137.28,27.7 138.33,26.65 143.95,26.65 145.34,25.27 159.59,25.27 160.9,23.96 161.28,23.96 161.83,24.51 168.65,24.51 168.78,24.38 168.78,24.13 168.65,24 166.93,24 v2(166.01,23.09)
  BOTTOM w0.076: UC1.AN54 124.75,34.54 v2(125.08,34.21)
  BOTTOM w0.102: JDIMM2.53 165.15,23.95 v2(166.01,23.09)
DDR_B_D16: length 80.9
  IN3 w0.076: v2(123.13,42.69) 122.73,42.3 122.24,42.3 120.54,40.6 120.54,33.68 119.67,32.81 119.67,32.27 119.28,31.88 119.28,29.39 120.36,28.31 120.36,27.61 121.13,26.84 121.33,26.84
  IN3 w0.102: v2(167.22,8.94) 167.22,8.67 167.08,8.53 161.56,8.53 161.33,8.76 161.33,9.31 161.21,9.44 160.44,9.44 155.32,14.56 147.53,14.56 147.43,14.66 147.43,14.94 147.31,15.06 147.05,15.06 146.92,14.94 146.92,14.66 146.82,14.56 146.52,14.56 146.42,14.66 146.42,14.94 146.29,15.06 146.04,15.06 145.91,14.94 145.91,14.66 145.81,14.56 145.5,14.56 145.4,14.66 145.4,14.94 145.27,15.06 145.02,15.06 144.89,14.94 144.89,14.66 144.79,14.56 144.49,14.56 144.38,14.66 144.38,14.94 144.26,15.06 144,15.06 143.88,14.94 143.88,14.66 143.77,14.56 143.47,14.56 143.37,14.66 143.37,14.94 143.24,15.06 136.58,15.06 130.12,21.52 127.47,21.52 124.32,24.66 122.77,24.66 122.3,25.14 122.3,25.87 121.33,26.84
  BOTTOM w0.076: UC1.AK40 122.8,43.02 v2(123.13,42.69)
  BOTTOM w0.102: JDIMM2.6 168.13,9.85 v2(167.22,8.94)
DDR_B_D17: length 80.2
  IN3 w0.076: v2(123.08,41.78) 122.98,41.78 120.87,39.67 120.87,33.54 120,32.67 120,32.14 119.61,31.74 119.61,29.53 120.73,28.4 122.84,28.4 123.62,27.63 123.62,26.51 124.23,25.9
  IN3 w0.102: v2(165.7,8.94) 166.12,9.36 168.45,9.36 168.58,9.49 168.58,9.74 168.45,9.87 165.89,9.87 165.36,9.35 162.17,9.35 162.03,9.49 162.03,10.5 161.94,10.59 160.15,10.59 155.06,15.67 136.83,15.67 130.3,22.2 127.92,22.2 124.23,25.9
  BOTTOM w0.076: v2(123.08,41.78) 122.8,42.05 UC1.AK42
  BOTTOM w0.102: JDIMM2.7 164.49,10.15 v2(165.7,8.94)
DDR_B_D18: length 77.7
  IN3 w0.076: 127.82,25.9 125.62,28.1 124.37,28.1 122.58,29.9 122.58,30.24 122.19,30.63 122.19,31.71 121.53,32.37 121.53,39.08 122.08,39.63 122.85,40.4 124.18,40.4 124.3,40.52 v2(124.3,40.83)
  IN3 w0.102: v2(165.7,11.99) 165.7,12.89 165.57,13.02 165.32,13.02 165.19,12.89 165.19,12.52 165.06,12.39 164.81,12.39 164.68,12.52 164.68,12.89 164.56,13.02 160.01,13.02 155.76,17.27 147.14,17.27 147.01,17.4 147.01,18.08 146.91,18.18 146.63,18.18 146.5,18.06 146.5,17.37 146.4,17.27 146.12,17.27 146,17.4 146,18.08 145.9,18.18 145.62,18.18 145.49,18.06 145.49,17.37 145.39,17.27 145.11,17.27 144.98,17.4 144.98,18.08 144.88,18.18 144.6,18.18 144.47,18.06 144.47,17.37 144.37,17.27 144.09,17.27 143.96,17.4 143.96,18.08 143.86,18.18 143.58,18.18 143.46,18.06 143.46,17.37 143.36,17.27 143.08,17.27 142.95,17.4 142.95,18.08 142.85,18.18 142.57,18.18 142.44,18.06 142.44,17.37 142.34,17.27 142.06,17.27 141.93,17.4 141.93,18.08 141.83,18.18 136.49,18.18 130.55,24.12 129.6,24.12 127.82,25.9
  BOTTOM w0.076: v2(124.3,40.83) 124.3,41.12 UC1.AM43
  BOTTOM w0.102: v2(165.7,11.99) 164.54,13.15 JDIMM2.17
DDR_B_D19: length 77.3
  IN3 w0.076: 127.1,28.43 124.51,28.43 123.13,29.81 123.13,30.34 122.52,30.95 122.52,31.85 121.86,32.51 121.86,38.95 122.35,39.44 124.27,39.44 124.37,39.54 v2(124.37,39.87)
  IN3 w0.102: 127.1,28.43 136.74,18.79 150.57,18.79 150.67,18.69 150.67,18.01 150.8,17.88 151.08,17.88 151.18,17.98 151.18,18.67 151.31,18.79 151.59,18.79 151.69,18.69 151.69,18.01 151.81,17.88 152.09,17.88 152.19,17.98 152.19,18.67 152.32,18.79 152.6,18.79 152.7,18.69 152.7,18.01 152.83,17.88 156.01,17.88 160.26,13.63 168.49,13.63 168.62,13.5 168.62,12.62 168.75,12.5 169,12.5 169.13,12.62 169.13,13.73 169.25,13.86 169.51,13.86 169.64,13.73 169.64,12.11 169.51,11.99 v2(168.75,11.99)
  BOTTOM w0.076: v2(124.37,39.87) 124.37,40.07 UC1.AM45
  BOTTOM w0.102: v2(168.75,11.99) 169.61,12.85 JDIMM2.16
DDR_B_D20: length 77.7
  IN3 w0.076: 128.29,25.9 125.92,28.27 124.44,28.27 122.83,29.87 122.83,30.32 122.35,30.8 122.35,31.78 121.7,32.44 121.7,39.02 122.57,39.89 v2(123.07,39.89)
  IN3 w0.102: 128.29,25.9 129.74,24.45 130.65,24.45 136.61,18.49 147.19,18.49 147.32,18.36 147.32,17.82 147.44,17.69 147.7,17.69 147.83,17.82 147.83,18.36 147.95,18.49 148.21,18.49 148.33,18.36 148.33,17.7 148.46,17.57 148.74,17.57 148.84,17.68 148.84,18.36 148.97,18.49 149.25,18.49 149.35,18.39 149.35,17.7 149.48,17.57 149.76,17.57 149.86,17.68 149.86,18.36 149.98,18.49 150.26,18.49 150.37,18.39 150.37,17.7 150.49,17.57 155.88,17.57 160.13,13.33 166.08,13.33 166.21,13.2 166.21,12.52 166.33,12.39 166.59,12.39 166.71,12.52 166.71,13.2 166.84,13.33 168.19,13.33 168.31,13.2 168.31,12.52 168.19,12.39 167.87,12.39 167.74,12.52 167.74,12.69 167.61,12.82 167.35,12.82 167.22,12.69 v2(167.22,11.99)
  BOTTOM w0.076: v2(123.07,39.89) 122.8,40.15 UC1.AK45
  BOTTOM w0.102: JDIMM2.18 168.68,13.45 v2(167.22,11.99)
DDR_B_D21: length 79.2
  IN3 w0.076: 121.8,31.52 121.8,31.68 121.37,32.11 121.37,39.22 122.98,40.83 v2(123,40.83)
  IN3 w0.102: 121.8,31.52 121.46,31.18 121.18,31.18 121.05,31.06 121.05,30.38 121.16,30.28 121.99,30.28 122.12,30.15 122.12,29.9 121.99,29.77 121.16,29.77 121.03,29.64 121.03,29.28 121.16,29.15 123.07,29.15 124.3,27.93 125.37,27.93 129.48,23.82 130.42,23.82 136.36,17.88 137.44,17.88 137.56,17.75 137.56,17.09 137.69,16.96 137.94,16.96 138.07,17.09 138.07,17.75 138.2,17.88 138.45,17.88 138.58,17.75 138.58,17.38 138.71,17.25 138.96,17.25 139.09,17.38 139.09,17.75 139.21,17.88 139.47,17.88 139.6,17.75 139.6,17.09 139.72,16.96 139.98,16.96 140.1,17.09 140.1,17.75 140.23,17.88 140.48,17.88 140.61,17.75 140.61,17.09 140.74,16.96 140.99,16.96 141.12,17.09 141.12,17.75 141.25,17.88 141.5,17.88 141.63,17.75 141.63,17.09 141.75,16.96 155.63,16.96 159.88,12.72 161,12.72 161.13,12.59 161.13,11.95 161.25,11.82 161.51,11.82 161.63,11.95 161.63,12.59 161.76,12.72 162.02,12.72 162.14,12.59 162.14,11.95 162.27,11.82 162.52,11.82 162.65,11.95 162.65,12.59 162.78,12.72 163.03,12.72 163.16,12.59 163.16,11.99 163.29,11.86 163.54,11.86 163.67,11.99 163.67,12.59 163.79,12.72 164.05,12.72 164.17,12.59 v2(164.17,11.99)
  BOTTOM w0.076: UC1.AK43 123,41.12 v2(123,40.83)
  BOTTOM w0.102: JDIMM2.15 163.66,12.55 163.96,12.85 164.14,12.85 164.49,12.49 164.49,12.31 v2(164.17,11.99)
DDR_B_D22: length 79.6
  IN3 w0.076: v2(124.43,42.69) 123.95,43.17 122.29,43.17 120.38,41.26 120.38,33.75 119.5,32.87 119.5,32.34 119.11,31.95 119.11,29.33 120.19,28.25 120.19,27.32 121.61,25.9
  IN3 w0.102: 121.61,25.9 121.9,25.61 121.9,25.22 122.94,24.18 124.38,24.18 127.42,21.14 130.07,21.14 136.45,14.76 142.84,14.76 143.34,14.25 155.19,14.25 161.22,8.22 168.03,8.22 v2(168.75,8.94)
  BOTTOM w0.076: UC1.AM40 124.1,43.02 v2(124.43,42.69)
  BOTTOM w0.102: v2(168.75,8.94) 169.06,9.25 JDIMM2.4
DDR_B_D23: length 78.5
  IN3 w0.076: 123.4,26.29 123.4,27.61 122.77,28.24 120.66,28.24 119.44,29.46 119.44,31.81 119.83,32.21 119.83,32.74 120.71,33.61 120.71,40.53 122.31,42.13 124.3,42.13 124.38,42.06 v2(124.38,41.78)
  IN3 w0.102: v2(164.17,8.94) 161.87,8.94 161.64,9.17 161.64,9.62 161.51,9.74 160.56,9.74 155.45,14.86 155.04,14.86 154.94,14.96 154.94,15.27 154.84,15.37 154.54,15.37 154.43,15.27 154.43,14.96 154.33,14.86 154.03,14.86 153.93,14.96 153.93,15.27 153.82,15.37 153.52,15.37 153.42,15.27 153.42,14.96 153.32,14.86 153.01,14.86 152.91,14.96 152.91,15.27 152.81,15.37 152.5,15.37 152.4,15.27 152.4,14.96 152.3,14.86 152,14.86 151.89,14.96 151.89,15.27 151.79,15.37 151.49,15.37 151.39,15.27 151.39,14.96 151.28,14.86 150.98,14.86 150.88,14.96 150.88,15.27 150.78,15.37 150.47,15.37 150.37,15.27 150.37,14.96 150.27,14.86 149.96,14.86 149.86,14.96 149.86,15.24 149.74,15.37 149.48,15.37 149.35,15.24 149.35,14.99 149.23,14.86 148.97,14.86 148.85,14.99 148.85,15.24 148.72,15.37 148.47,15.37 148.34,15.24 148.34,14.96 148.24,14.86 147.93,14.86 147.83,14.96 147.83,15.24 147.7,15.37 136.7,15.37 130.2,21.87 127.82,21.87 123.4,26.29
  BOTTOM w0.076: UC1.AM42 124.1,42.05 v2(124.38,41.78)
  BOTTOM w0.102: JDIMM2.5 163.56,9.55 v2(164.17,8.94)
DDR_B_D24: length 57.5
  IN3 w0.076: 131.75,35.78 130.02,35.78 129.41,36.39 127.49,36.39 126.77,37.11 126.77,38.04 126.52,38.28 124.86,38.28 124.66,38.49 124.26,38.49 v2(123.83,38.92)
  IN3 w0.102: v2(164.41,29.39) 163.96,29.85 162.53,29.85 162.4,29.72 162.4,29.25 162.32,29.17 162.02,29.17 161.89,29.3 161.89,29.72 161.76,29.85 160.6,29.85 160.45,29.71 160.45,29.31 160.33,29.18 160.07,29.18 159.95,29.31 159.95,29.94 159.82,30.06 159.57,30.06 159.44,29.94 159.44,29.31 159.31,29.18 159.06,29.18 158.93,29.31 158.93,29.94 158.8,30.06 158.55,30.06 158.42,29.94 158.42,29.31 158.3,29.18 158.04,29.18 157.91,29.31 157.91,29.96 157.79,30.09 157.53,30.09 157.41,29.96 157.41,29.31 157.28,29.18 157.03,29.18 156.9,29.31 156.9,29.96 156.77,30.09 156.52,30.09 156.39,29.96 156.39,29.31 156.26,29.18 156.01,29.18 155.88,29.31 155.88,29.96 155.76,30.09 155.5,30.09 155.37,29.96 155.37,29.31 155.3,29.24 154.99,29.24 154.88,29.35 154.88,29.96 154.76,30.08 146.02,30.08 145.74,30.36 140.07,30.36 138.74,31.69 135.84,31.69 131.75,35.78
  BOTTOM w0.076: UC1.AM46 124.1,39.19 v2(123.83,38.92)
  BOTTOM w0.102: JDIMM2.69 163.77,28.75 v2(164.41,29.39)
DDR_B_D25: length 56.7
  IN3 w0.076: 136.88,28.99 135.78,28.99 130.82,33.95 129.39,33.95 128.11,35.23 125.56,35.23 125.16,35.63 124.37,35.63 124.07,35.93 124.07,36.34 123.81,36.61 123,36.61 122.03,37.59 122.03,38 v2(123,38.97)
  IN3 w0.102: v2(166.01,25.63) 164.95,26.69 146.84,26.69 146.72,26.82 146.72,27.3 146.59,27.42 146.34,27.42 146.21,27.3 146.21,26.82 146.08,26.69 145.83,26.69 145.7,26.82 145.7,27.3 145.57,27.42 145.1,27.42 144.65,27.87 138.94,27.87 137.82,28.99 136.88,28.99
  BOTTOM w0.076: v2(123,38.97) 122.8,39.17 UC1.AK46
  BOTTOM w0.102: v2(166.01,25.63) 165.55,26.09 164.37,26.09 164.03,25.75 JDIMM2.59
DDR_B_D26: length 54.6
  IN3 w0.076: 136.88,29.6 135.66,29.6 130.97,34.28 129.53,34.28 128.25,35.56 125.7,35.56 124.93,36.33 124.93,36.4 v2(124.36,36.96)
  IN3 w0.102: v2(169.06,25.63) 169.06,26.53 168.93,26.66 168.68,26.66 168.55,26.53 168.55,26.23 168.42,26.1 168.17,26.1 168.04,26.23 168.04,26.53 167.92,26.66 166.26,26.66 165.62,27.3 149.49,27.3 149.36,27.43 149.36,27.91 149.23,28.03 148.98,28.03 148.85,27.91 148.85,27.43 148.72,27.3 148.47,27.3 148.34,27.43 148.34,27.91 148.22,28.03 145.35,28.03 144.9,28.48 139.19,28.48 138.07,29.6 136.88,29.6
  BOTTOM w0.076: UC1.AM49 124.1,37.23 v2(124.36,36.96)
  BOTTOM w0.102: v2(169.06,25.63) 169.24,25.45 JDIMM2.58
DDR_B_D27: length 54.1
  IN3 w0.076: 131.39,36.55 127.56,36.55 126.95,37.17 126.95,38.09 126.59,38.45 125.45,38.45 124.63,39.28 123.68,39.28 123.47,39.07 123.47,38.74 122.8,38.06 122.8,37.32 v2(123.1,37.02)
  IN3 w0.102: 131.39,36.55 135.95,32 138.86,32 140.19,30.67 145.87,30.67 146.12,30.42 164.91,30.42 v2(165.93,29.39)
  BOTTOM w0.076: UC1.AK49 122.8,37.31 v2(123.1,37.02)
  BOTTOM w0.102: v2(165.93,29.39) 164.69,28.15 JDIMM2.67
DDR_B_D28: length 55.9
  IN3 w0.076: 131.42,35.42 129.91,35.42 129.28,36.06 127.36,36.06 126.04,37.37 125.29,37.37 124.7,37.97 v2(124.43,37.97)
  IN3 w0.102: 131.42,35.42 135.77,31.08 138.49,31.08 139.81,29.75 145.49,29.75 145.77,29.47 151.94,29.47 152.24,29.17 152.24,28.73 152.37,28.6 152.62,28.6 152.75,28.73 152.75,29.17 152.87,29.29 153.13,29.29 153.26,29.17 153.26,28.7 153.41,28.55 163.93,28.55 164.02,28.64 167.84,28.64 167.97,28.76 167.97,28.86 168.09,28.99 168.35,28.99 168.47,28.86 168.47,27.7 168.6,27.57 168.86,27.57 168.98,27.7 v2(168.98,29.39)
  BOTTOM w0.076: UC1.AM48 124.1,38.29 v2(124.43,37.97)
  BOTTOM w0.102: JDIMM2.70 169.64,29.05 169.48,28.88 169.11,28.88 168.98,29.01 v2(168.98,29.39)
DDR_B_D29: length 55.4
  IN3 w0.076: 131.53,35.6 129.96,35.6 129.35,36.22 127.42,36.22 126.11,37.54 125.36,37.54 124.57,38.32 123.56,38.32 v2(123.15,37.92)
  IN3 w0.102: v2(167.46,29.39) 167.05,28.98 163.77,28.98 163.65,28.86 161.82,28.86 161.59,29.09 161.59,29.42 161.46,29.54 160.9,29.54 160.77,29.42 160.77,28.95 160.7,28.88 154.7,28.88 154.58,29 154.58,29.47 154.45,29.6 154.2,29.6 154.07,29.47 154.07,29 153.94,28.88 153.69,28.88 153.56,29 153.56,29.47 153.26,29.77 145.9,29.77 145.62,30.06 139.94,30.06 138.61,31.39 135.75,31.39 131.53,35.6
  BOTTOM w0.076: UC1.AK48 122.8,38.27 v2(123.15,37.92)
  BOTTOM w0.102: v2(167.46,29.39) 168.4,28.45 JDIMM2.68
DDR_B_D30: length 53.3
  IN3 w0.076: 136.88,29.3 135.71,29.3 130.89,34.12 129.46,34.12 128.18,35.39 125.63,35.39 124.98,36.05 v2(124.46,36.05)
  IN3 w0.102: 136.88,29.3 137.95,29.3 139.07,28.17 144.78,28.17 145.23,27.73 146.9,27.73 147.02,27.6 147.02,27.12 147.15,27 147.4,27 147.53,27.12 147.53,27.6 147.66,27.73 147.91,27.73 148.04,27.6 148.04,27.12 148.17,27 165.49,27 166.14,26.35 167.41,26.35 167.54,26.23 v2(167.54,25.63)
  BOTTOM w0.076: v2(124.46,36.05) 124.1,36.4 UC1.AM51
  BOTTOM w0.102: JDIMM2.56 168.31,24.85 v2(167.54,25.63)
DDR_B_D31: length 52.5
  IN3 w0.076: 136.88,28.69 135.85,28.69 130.75,33.79 129.32,33.79 128.04,35.06 125.49,35.06 125.09,35.47 123.64,35.47 123.09,36.02 v2(123.09,36.07)
  IN3 w0.102: v2(164.49,25.63) 164.49,26.26 164.36,26.39 163.88,26.39 163.75,26.26 163.75,25.76 163.62,25.63 163.26,25.63 163.13,25.76 163.13,26.26 163.01,26.39 162.75,26.39 162.63,26.26 162.63,25.73 162.52,25.63 162.22,25.63 162.12,25.73 162.12,26.26 161.99,26.39 161.74,26.39 161.61,26.26 161.61,25.73 161.51,25.63 160.82,25.63 160.7,25.76 160.7,26.26 160.57,26.39 145.7,26.39 144.52,27.57 138.81,27.57 137.69,28.69 136.88,28.69
  BOTTOM w0.076: v2(123.09,36.07) 122.8,36.36 UC1.AK51
  BOTTOM w0.102: JDIMM2.57 164.01,25.15 v2(164.49,25.63)
DDR_B_D32: length 54.2
  IN3 w0.076: v2(123.61,49.39) 123.65,49.39 124.63,48.41 125.46,48.41 125.83,48.78 128.63,48.78 129.41,49.56 136.36,49.56 136.65,49.85 136.88,49.85
  IN3 w0.102: 136.88,49.85 142.09,49.85 142.8,50.56 145.97,50.56 146.08,50.46 146.08,49.93 146.16,49.85 146.54,49.85 146.61,49.93 146.61,50.49 146.69,50.57 147.04,50.57 147.12,50.49 147.12,49.93 147.2,49.85 147.55,49.85 147.63,49.93 147.63,50.49 147.71,50.57 148.05,50.57 148.14,50.49 148.14,49.93 148.21,49.85 148.57,49.85 148.64,49.93 148.64,50.49 148.73,50.57 149.07,50.57 149.15,50.49 149.15,49.93 149.23,49.85 149.58,49.85 149.66,49.93 149.66,50.49 149.74,50.57 150.09,50.57 150.17,50.49 150.17,49.93 150.24,49.85 150.6,49.85 150.68,49.93 150.68,50.49 150.76,50.57 151.1,50.57 151.18,50.49 151.18,49.95 151.29,49.85 151.66,49.85 151.76,49.95 151.76,50.46 151.87,50.57 152.18,50.57 152.29,50.46 152.29,49.98 152.42,49.85 162.97,49.85 164.54,48.28 v2(164.69,48.28)
  BOTTOM w0.076: UC1.AM29 124.1,49.8 123.7,49.39 v2(123.61,49.39)
  BOTTOM w0.102: JDIMM2.129 163.81,49.15 v2(164.69,48.28)
DDR_B_D33: length 55.6
  IN3 w0.076: v2(122.5,49.47) 122.74,49.47 123.96,48.25 125.53,48.25 125.9,48.62 128.7,48.62 129.48,49.4 136.43,49.4 136.58,49.55 136.88,49.55
  IN3 w0.102: 136.88,49.55 142.82,49.55 142.91,49.64 142.91,50.16 143.01,50.26 143.31,50.26 143.42,50.16 143.42,49.62 143.49,49.55 143.85,49.55 143.92,49.62 143.92,50.16 144.03,50.26 144.33,50.26 144.43,50.16 144.43,49.62 144.51,49.55 144.88,49.55 144.95,49.62 144.95,50.16 145.05,50.26 145.36,50.26 145.46,50.16 145.46,49.65 145.56,49.55 162.84,49.55 164.59,47.79 169.11,47.79 169.26,47.94 v2(169.26,48.28)
  BOTTOM w0.076: UC1.AK29 122.8,49.8 122.48,49.47 122.48,49.47 v2(122.5,49.47)
  BOTTOM w0.102: JDIMM2.130 169.66,49.45 169.26,49.05 v2(169.26,48.28)
DDR_B_D34: length 55
  IN3 w0.076: v2(123.16,50.35) 123.5,50 123.73,50 124.33,49.41 124.33,49.18 124.77,48.74 125.32,48.74 125.69,49.11 128.49,49.11 129.27,49.89 130.2,49.89 131.04,50.74 136.4,50.74 136.61,50.54 136.94,50.54
  IN3 w0.102: 136.94,50.54 141.91,50.54 142.55,51.18 156.02,51.18 156.16,51.03 156.16,50.59 156.29,50.46 156.54,50.46 156.65,50.57 156.65,51.07 156.75,51.17 157.06,51.17 157.16,51.07 157.16,50.6 157.3,50.46 157.61,50.46 157.72,50.57 157.72,51.04 157.85,51.17 158.1,51.17 158.23,51.04 158.23,50.6 158.37,50.46 163.25,50.46 164.47,49.24 165.5,49.24 166.05,48.68 167.33,48.68 v2(167.73,48.28)
  BOTTOM w0.076: UC1.AL28 123.45,50.74 123.16,50.45 v2(123.16,50.35)
  BOTTOM w0.102: v2(167.73,48.28) 167.73,48.94 168.84,50.05 JDIMM2.132
DDR_B_D35: length 55.1
  IN3 w0.076: 136.88,50.17 136.74,50.17 136.29,49.73 129.34,49.73 128.56,48.95 125.77,48.95 125.39,48.58 124.7,48.58 124.15,49.12 124.15,49.35 123.68,49.83 123.05,49.83 122.6,50.27 122.6,50.35 v2(122.6,50.35)
  IN3 w0.102: 136.88,50.17 141.98,50.17 142.68,50.87 152.6,50.87 152.71,50.76 152.71,50.26 152.81,50.16 153.11,50.16 153.21,50.26 153.21,50.75 153.31,50.85 153.62,50.85 153.72,50.75 153.72,50.26 153.82,50.16 154.13,50.16 154.23,50.26 154.23,50.75 154.33,50.85 154.64,50.85 154.74,50.75 154.74,50.26 154.84,50.16 155.14,50.16 155.25,50.26 155.25,50.75 155.35,50.85 155.65,50.85 155.75,50.75 155.75,50.28 155.88,50.16 163.1,50.16 164.32,48.93 165.37,48.93 166.02,48.28 v2(166.21,48.28)
  BOTTOM w0.076: UC1.AK28 122.6,50.61 122.6,50.35 v2(122.6,50.35)
  BOTTOM w0.102: JDIMM2.131 164.02,49.75 164.56,49.2 165.28,49.2 v2(166.21,48.28)
DDR_B_D36: length 52.2
  IN3 w0.076: 136.88,52.38 136.35,52.38 135.68,51.71 128.42,51.71 126.69,49.98 126.23,49.98 125.88,50.33 v2(125.7,50.33)
  IN3 w0.102: v2(164.74,52.44) 164.33,52.85 163.68,52.85 163.42,52.59 159.61,52.59 158.42,53.79 154.31,53.79 154.19,53.66 154.19,53.19 154.06,53.07 148.17,53.07 148.07,53.17 148.07,53.69 147.97,53.79 147.66,53.79 147.56,53.69 147.56,53.17 147.46,53.07 147.16,53.07 147.05,53.17 147.05,53.69 146.95,53.79 146.65,53.79 146.55,53.69 146.55,53.17 146.44,53.07 146.14,53.07 146.04,53.17 146.04,53.69 145.94,53.79 145.63,53.79 145.53,53.69 145.53,53.17 145.43,53.07 145.12,53.07 145.02,53.17 145.02,53.69 144.92,53.79 144.62,53.79 144.51,53.69 144.51,53.17 144.41,53.07 144.11,53.07 144.01,53.17 144.01,53.69 143.9,53.79 143.6,53.79 143.5,53.69 143.5,53.17 143.4,53.07 143.09,53.07 142.99,53.17 142.99,53.69 142.89,53.79 142.58,53.79 142.48,53.69 142.48,53.17 142.38,53.07 141.7,53.07 141.01,52.38 136.88,52.38
  BOTTOM w0.076: v2(125.7,50.33) 126.05,49.98 UC1.AR29
  BOTTOM w0.102: JDIMM2.141 163.54,52.75 163.74,52.95 164.23,52.95 v2(164.74,52.44)
DDR_B_D37: length 54.1
  IN3 w0.076: 136.88,51.77 136.35,51.77 135.91,51.33 130.93,51.33 130.32,50.72 127.9,50.72 126.83,49.65 126.09,49.65 125.93,49.81 125.3,49.81 125.03,49.54 v2(125.03,49.46)
  IN3 w0.102: 136.88,51.77 141.27,51.77 141.95,52.46 158.89,52.46 159.53,51.82 163.6,51.82 163.68,51.73 164.22,51.73 164.34,51.62 164.34,51.16 164.46,51.04 164.72,51.04 164.84,51.16 164.84,51.65 164.93,51.73 165.24,51.73 165.34,51.63 165.34,51.38 165.43,51.29 165.76,51.29 165.85,51.37 165.85,51.63 165.95,51.73 166.25,51.73 166.35,51.63 166.35,51.35 166.48,51.22 166.73,51.22 166.86,51.35 166.86,51.63 166.96,51.73 167.27,51.73 167.37,51.63 167.37,51.35 167.5,51.22 167.75,51.22 167.88,51.35 167.88,51.91 168,52.04 168.32,52.04 168.45,51.91 168.45,51.21 168.58,51.08 169.18,51.08 169.31,51.21 v2(169.31,52.44)
  BOTTOM w0.076: v2(125.03,49.46) 124.75,49.73 UC1.AN29
  BOTTOM w0.102: v2(169.31,52.44) 169.31,52.81 169.55,53.05 JDIMM2.142
DDR_B_D38: length 52.4
  IN3 w0.076: 136.88,52.72 136.45,52.72 135.61,51.87 128.35,51.87 126.81,50.33 v2(126.38,50.33)
  IN3 w0.102: 136.88,52.72 140.92,52.72 142.3,54.1 142.94,54.1 143.04,54.2 143.04,54.6 143.16,54.72 143.43,54.72 143.55,54.6 143.55,54.2 143.65,54.1 143.96,54.1 144.05,54.19 144.05,54.6 144.17,54.72 144.44,54.72 144.56,54.6 144.56,54.2 144.67,54.1 144.98,54.1 145.07,54.19 145.07,54.6 145.19,54.72 145.46,54.72 145.58,54.6 145.58,54.2 145.69,54.1 145.99,54.1 146.09,54.19 146.09,54.6 146.2,54.72 146.47,54.72 146.59,54.6 146.59,54.2 146.7,54.1 147.01,54.1 147.07,54.16 147.07,54.63 147.17,54.72 147.49,54.72 147.58,54.63 147.58,54.23 147.72,54.1 158.54,54.1 159.74,52.9 163.13,52.9 163.43,53.2 166.07,53.2 166.26,53.01 v2(166.26,52.44)
  BOTTOM w0.076: v2(126.38,50.33) 126.05,50.66 UC1.AR28
  BOTTOM w0.102: JDIMM2.143 165.35,53.35 v2(166.26,52.44)
DDR_B_D39: length 53.2
  IN3 w0.076: v2(125.07,50.27) 125.36,49.98 126,49.98 126.16,49.81 126.76,49.81 127.83,50.89 130.25,50.89 130.87,51.5 135.77,51.5 136.35,52.07 136.88,52.07
  IN3 w0.102: v2(167.78,52.44) 167.38,52.04 163.81,52.04 163.73,52.12 159.65,52.12 159.02,52.76 158.2,52.76 158.07,52.89 158.07,53.36 157.95,53.49 157.69,53.49 157.57,53.36 157.57,52.89 157.44,52.76 157.16,52.76 157.03,52.89 157.03,53.36 156.91,53.49 156.65,53.49 156.52,53.36 156.52,52.89 156.4,52.76 156.14,52.76 156.02,52.89 156.02,53.36 155.89,53.49 155.64,53.49 155.51,53.36 155.51,52.89 155.38,52.76 155.13,52.76 155,52.89 155,53.36 154.87,53.49 154.62,53.49 154.49,53.36 154.49,52.89 154.37,52.76 141.82,52.76 141.14,52.07 136.88,52.07
  BOTTOM w0.076: v2(125.07,50.27) 125.07,50.39 125.4,50.73 UC1.AP28
  BOTTOM w0.102: JDIMM2.140 169.89,52.45 169.44,52 168.23,52 v2(167.78,52.44)
DDR_B_D40: length 52
  IN3 w0.076: v2(125.08,51.37) 125.41,51.03 126.81,51.03 129.12,53.34 135.45,53.34 135.7,53.59 136.12,53.59 136.37,53.84 136.88,53.84
  IN3 w0.102: 136.88,53.84 140.12,53.84 142.19,55.91 150.89,55.91 150.98,55.82 150.98,55.34 151.11,55.21 151.36,55.21 151.49,55.34 151.49,55.85 151.57,55.93 151.91,55.93 152,55.85 152,55.34 152.12,55.21 152.38,55.21 152.5,55.34 152.5,55.79 152.63,55.92 152.89,55.92 153.01,55.79 153.01,55.34 153.14,55.21 153.39,55.21 153.52,55.34 153.52,55.85 153.6,55.93 153.95,55.93 154.03,55.85 154.03,55.34 154.16,55.21 154.41,55.21 154.54,55.34 154.54,55.85 154.62,55.93 154.96,55.93 155.04,55.85 155.04,55.34 155.17,55.21 155.43,55.21 155.55,55.34 155.55,55.85 155.63,55.93 155.98,55.93 156.06,55.85 156.06,55.34 156.19,55.21 159.01,55.21 160.2,54.02 162.66,54.02 162.97,54.32 164.33,54.32 v2(164.74,54.73)
  BOTTOM w0.076: UC1.AN26 124.75,51.69 v2(125.08,51.37)
  BOTTOM w0.102: v2(164.74,54.73) 164.29,54.28 163.74,54.28 163.47,54.55 JDIMM2.147
DDR_B_D41: length 51.1
  IN3 w0.076: v2(126.4,51.4) 126.94,51.4 129.05,53.51 135.38,53.51 135.63,53.75 135.99,53.75 136.41,54.17 136.88,54.17
  IN3 w0.102: 136.88,54.17 140.02,54.17 142.08,56.23 156.25,56.23 156.38,56.11 156.38,55.65 156.5,55.52 156.76,55.52 156.88,55.65 156.88,56.15 157,56.27 157.27,56.27 157.39,56.15 157.39,55.65 157.52,55.52 157.79,55.52 157.92,55.65 157.92,56.15 158.04,56.27 158.31,56.27 158.43,56.15 158.43,55.65 158.55,55.52 159.13,55.52 159.82,54.83 163.49,54.83 163.79,55.13 165.05,55.13 165.05,55.13 167.91,55.13 167.91,55.14 168.17,55.14 168.48,55.44 169.18,55.44 169.31,55.31 v2(169.31,54.73)
  BOTTOM w0.076: UC1.AR26 126.05,51.76 126.4,51.41 v2(126.4,51.4)
  BOTTOM w0.102: v2(169.31,54.73) 169.43,54.85 JDIMM2.148
DDR_B_D42: length 50.2
  IN3 w0.076: v2(126.38,52.32) 127.16,52.32 129.5,54.66 130.2,54.66 130.79,55.26 136.04,55.26 136.2,55.43 136.88,55.43
  IN3 w0.102: 136.88,55.43 139.51,55.43 141.6,57.51 158.99,57.51 160.02,56.48 161.55,56.48 161.68,56.61 161.68,57.14 161.78,57.24 162.09,57.24 162.19,57.14 162.19,56.58 162.32,56.46 164.74,56.46 164.84,56.56 164.84,56.81 164.97,56.94 165.22,56.94 165.35,56.81 165.35,56.56 165.45,56.46 166.11,56.46 166.26,56.61 v2(166.26,57.78)
  BOTTOM w0.076: v2(126.38,52.32) 126.05,52.64 UC1.AR25
  BOTTOM w0.102: v2(166.26,57.78) 165.69,58.35 163.8,58.35 163.6,58.15 JDIMM2.159
