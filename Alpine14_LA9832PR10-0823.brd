# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOARD_ID: length 15.9
  TOP w0.102: R392.2 C368.1 145.19,88.94 145.48,89.23 145.48,90.9 145.77,91.19 v1(145.77,91.57) 145.77,92.05 145.33,92.5 145.33,93.97 v2(145.52,94.16) ; U38.B10 145.64,100.32 145.84,100.52 v2(146.06,100.52)
  IN1 w0.097: v2(145.52,94.16) 145.52,94.86 146.98,96.32 146.98,98.29 146.53,98.73 146.53,100.05 v2(146.06,100.52)
BOOT_1.35V: length 5.9
  TOP w0.102: v1(180.64,79.09) 180.43,79.3 180.43,79.57 PR100.2
  TOP w0.203: PU100.18 178.38,81.98
  TOP w0.508: 178.38,81.98 178.91,81.98 179.42,81.47 PR100.2
BPM#0: length 9.9
  BOTTOM w0.076: UC1.J60 111.8,30.24 111.8,29.77 111.76,29.73 111.76,28.94 111.93,28.78 111.93,28.27 111.93,27.97 111.39,27.43 111.39,25.9
  BOTTOM w0.102: 111.39,25.9 v1(111.39,25.54) 111.39,21.68 RC194.1
BPM#1: length 13.3
  IN1 w0.097: v2(112.16,19.55) 112.19,19.57 112.19,19.66 112.75,20.23 112.75,25.45 110.59,27.61 110.59,29.73 v2(111.09,30.24)
  BOTTOM w0.076: UC1.H60 110.79,30.54 v2(111.09,30.24)
  BOTTOM w0.102: RC204.1 112.16,19.04 v2(112.16,19.55)
BQ24715_3.3V: length 21.1
  TOP w0.254: v2(111.84,142.8) PU402.5 ; PR425.2 PR428.1 PR427.2 105.46,150.15 104.99,149.69 103.73,149.69 103.3,150.12 102.91,150.12 102.68,149.88 v1(102.68,149.7) 102.68,149.19 102.89,148.97 102.89,147.39 v2(103.16,147.12)
  IN3 w0.254: v2(103.16,147.12) 103.16,144.24 104.6,142.8 v2(111.84,142.8)
BQ24715_REGN: length 56.3
  TOP w0.102: v1(108.29,138.87) 108.05,139.11 v2(108.05,139.44)
  TOP w0.254: PR425.1 107.3,148.97 107.03,148.71 ; v2(103.67,121.53) 103.92,121.28 PR448.1 ; PR431.1 v2(116.12,147.31) ; 107.03,148.71 105.83,148.71 105.48,149.06 PD401.2 v2(104.37,148.33) ; 107.03,148.71 107.35,148.39 PC410.1 108.05,147.25 108.05,147.06 108.7,146.41 PU402.16
  IN1 w0.254: v2(104.37,148.33) 104.37,144.01 105.51,142.87 105.51,141.98 v2(108.05,139.44) 112.21,139.44 115.13,142.36 116.24,142.36 116.81,142.93 116.81,146.61 v2(116.12,147.31)
  IN2 w0.254: v2(102.42,131.56) 103.57,132.71 103.57,135.53 107.48,139.44 v2(108.05,139.44)
  IN3 w0.254: v2(102.42,131.56) 102.42,122.59 103.48,121.53 v2(103.67,121.53)
BREATH_LED#: length 136
  TOP w0.102: U37.B39 165.48,93.3 165.65,93.47 165.65,93.96 v2(166.1,94.41) ; Q28.1 190.98,88.84 R436.1 189.32,88.84 188.73,89.42 v1(188.73,90.17) 188.73,90.5 v2(188.25,90.99)
  IN1 w0.097: v2(166.1,94.41) 166.1,95.06 166.5,95.46 166.5,99.39 166.85,99.75 166.85,102.1 166.11,102.84 166.11,105.19 164.8,106.5 164.8,108.04 165.52,108.77 165.52,112.02 169.26,115.76 171.09,115.76 172.29,116.96 176.44,116.96 177.14,117.66 178.08,117.66 178.59,118.17 184.73,118.17 v2(186.31,119.75)
  IN3 w0.102: v2(186.31,119.75) 186.31,121.63 179.3,128.64 179.3,131.5 180.25,132.45 180.25,134.21 179.95,134.51 179.95,135.58 180.25,135.88 180.25,138.87 181.33,139.95 181.33,144.2 182.47,145.34 182.47,148.71 181.08,150.11 181.08,152.14 178.98,154.23 178.98,159.14 177.99,160.13 177.99,161.99 178.41,162.41 178.41,163.63 178.66,163.88 178.66,166.11 v2(178.47,166.3)
  BOTTOM w0.102: v2(178.47,166.3) 177.71,167.06 176.82,167.06 175.5,168.38 175.06,168.38 173.45,169.99 JDOCK1.98 ; v2(188.25,90.99) 186.85,90.99 185.72,89.85 169.57,89.85 169.01,90.42 169.01,90.96 168.08,91.89 168.08,92.13 166.53,93.67 166.53,94.1 166.22,94.41 v2(166.1,94.41)
BREATH_LED#_Q: length 146
  TOP w0.102: v2(194.6,89.27) 194.17,88.84 Q28.6 ; v2(272.07,153.98) 272.07,155.82 277.15,160.9 277.15,163.19 279.37,165.41 281.02,165.41 281.55,165.93 JPWR1.4
  IN2 w0.102: v2(194.6,89.27) 195.43,90.1 195.43,119.56 196.75,120.88 206.11,120.88 209.68,124.45 215.56,124.45 235.62,144.52 235.62,146.8 239.43,150.61 242.42,150.61 243.12,151.31 248.17,151.31 248.49,150.99 251.43,150.99 255.43,154.99 261.72,154.99 262.67,154.04 269.91,154.04 270.29,154.42 271.63,154.42 v2(272.07,153.98)
  BOTTOM w0.102: v2(194.6,89.27) v1(196.16,89.27)
BREATH_WHITE_LED#: length 96.6
  TOP w0.102: JLED1.8 188.67,8.35 189.65,9.32 189.65,13.58 189.27,13.96 189.27,17.45 189.97,19.8 193.74,23.58 193.74,29.09 197.14,32.49 197.14,40.5 195.05,42.6 v2(194.86,42.6) ; R436.2 189.15,87.24 v2(188.82,87.24)
  IN2 w0.102: v2(194.86,42.6) 194.53,42.92 194.53,46.8 190.21,51.13 190.21,52.63 188.35,54.49 188.35,57.8 187.3,58.86 186.15,58.86 183.93,61.07 183.93,69.57 187.62,73.25 187.62,73.89 188.31,74.59 188.31,86.73 v2(188.82,87.24)
  BOTTOM w0.102: v2(194.86,42.6) 194.86,42.82 v1(194.44,43.23)
BST_3V:
  vias: v1(191.08,140.36)
BST_5V: length 2.2
  TOP w0.102: v1(192.94,148.29) 192.65,148 192.65,147.54 191.91,146.8 PR61.1
BST_+V1.05SP: length 3.1
  TOP w0.508: PC165.1 150.72,79.05 150.15,78.48 v2(149.45,78.48)
  BOTTOM w0.203: v2(149.45,78.48) 149.45,78.6 149.77,78.92 PU150.5
BST_+VDDRP: length 1.7
  BOTTOM w0.102: PR701.1 v1(37.06,26.7)
BT_LED#: length 82.5
  IN2 w0.102: v2(233.27,151.82) 238.53,157.08 238.53,158.32 241.49,161.28 246.42,161.28 247.24,162.11 253.28,162.11 254.48,160.9 260.58,160.9 262.67,158.8 265.21,158.8 266.24,157.78 274.37,157.78 275.16,156.98 283.04,156.98 286.36,153.66 294.61,153.66 v2(295.31,154.36)
  BOTTOM w0.102: v2(233.27,151.82) v1(231.99,151.82) 230.34,151.82 R229.1 227.68,150.18 Q30.1 ; JMINI1.46 295.46,153.36 295.31,153.51 v2(295.31,154.36)
BT_RADIO_DIS#: length 179
  TOP w0.102: v1(298.49,159.29) 298.17,158.97 v2(298.17,158.55) 298.17,158.23 D14.1 298.63,157.42 R225.1 ; R298.2 166.02,104.75 v2(165.64,104.37) 165.23,103.96 U37.A13
  IN3 w0.102: v2(298.17,158.55) 298.17,159 297.55,159.62 287.29,159.62 284.79,162.12 267.3,162.12 265.66,163.76 261.47,163.76 260.64,162.93 254.16,162.93 253.85,163.25 246.35,163.25 245.62,162.51 238.62,162.51 238.45,162.34 231.38,162.34 229.88,160.85 225.12,160.85 221.36,157.09 221.36,154.58 219.37,152.58 219.37,145.29 214.55,140.47 214.55,138.32 213.02,136.78 213.02,132.53 209.1,128.62 204.79,128.62 203.55,127.38 203.55,122.94 201.48,120.87 198,120.87 191.46,114.33 191.46,112.84 v2(190.9,112.27)
  BOTTOM w0.102: v2(190.9,112.27) 189.19,112.27 188.7,112.77 184.76,112.77 181.46,109.47 178.79,109.47 176.31,106.99 173.53,106.99 172.37,105.83 170.08,105.83 169.65,105.4 167.73,105.4 166.71,104.37 v2(165.64,104.37)
BT_RADIO_DIS#_R: length 4.6
  TOP w0.102: v1(296.75,159.16) 297.37,158.54 v2(297.46,158.54) 297.41,158.49 D14.2 297.71,157.29 R225.2
  BOTTOM w0.102: JMINI1.51 v2(297.46,158.54)
CAM_MIC_CBL_DET#: length 93.3
  TOP w0.102: JLVDS1.8 96.4,136.92 v2(97.23,136.1) ; RC193.2 103.98,84.34 103.98,85.1 v2(104.01,85.13) ; v2(100.81,101.4) 99.72,101.4 v1(99.26,101.86)
  IN2 w0.102: v2(109.64,65.56) 105.79,69.41 101.52,69.41 98.93,72 98.93,79.73 99.26,80.06 99.26,81.09 100.01,81.84 102.84,81.84 103.16,82.16 103.16,83.62 104.01,84.46 v2(104.01,85.13)
  IN3 w0.102: v2(100.81,101.4) 100.81,104.39 103.67,107.24 103.67,113.53 97.95,119.24 97.95,122.48 95.89,124.55 95.89,134.76 v2(97.23,136.1)
  BOTTOM w0.076: UC1.F4 109.94,65.26 v2(109.64,65.56)
  BOTTOM w0.102: v2(104.01,85.13) 104.01,86.08 101.89,88.19 101.89,90.61 103.15,91.86 103.15,96.02 101.89,97.27 101.89,99.24 100.81,100.32 v2(100.81,101.4)
CARD_SMBCLK: length 167.7
  TOP w0.102: v2(90.1,17.79) 89.92,17.97 89.92,18.19 90.06,18.32 JEXP1.34 ; U38.A49 139.8,107.56 139.93,107.69 139.93,107.9 138.4,109.43 v3(135.27,109.43) 134.62,109.43 v2(134.28,109.08) 134.22,109.14 RP15.3
  IN1 w0.097: v2(106.02,115.79) 105.84,115.97 103.26,115.97 103.01,116.23 92.97,116.23 90.91,114.16 90.91,111.31 91.26,110.96 91.26,90.93 87.08,86.75 87.08,85.14 85.35,83.42 85.35,81.32 84.63,80.59 84.63,73.87 85.22,73.28 85.22,69.27 85.8,68.7 85.8,67.17 87.85,65.12 87.85,58.42 88.77,57.5 88.77,45.77 89.16,45.38 90.22,45.38 91.57,44.03 92.86,44.03 93.37,43.52 93.8,43.52 97.01,40.3 97.01,30.83 95.73,29.54 95.73,27.17 94.77,26.21 92.23,26.21 89.92,23.9 89.92,17.97 v2(90.1,17.79)
  BOTTOM w0.102: v2(106.02,115.79) 106.19,115.97 108.15,115.97 110.31,113.81 115.96,113.81 116.85,112.92 131.77,112.92 132.65,112.04 132.65,110.27 133.63,109.29 134.07,109.29 v2(134.28,109.08)
CARD_SMBDAT: length 168.3
  TOP w0.102: U38.B52 140.33,107.81 138.49,109.66 134.34,109.66 v2(134.28,109.72) 134.2,109.64 RP15.4 ; JEXP1.36 89.56,18.29 89.69,18.16 89.69,17.97 v2(89.52,17.79)
  IN1 w0.097: v2(89.52,17.79) 89.7,17.97 89.7,23.99 92.14,26.43 94.68,26.43 95.51,27.26 95.51,29.64 96.79,30.92 96.79,40.21 93.7,43.29 93.28,43.29 92.77,43.81 91.47,43.81 90.13,45.15 89.07,45.15 88.54,45.68 88.54,57.41 87.62,58.33 87.62,65.02 85.57,67.07 85.57,68.61 85,69.18 85,73.18 84.4,73.78 84.4,80.69 85.13,81.41 85.13,83.51 86.85,85.23 86.85,86.85 91.03,91.02 91.03,110.86 90.68,111.21 90.68,114.25 92.88,116.45 103.1,116.45 103.35,116.2 105.84,116.2 v2(106.02,116.38)
  BOTTOM w0.102: v2(134.28,109.72) 134.07,109.52 133.72,109.52 132.88,110.36 132.88,112.13 131.86,113.15 116.94,113.15 116.05,114.04 110.4,114.04 108.24,116.2 106.2,116.2 v2(106.02,116.38)
CCD_OFF: length 72.2
  TOP w0.102: v2(118.72,87.62) 118.72,88.32 117.58,89.46 v1(116.52,89.46) 114.85,89.46 113.36,90.95 113.36,92.41 112.94,92.83 112.43,92.83 111.92,93.34 111.92,94.72 R2601.2 ; v2(167.9,94.36) 167.48,93.94 U37.B43
  IN3 w0.102: v2(167.9,94.36) 167.75,94.36 167.48,94.1 167.48,93.37 165.92,91.81 165.92,89.91 164.12,88.11 164.12,86.68 162.99,85.55 162.99,84.98 162.2,84.19 158.17,84.19 157.07,85.28 152.28,85.28 150.01,87.56 141.54,87.56 140.91,88.18 135.82,88.18 135.09,87.46 130.8,87.46 130.04,88.21 120.98,88.21 120.93,88.26 119.33,88.26 118.72,87.64 v2(118.72,87.62)
CD3301_DCIN: length 5.7
  TOP w0.102: PR533.2 v1(117.36,133.56)
  TOP w0.254: PU701.1 121.03,134.3 120.62,133.89 PC511.1 119,133.53 PR533.2
CD3301_SDC_IN: length 2.5
  TOP w0.254: PU701.6 123.53,135 124.12,134.42 124.12,133.67 PR542.2
CD_PBATT_OFF: length 2.7
  TOP w0.254: PR543.1 121.53,142.89 PU701.26
CFD_PWRBTN#_XDP: length 3.4
  TOP w0.102: JXDP1.41 138.65,13.47 140.04,14.86 RC107.2
CFG0: length 44
  TOP w0.102: JXDP1.9 v1(146.65,14.37) 146.65,14.78 138.59,22.84 129.36,22.84 127.75,21.23 124.38,21.23 123.81,21.79 120.51,21.79 v2(120.29,21.58)
  BOTTOM w0.076: UC1.AC60 119.29,30.24 119.29,29.77 119.25,29.73 119.25,28.94 119.42,28.78 119.42,28.4 119.18,28.16 119.18,27.74 119.51,27.41 119.51,25.9
  BOTTOM w0.102: v2(120.29,21.58) 119.86,21.15 RC232.1 119.61,22.47 119.51,22.57 119.51,25.9
CFG1: length 45.8
  TOP w0.102: v2(118.66,19.55) 118.66,19.8 119.96,21.11 121.23,21.11 121.69,21.57 123.71,21.57 124.28,21 127.85,21 129.46,22.61 138.22,22.61 v1(144.56,16.27) 146.15,14.68 JXDP1.11
  BOTTOM w0.076: UC1.AC62 118.96,29 119.25,28.71 119.25,28.46 119.02,28.23 119.02,27.61 119.28,27.35 119.28,25.9
  BOTTOM w0.102: 119.28,25.9 119.28,21.71 RC233.1 118.21,20.64 118.21,19.87 118.53,19.55 v2(118.66,19.55)
CFG2: length 45
  TOP w0.102: v2(119.26,19.56) 119.26,19.97 119.99,20.69 v1(120.83,20.69) 121.2,20.69 121.84,21.34 123.62,21.34 124.19,20.77 127.94,20.77 129.55,22.38 137.86,22.38 145.15,15.09 JXDP1.15
  BOTTOM w0.076: UC1.AC63 118.85,28.48 118.85,27.52 119.04,27.33 119.04,25.9
  BOTTOM w0.102: 119.04,25.9 119.04,22.29 117.96,21.2 117.96,19.49 118.34,19.1 118.81,19.1 v2(119.26,19.56)
CFG3: length 47.7
  TOP w0.102: v2(132.89,9.19) 143.33,9.19 144.65,10.51 JXDP1.17 ; RC99.2 132.89,4.4 v2(132.89,5.77)
  IN1 w0.097: v2(131.69,14.28) 131.45,14.28 127.94,17.79 125.78,17.79 123.64,19.93 121.94,19.93 121.69,20.18 121.69,21.59 118.09,25.19 v2(117.83,25.19)
  IN3 w0.102: v2(132.89,5.77) v2(132.89,9.19) 132.89,13.07 v2(131.69,14.28)
  BOTTOM w0.076: 118.36,25.9 118.36,28.31 118.34,28.33 118.34,28.46 UC1.AA63
  BOTTOM w0.102: 118.36,25.9 118.36,25.9 118.36,25.48 118.07,25.19 v2(117.83,25.19)
CFG3_R: length 3.7
  TOP w0.102: v1(133.27,3.18) 133.28,3.18 133.65,3.56 RC99.1 133.65,4.7 134.15,5.2 JXDP1.60
CFG4: length 41.3
  TOP w0.076: RC238.1 119.32,30.97 v2(118.59,30.24)
  TOP w0.102: JXDP1.27 142.15,13.42 v1(143.01,14.28) 143.41,14.67 143.41,16.51 137.76,22.15 129.65,22.15 128.04,20.54 123.77,20.54 v2(123.39,20.92)
  IN1 w0.097: v2(123.39,20.92) 123.39,21.16 119,25.56 119,29.95 118.71,30.24 v2(118.59,30.24)
  BOTTOM w0.076: v2(118.59,30.24) 118.29,30.54 UC1.AA60
CFG5: length 39.2
  TOP w0.102: v2(122.5,20.92) 122.79,20.92 123.4,20.31 128.13,20.31 129.74,21.92 137.67,21.92 143.06,16.53 v1(143.06,15.89) 143.06,14.88 141.65,13.47 JXDP1.29
  IN1 w0.097: v2(122.5,20.92) 122.5,21.41 118.53,25.39 118.53,26.45 v2(117.83,27.14)
  BOTTOM w0.076: UC1.Y62 117.46,29 117.75,28.71 117.75,28.39 118.03,28.12 118.03,27.27 117.9,27.14 v2(117.83,27.14)
CFG6: length 40.4
  TOP w0.102: JXDP1.33 140.65,13.29 141.12,13.76 141.62,13.76 142.71,14.85 142.71,16.56 137.76,21.5 v1(134.33,21.5) 129.65,21.5 128.22,20.08 123.03,20.08 v2(122.74,20.37)
  IN1 w0.097: v2(122.74,20.37) 122.91,20.54 122.91,21.32 118.75,25.48 118.75,27.63 117.09,29.29 v2(117.09,29.59)
  BOTTOM w0.076: UC1.Y61 117.39,29.89 v2(117.09,29.59)
CFG7: length 41.1
  TOP w0.102: v2(122.15,20.39) 122.68,19.85 128.32,19.85 129.59,21.12 137.82,21.12 142.48,16.46 142.48,14.94 141.66,14.13 v1(141.38,14.13) 141.16,14.13 140.65,13.61 140.34,13.61 140.15,13.42 JXDP1.35
  IN1 w0.097: v2(117.83,26.49) 118.29,26.04 118.29,25.31 122.09,21.51 122.09,20.44 v2(122.15,20.39)
  BOTTOM w0.076: v2(117.83,26.49) 117.9,26.49 118.19,26.79 118.19,28.19 117.92,28.46 117.92,28.78 117.75,28.94 117.75,29.73 117.79,29.77 117.79,30.24 UC1.Y60
CFG8: length 55.5
  TOP w0.102: JXDP1.10 146.65,7.93 149.21,10.49 149.21,14.96 v1(147.46,16.71) 140.42,23.75 128.98,23.75 127.37,22.14 124.76,22.14 124.19,22.71 117.94,22.71 v2(117.83,22.6)
  BOTTOM w0.076: UC1.V62 117.17,28.78 117.17,28.46 117.24,28.4 117.24,26.03
  BOTTOM w0.102: v2(117.83,22.6) 117.83,21.53 RC241.1 117.45,22.03 117.24,22.24 117.24,26.03
CFG9: length 56.4
  TOP w0.102: JXDP1.12 146.15,7.75 148.98,10.58 148.98,14.52 v1(148.33,15.17) 139.98,23.52 129.08,23.52 127.47,21.91 124.66,21.91 124.09,22.48 119.11,22.48 117.97,21.34 RC240.1 116.65,21.34 v2(116.45,21.14)
  BOTTOM w0.076: UC1.V61 116.42,29.63 116.42,29.12 116.66,28.88 116.83,28.88 117.01,28.71 117.01,28.22 117.07,28.15 117.07,26.31 116.99,26.23
  BOTTOM w0.102: v2(116.45,21.14) 116.99,21.68 116.99,26.23
CFG10: length 51.1
  TOP w0.102: v1(145.15,4.43) JXDP1.16 v2(145.15,8.32) ; v2(117.09,30.24) 117.09,30.24 116.43,30.89 RC239.1
  IN1 w0.097: v2(117.09,30.24) 116.7,29.85 116.7,29.18 117.18,28.69 117.18,25.15 117.42,24.92 117.42,22.38 117.64,22.15 120.75,22.15 121.45,21.45 121.45,20.06 121.83,19.68 123.58,19.68 125.69,17.56 127.83,17.56 132.13,13.27 144.32,13.27 145.15,12.44 v2(145.15,8.32)
  BOTTOM w0.076: v2(117.09,30.24) 116.79,30.54 UC1.V60
CFG11: length 46.1
  TOP w0.102: JXDP1.18 144.65,7.85 v2(144.1,8.4)
  IN1 w0.097: v2(116.31,25.07) 116.72,24.66 116.72,22.05 118.15,20.63 118.85,20.63 120.56,18.91 123.39,18.91 125.41,16.89 127.55,16.89 131.85,12.6 142.37,12.6 143.06,11.91 143.06,9.44 v2(144.1,8.4)
  BOTTOM w0.076: UC1.U60 116.29,30.24 116.29,29.77 116.26,29.73 116.26,28.94 116.42,28.78 116.42,28.4 116.21,28.18 116.21,27.86 116.89,27.18 116.89,26.39 116.74,26.23
  BOTTOM w0.102: 116.74,26.23 116.74,25.5 v2(116.31,25.07)
CFG12: length 43
  TOP w0.102: v2(142.15,8.32) JXDP1.28
  IN1 w0.097: v2(142.15,8.32) 142.15,11.77 141.55,12.37 131.75,12.37 127.46,16.67 125.32,16.67 123.33,18.66 120.18,18.66 119.73,19.1 118.21,19.1 117.83,19.49 117.83,20.59 116.27,22.15 v2(116.27,22.66)
  BOTTOM w0.076: UC1.T63 115.21,26.13 115.41,25.94 115.41,25.9
  BOTTOM w0.102: 115.41,25.9 115.41,24.75 115.58,24.58 115.58,23.39 116.27,22.7 v2(116.27,22.66)
CFG13: length 43.9
  TOP w0.102: v2(141.45,7.97) 141.65,7.77 JXDP1.30
  IN1 w0.097: v2(141.45,7.97) 141.4,7.92 140.81,7.92 140.56,8.17 140.56,8.54 140.37,8.73 140.37,11.26 139.7,11.93 131.57,11.93 127.27,16.22 125.12,16.22 123.19,18.15 119.93,18.15 119.48,18.6 117.56,18.6 115.48,20.68 115.48,23.65 v2(116.31,24.49)
  BOTTOM w0.076: UC1.T62 115.66,28.79 115.66,28.79 115.67,28.78 115.67,27.69 115.87,27.49 v1(115.87,26.67) 115.87,25.9
  BOTTOM w0.102: v2(116.31,24.49) 115.87,24.93 115.87,25.9
CFG14: length 43.9
  TOP w0.102: v2(140.98,8.35) 140.65,8.02 JXDP1.34
  IN1 w0.097: v2(116.28,23.26) 115.82,22.8 115.82,20.73 117.7,18.85 119.61,18.85 120.05,18.41 123.25,18.41 125.21,16.44 127.37,16.44 131.66,12.15 139.84,12.15 140.61,11.38 140.61,8.83 140.98,8.46 v2(140.98,8.35)
  BOTTOM w0.076: 115.64,25.9 115.64,26.23 115.51,26.36 115.51,28.71 115.34,28.88 115.16,28.88 114.92,29.12 114.92,29.63 UC1.T61
  BOTTOM w0.102: 115.64,25.9 115.64,24.84 115.88,24.6 115.88,23.67 v2(116.28,23.26)
CFG15: length 46.2
  TOP w0.102: v1(140.15,4.53) JXDP1.36 v2(140.15,8.31)
  IN1 w0.097: v2(115.59,30.24) 116.05,29.78 116.05,28.18 115.89,28.02 115.89,24.38 115.16,23.65 115.16,20.62 117.44,18.34 119.35,18.34 119.8,17.9 123.12,17.9 125.02,16 127.18,16 131.48,11.7 139.48,11.7 140.15,11.03 v2(140.15,8.31)
  BOTTOM w0.076: v2(115.59,30.24) 115.29,30.54 UC1.T60
CFG16: length 53.1
  TOP w0.102: JXDP1.6 147.65,8.61 149.62,10.57 149.62,15.15 v1(145.93,18.84) 140.79,23.98 128.89,23.98 127.39,22.48 124.77,22.48 122.29,24.96 118.91,24.96 v2(117.84,23.89)
  BOTTOM w0.076: UC1.AA62 118.27,29.18 118.27,29.18 118.67,28.78 118.67,28.46 118.69,28.45 118.69,27.42 118.82,27.29 118.82,25.9
  BOTTOM w0.102: 118.82,25.9 118.82,24.68 118.03,23.89 v2(117.84,23.89)
CFG17: length 53.6
  TOP w0.102: v2(117.83,24.54) 118.47,25.19 122.39,25.19 124.87,22.71 127.29,22.71 128.79,24.21 141.08,24.21 v1(144.62,20.67) 149.84,15.45 149.84,10.48 148.15,8.78 JXDP1.4
  BOTTOM w0.076: 118.59,25.9 118.59,27.24 118.52,27.31 118.52,28.38 118.5,28.4 118.5,28.71 118.27,28.94 118.09,28.94 117.92,29.12 117.92,29.63 UC1.AA61
  BOTTOM w0.102: 118.59,25.9 118.59,24.83 118.3,24.54 v2(117.83,24.54)
CFG18: length 48.3
  TOP w0.102: JXDP1.24 143.15,5.24 v2(143.41,4.98)
  IN1 w0.097: v2(143.41,4.98) 144.56,6.14 144.56,12.47 143.98,13.04 132.03,13.04 127.74,17.34 125.6,17.34 123.51,19.42 121.77,19.42 121.2,19.99 121.2,20.69 120.75,21.14 118.3,21.14 117.19,22.24 117.19,24.82 116.96,25.06 116.96,26.3 v2(116.31,26.94)
  BOTTOM w0.076: v2(116.31,26.94) 116.31,27.29 115.88,27.73 115.88,28.5 UC1.U63
CFG19: length 45.3
  TOP w0.102: v2(144.09,9.1) 143.65,8.66 JXDP1.22
  IN1 w0.097: v2(144.09,9.1) 143.65,9.54 143.65,12.18 143.01,12.82 131.94,12.82 127.64,17.12 125.5,17.12 123.45,19.17 121.64,19.17 120.94,19.87 120.94,20.57 120.62,20.88 118.22,20.88 116.96,22.14 116.96,24.74 116.74,24.97 116.74,25.95 v2(116.31,26.37)
  BOTTOM w0.076: UC1.U62 115.96,29 116.26,28.71 116.26,28.46 116.04,28.25 116.04,27.8 116.73,27.11 116.73,26.79 v2(116.31,26.37)
CFG_RCOMP: length 3.6
  TOP w0.102: v2(116.63,28.01) 117.13,27.51 RC235.1
  BOTTOM w0.089: v2(116.63,28.01) 116.71,28.09 UC1.V63
CHAGER_SRC:
  vias: v1(100.66,164.15) v2(96.87,164.27) v2(96.87,163.63) v2(97.51,164.27) v2(97.51,163.63) v2(98.14,164.27) v2(98.14,163.63) v2(98.78,164.27) v2(98.78,163.63) v2(99.41,164.27) v2(99.41,163.63) v2(100.05,164.27) v2(100.05,163.63)
CHARGE_EN: length 3.2
  TOP w0.102: U37.A45 169.73,91.13 v1(170.31,90.55) 170.41,90.45 170.41,89.87 R313.2
CHARGER_CELL_PIN: length 43.4
  TOP w0.254: v2(142.91,138.1) 143.04,137.98 v1(143.04,137.57) 143.04,136.14 143.24,135.94 PD504.2 ; PU402.10 113,146.41 113.02,146.42 v2(113.83,146.42) 113.83,147.12 114.02,147.31 PR431.2
  BOTTOM w0.254: v2(142.91,138.1) 142.15,137.34 137.96,137.34 137.16,136.54 133.84,136.54 132.54,135.25 130.47,135.25 129.89,135.82 129.89,135.84 129.79,135.94 129.22,135.94 127.57,137.6 125.32,137.6 123.42,139.5 115.82,139.5 115.23,140.09 115.23,145.03 v2(113.83,146.42)
CHARGER_SMBCLK: length 57.1
  TOP w0.102: U38.B50 141.64,108.2 v2(141.2,107.75) ; RP16.5 140,112.2 140.16,112.04 140.16,111.78 v2(141.23,110.7) ; v2(116.18,146.19) 115.66,146.19 PR430.1
  IN3 w0.102: v2(141.2,107.75) 141.23,107.78 v2(141.23,110.7) 141.01,110.92 140.76,110.92 140.46,111.21 140.46,112.46 138.62,114.3 138.62,119.66 133.35,124.93 131.5,124.93 129.06,127.38 129.06,133.07 127.65,134.47 127.65,135.77 123.09,140.33 123.09,141.63 120.18,144.54 117.8,144.54 117.42,144.92 115.9,144.92 115.51,145.32 115.51,145.75 115.73,145.98 115.96,145.98 v2(116.18,146.19)
CHARGER_SMBDAT: length 54.3
  TOP w0.102: PR429.1 115.62,145.6 v2(116.18,145.6) ; RP16.6 140.5,112.17 140.37,112.04 140.37,111.88 140.97,111.29 v2(141.23,111.29) 141.89,110.62 U38.A47
  IN3 w0.102: v2(141.23,111.29) 141.09,111.15 140.85,111.15 140.69,111.31 140.69,112.55 138.85,114.4 138.85,119.76 133.44,125.16 131.6,125.16 129.28,127.47 129.28,133.16 127.88,134.57 127.88,135.87 123.32,140.42 123.32,141.73 120.28,144.77 117.9,144.77 117.52,145.15 115.99,145.15 115.73,145.41 115.73,145.66 115.82,145.75 116.03,145.75 v2(116.18,145.6)
CHG_LGATE: length 5
  IN3 w1.016: 109.07,148.64 108.59,149.12 108.59,152.74 109.07,153.22
  vias: v1(110.24,154.3) v2(109.1,147.69) v2(109.1,147.06) v2(109.83,154.61) v2(109.83,153.98)
CHG_UGATE: length 19.7
  IN3 w1.016: 110.27,165.47 110.27,159.31 107.42,156.46 107.42,146.99
  vias: v1(109.23,166.65) v2(107.73,145.85) v2(108.11,145.41) v2(108.56,166.04) v2(109.19,166.04)
CHGVR_DCIN: length 3.6
  TOP w0.102: PR530.2 118.29,137.09 118.88,136.5 v1(118.88,136.18)
  TOP w0.254: PU701.35 118.9,137.17 118.54,137.53 PR530.2
CIICSCL: length 8.2
  TOP w0.102: R2598.1 108.95,106.13 108.95,106.71 v3(109.31,107.06) 109.83,107.59 109.83,108.41 109.3,108.93 107.37,108.93 106.63,109.68 106.63,110.51 106.57,110.57 U52.13
CIICSDA: length 8.7
  TOP w0.102: R2597.1 109.18,106.13 109.18,106.61 110.06,107.49 110.06,108.5 109.4,109.16 v3(108.5,109.16) 107.47,109.16 106.86,109.77 106.86,110.66 106.55,110.97 U52.14
CLK_27M_IN: length 6
  TOP w0.102: 124.87,98.36 125.88,97.34 R66.1 125.12,96.76 R107.2 ; 124.87,98.36 v1(124.87,98.35) ; 124.87,98.36 U6.K1
CLK_27M_IN_R: length 3.8
  TOP w0.102: R107.1 125,95.1 C42.1 ; Y1.1 125.56,93.87 C42.1 ; C42.1 124.15,94.43 v1(124.01,94.29)
CLK_27M_OUT: length 7.3
  TOP w0.102: Y1.3 128.58,95.84 C43.1 R66.2 126.79,97.08 v1(126.11,97.76) U6.L1
CLK_BIASREF: length 8.7
  TOP w0.254: v2(103.79,53.01) v1(102.92,53.89) RC45.1
  BOTTOM w0.089: UC1.C26 107.92,51.94 107.81,52.05 107.81,52.06 107.63,52.24 107.62,52.24 107.59,52.27 107.42,52.27 107.35,52.2 106.96,52.2 106.86,52.1 106.21,52.1 106.19,52.11
  BOTTOM w0.305: v2(103.79,53.01) 104.04,52.77 105.02,52.77 105.68,52.11 106.19,52.11
CLK_DDC2_CRT: length 165
  TOP w0.102: U39.14 163.74,152.26 v2(163.87,152.39)
  IN3 w0.102: v2(312.65,159.19) 312.71,159.13 312.71,159.06 312.43,158.78 311.59,158.78 310.62,159.76 306.23,159.76 305.92,159.44 303.44,159.44 302.3,160.58 292.2,160.58 291.31,161.47 287.06,161.47 285.35,163.19 279.7,163.19 278.69,164.2 274.42,164.2 274.17,164.46 268.32,164.46 267.31,165.47 237.96,165.47 237.07,164.58 229.3,164.58 227.47,162.75 222.3,162.75 219.81,160.27 200.57,160.27 199.62,159.31 193.71,159.31 193.23,158.84 192.79,158.84 192.51,158.55 192.51,157.98 v2(192.57,157.92)
  BOTTOM w0.102: v2(163.87,152.39) 163.61,152.14 163.61,151.95 163.68,151.88 164.02,151.88 164.4,151.5 178.15,151.5 178.79,152.14 189.33,152.14 192.19,154.99 192.19,157.03 192.76,157.6 192.76,157.73 v2(192.57,157.92) ; JIO1.32 311.38,159.9 311.46,159.82 312.27,159.82 v1(312.42,159.67) 312.65,159.44 v2(312.65,159.19)
CLK_DDC2_DOCK: length 29.2
  TOP w0.102: U39.15 163.4,152.66 v1(163.54,152.8) 164.15,153.41 164.15,156.55 163.51,157.19 163.51,158.58 162.88,159.21 158.44,159.21 157.92,159.73 157.92,163.09 157.17,163.85 157.17,168.36 157.45,168.65 158.03,168.65 158.22,168.46 158.22,168.2 v2(158.53,167.89)
  BOTTOM w0.102: JDOCK1.48 158.95,171.16 158.79,171 158.79,169.94 158.13,169.28 158.13,168.29 v2(158.53,167.89)
CLK_KBD: length 76.3
  TOP w0.102: U38.A38 146.39,109.97 146.53,110.11 146.53,110.13 146.56,110.13 ; 146.56,110.13 v2(146.57,110.13) ; 146.56,110.13 146.72,110.29 146.72,110.59 146.78,110.65 146.78,111.24 146.56,111.47 146.4,111.47 146.11,111.75 146.11,111.8 146.1,111.82 146.1,111.93 146.08,111.94 RP4.7
  IN3 w0.102: v2(146.57,110.13) 146.56,110.14 146.56,110.38 147.67,111.5 147.67,112.47 147,113.14 147,113.31 146.89,113.43 146.89,116.38 148.1,117.59 149.58,117.59 150.47,118.48 150.47,120.01 151.72,121.26 151.72,128.38 153.42,130.07 153.42,131.27 153.92,131.77 153.92,137.75 157.23,141.06 157.23,146.24 158.76,147.77 158.76,154.85 159.36,155.44 159.36,156.78 163.55,160.97 163.55,163.08 165.08,164.61 165.08,166.62 167.87,169.41 167.87,170.18 v2(167.45,170.59)
  BOTTOM w0.102: JDOCK1.78 v2(167.45,170.59)
CLK_MSE: length 73.2
  TOP w0.102: U38.A39 145.89,110.46 146.3,110.86 ; 146.3,110.86 145.58,111.58 RP4.6 ; 146.3,110.86 v2(146.3,110.88)
  IN3 w0.102: v2(163.63,165.97) 164.29,165.97 164.6,165.66 164.6,164.81 163.07,163.28 163.07,161.17 159.32,157.42 158.4,157.42 157.45,156.47 157.45,150.42 156.63,149.6 156.63,141.23 153.57,138.17 153.57,131.92 153.06,131.41 153.06,130.22 151.36,128.51 151.36,122.01 145.39,116.04 145.39,113.89 147.08,112.21 147.08,111.66 v2(146.3,110.88)
  BOTTOM w0.102: v2(163.63,165.97) 165.47,165.97 165.95,165.48 JDOCK1.71
CLK_PCI_5048: length 65.6
  TOP w0.102: v2(156.08,88.81) 155.87,89.03 152.21,89.03 151.31,88.13 150.6,88.13 147.38,84.92 141.35,84.92 v1(139.25,87.02) 134.99,91.28 134.99,92.3 134.4,92.89 130.85,92.89 129.45,91.49 129.45,89.07 129.35,88.97 129.04,88.97 128.94,89.07 128.94,90.92 128.82,91.05 128.56,91.05 128.44,90.92 128.44,89.07 128.31,88.95 123.98,88.95 123.63,88.6 123.06,88.6 122.29,87.82 122.29,86.91 122.49,86.7 122.49,85.19 123.72,83.96 RC61.2 ; R324.1 159.79,96.46 160.41,95.84 v2(161.2,95.84) U37.A28
  IN1 w0.097: v2(156.08,88.81) 157.01,89.74 158.9,89.74 161.98,92.81 161.98,95.06 v2(161.2,95.84)
CLK_PCI_DOCK: length 147.6
  TOP w0.102: R273.1 178.89,165.45 v2(179.45,165.45) ; v2(135.93,65.84) 137.18,64.59 RC64.2
  IN1 w0.097: v2(187.13,118.97) 178.98,110.82 178.98,97.27 177.5,95.79 177.5,91.05 175.3,88.85 175.3,87.79 171.27,83.76 171.27,82.33 169.65,80.7 164.26,80.7 163.72,81.24 162.2,81.24 159.41,78.45 159.41,72.92 158.14,71.64 155.5,71.64 155.12,71.26 142.36,71.26 139.47,68.37 139.47,67.14 137.94,65.61 136.16,65.61 v2(135.93,65.84)
  IN3 w0.102: v2(179.45,165.45) 179.45,163.97 178.92,163.44 178.92,162.23 178.47,161.79 178.47,160.33 180.02,158.78 180.02,156.08 179.55,155.61 179.55,154.36 181.58,152.33 181.58,150.3 182.98,148.9 182.98,145.15 181.84,144.01 181.84,139.69 181.46,139.31 181.46,139.29 181.33,139.16 181.33,133.53 180.85,133.05 180.85,132.29 179.87,131.31 179.87,128.77 187.13,121.5 v2(187.13,118.97)
  BOTTOM w0.102: JDOCK1.121 v2(179.45,165.45)
CLK_PCI_FBIN: length 2.8
  TOP w0.102: UC5.8 133.4,87.18 RC100.2 134.44,87.06 CC23.1
CLK_PCI_LPDEBUG: length 220.7
  TOP w0.102: v2(137.71,66.03) 138.07,65.66 RC66.2
  IN1 w0.097: v2(137.71,66.03) 137.71,66.67 138,66.96 138.33,66.96 138.99,67.62 138.99,68.39 138.99,68.57 142.17,71.75 153.97,71.75 154.36,72.13 157.94,72.13 158.44,72.64 158.44,73.61 158.93,74.09 158.93,78.63 162.01,81.71 166.92,81.71 167.42,81.21 168.44,81.21 169.49,82.25 169.49,82.7 174.79,88 174.79,89.84 177.02,92.07 177.02,96.14 178.47,97.59 178.47,111.12 189.24,121.88 197.43,121.88 199.17,123.63 202.51,123.63 204,125.11 205.49,125.11 206.68,126.31 211.05,126.31 215.67,130.93 216,130.93 218.16,133.09 218.16,134.04 v2(217.65,134.55)
  IN3 w0.102: v2(217.65,134.55) 217.65,136.07 219.75,138.17 219.75,141.78 220.87,142.9 224.75,142.9 226.07,144.22 226.07,145.7 227.28,146.9 227.28,154.7 225.51,156.47 225.51,157.51 226.18,158.17 230.01,158.17 230.78,158.94 239.31,158.94 239.76,159.38 242.54,159.38 242.79,159.63 248.32,159.63 248.96,160.27 253.91,160.27 254.42,159.76 261.47,159.76 261.85,159.38 266.19,159.38 267.18,158.39 273.77,158.39 275.34,159.96 283.64,159.96 v2(284.71,161.03)
  BOTTOM w0.102: R244.1 v2(284.71,161.03)
CLK_PCI_MEC: length 41.4
  TOP w0.102: U38.A29 151.12,106.06 151.6,106.54 v2(151.68,106.54) ; RC63.2 134.93,85.66 135.76,85.66 v2(136.17,85.26) ; R382.1 v2(152.75,111.69)
  IN1 w0.097: v2(152.75,111.69) 152.44,111.37 152.44,109.01 152.31,108.88 152.31,107.31 151.68,106.67 v2(151.68,106.54) 152.14,106.08 152.14,104.93 150.84,103.63 150.84,100.27 150.12,99.55 150.12,94.65 147.4,91.92 142.05,91.92 141.11,90.98 141.11,90.38 140.32,89.59 139.72,89.59 136.17,86.04 v2(136.17,85.26)
CLK_PCI_TPM_TCM: length 99.1
  TOP w0.102: RC58.2 124.69,88.22 136.78,88.22 137.78,87.21 137.78,84.57 138.61,83.75 v1(141.45,83.75) 147.1,83.75 150.53,87.18 155.06,87.18 158.16,84.08 161.49,84.08 162.9,82.67 v2(164.25,82.67) ; R290.1 160.43,108.28 U25.21 160.43,110.84 161.56,111.97 162.25,111.97 163.11,112.83 164.38,112.83 165.45,111.75 v2(166.41,111.75)
  IN1 w0.097: v2(166.41,111.75) 167.04,111.12 172.19,111.12 172.92,110.38 172.92,108.13 174.68,106.37 174.68,91.7 172.76,89.77 172.76,87.91 172.53,87.68 171.77,87.68 170.43,86.35 170.43,85.86 167.82,83.24 164.82,83.24 v2(164.25,82.67)
CLK_PCIE_EXP: length 39.6
  TOP w0.102: v2(118.62,3.89) 118.45,3.71 118.09,3.71 RC188.2 ; JEXP1.18 94.06,18.25 93.86,18.06 93.86,17.83 v2(93.74,17.7)
  IN1 w0.097: v2(93.74,17.7) 93.74,18.24 94.15,18.65 98.83,18.65 99.71,17.77 99.71,16.4 100.71,15.39 100.71,14.63 102.09,13.25 102.09,9.14 102.34,8.89 102.34,7.92 105.64,4.62 116.72,4.62 117.63,3.71 118.44,3.71 v2(118.62,3.89)
  BOTTOM w0.102: v2(118.62,3.89) 118.78,3.73 119.24,3.73 RC184.2
CLK_PCIE_EXP#: length 39.6
  TOP w0.102: RC164.2 118.09,3.45 118.47,3.45 v2(118.62,3.3) ; JEXP1.16 94.56,18.5 94.56,18.17 94.52,18.14 94.32,18.14 94.13,17.95 94.13,17.9 v2(94.32,17.7)
  IN1 w0.097: v2(118.62,3.3) 118.47,3.45 117.52,3.45 116.61,4.36 105.53,4.36 102.07,7.81 102.07,8.79 101.83,9.03 101.83,13.14 100.45,14.52 100.45,15.28 99.45,16.29 99.45,17.66 98.72,18.39 94.26,18.39 94,18.13 94,18.03 v2(94.32,17.7)
  BOTTOM w0.102: v2(118.62,3.3) 118.78,3.46 119.24,3.46 RC160.2
CLK_PCIE_FMC: length 283.1
  IN1 w0.097: v2(193.38,117.83) 193.38,108.5 191.16,106.27 191.16,88.32 187.68,84.84 187.68,75.31 186.42,74.06 185.26,74.06 184.71,73.52 184.71,55.16 187.2,52.68 187.2,15.41 187.84,14.77 187.84,9.14 186.42,7.72 173.91,7.72 171.21,5.02 160.02,5.02 157.31,7.73 148.4,7.73 143.91,3.23 124.34,3.23 123.63,2.52 120.77,2.52 119.78,3.51 119.78,7.51 v2(119.61,7.67)
  IN3 w0.102: v2(193.38,117.83) 193.38,119.99 193.76,120.36 195.44,120.36 197.92,122.84 197.92,122.93 204.75,129.76 208.22,129.76 210.61,132.15 210.61,133.53 210.35,133.79 v2(209.85,133.79) ; v2(102.4,44.79) 103.78,44.79 106.53,42.05 106.53,31.88 110.4,28.01 115.34,28.01 115.76,27.59 116.7,27.59 117.37,26.92 117.37,22.21 118.25,21.33 118.25,16.44 117.11,15.31 113.99,15.31 113.4,14.72 113.4,12.61 113.84,12.16 113.84,10.08 116.72,7.2 119.6,7.2 119.77,7.38 119.77,7.51 v2(119.61,7.67)
  BOTTOM w0.102: UC1.C37 107.65,44.98 107.35,44.68 107.17,44.68 106.93,44.44 102.98,44.44 102.77,44.65 102.53,44.65 v2(102.4,44.79) ; JMINI2.13 210.48,133.9 210.37,133.79 v2(209.85,133.79)
CLK_PCIE_FMC#: length 283.5
  IN1 w0.097: v2(192.8,117.83) 193.12,117.51 193.12,108.61 190.9,106.38 190.9,88.43 187.42,84.95 187.42,75.42 186.32,74.32 185.15,74.32 184.45,73.62 184.45,55.06 186.94,52.57 186.94,15.3 187.58,14.66 187.58,9.25 186.31,7.98 173.8,7.98 171.1,5.28 160.12,5.28 157.41,7.99 148.3,7.99 143.8,3.49 124.23,3.49 123.52,2.78 120.88,2.78 120.04,3.62 120.04,7.51 v2(120.2,7.67)
  IN3 w0.102: v2(192.8,117.83) 193.12,118.15 193.12,120.1 193.65,120.63 195.33,120.63 197.65,122.95 197.65,123.04 204.64,130.03 208.11,130.03 210.35,132.26 210.35,133.42 210.24,133.53 210.17,133.53 v2(209.85,133.21) ; v2(120.2,7.67) 120.04,7.51 120.04,7.27 119.71,6.93 116.61,6.93 113.57,9.97 113.57,12.05 113.13,12.5 113.13,14.83 113.88,15.57 117,15.57 117.98,16.55 117.98,21.22 117.1,22.1 117.1,26.81 116.59,27.32 115.65,27.32 115.23,27.74 110.29,27.74 106.26,31.77 106.26,41.94 103.67,44.52 102.71,44.52 v2(102.4,44.21)
  BOTTOM w0.102: v2(209.85,133.21) 210.16,133.52 210.21,133.52 210.26,133.47 210.26,133.16 210.32,133.1 JMINI2.11 ; v2(102.4,44.21) 102.4,44.21 102.58,44.39 102.66,44.39 102.87,44.17 v3(103.66,44.17) 107.04,44.17 107.14,44.28 107.19,44.28 107.41,44.06 107.61,44.06 107.77,44.22 107.77,44.32 107.68,44.41 UC1.B38
CLK_PCIE_LAN: length 183
  TOP w0.102: v2(171.62,138.15) 171.91,137.86 174.99,137.86 175.17,138.04 U21.44
  IN1 w0.097: v2(118.34,134.42) 117.76,133.84 115.72,133.84 114.12,132.24 112.65,132.24 111.21,130.8 111.21,119.36 110.34,118.49 110.34,116.9 109.77,116.32 109.77,112.65 109.01,111.9 109.01,109.66 107.34,108 106.13,108 104.98,106.85 101.85,106.85 101.63,106.64 100.6,106.64 97.6,103.64 97.6,100.48 94.46,97.34 94.46,94.49 93.75,93.78 93.75,91.31 88.75,86.3 88.75,80.13 89.18,79.7 89.18,71.94 89.11,71.87 89.11,66.01 89.32,65.8 89.32,59.2 90.34,58.18 90.34,55.51 90.78,55.07 90.78,50.73 90.17,50.12 90.17,46.72 90.66,46.23 91.95,46.23 93.86,44.31 94.81,44.31 96.79,42.33 96.79,42.07 v2(96.95,41.9)
  BOTTOM w0.102: v2(171.62,138.15) 171.47,137.99 168.75,137.99 167.61,136.85 161.47,136.85 158.42,133.8 157.09,133.8 156.88,133.6 147.23,133.6 146.72,134.1 138.92,134.1 138.1,133.29 118.9,133.29 118.15,134.04 118.15,134.23 v2(118.34,134.42) ; RC49.2 101.55,41.81 101.76,42.03 101.76,42.16 101.69,42.23 100.76,42.23 100.21,42.79 98.47,42.79 98.15,43.11 97.55,43.11 96.68,42.24 96.68,42.17 v2(96.95,41.9)
CLK_PCIE_LAN#: length 182.8
  TOP w0.102: v2(171.62,137.56) 171.66,137.6 v3(174.32,137.6) 175.1,137.6 175.14,137.64 U21.45
  IN1 w0.097: v2(96.37,41.91) 96.52,42.07 96.52,42.22 94.7,44.05 93.76,44.05 91.84,45.97 90.56,45.97 89.91,46.61 89.91,50.23 90.52,50.84 90.52,54.96 90.08,55.4 90.08,58.07 89.06,59.09 89.06,65.69 88.85,65.91 88.85,71.98 88.91,72.04 88.91,79.59 88.49,80.02 88.49,86.41 93.49,91.42 93.49,93.89 94.2,94.6 94.2,97.45 97.34,100.59 97.34,103.75 100.5,106.9 101.53,106.9 101.74,107.12 104.88,107.12 106.02,108.26 107.24,108.26 108.75,109.77 108.75,112.01 109.5,112.76 109.5,116.43 110.08,117.01 110.08,118.6 110.95,119.47 110.95,130.91 112.54,132.51 114.01,132.51 115.61,134.1 117.65,134.1 117.75,134.21 v2(117.75,134.42)
  BOTTOM w0.102: v2(96.37,41.91) 96.42,41.96 96.42,42.35 97.44,43.37 98.26,43.37 98.58,43.06 100.32,43.06 100.87,42.5 101.36,42.5 RC48.2 ; v2(171.62,137.56) 171.47,137.72 168.86,137.72 167.72,136.58 161.58,136.58 158.53,133.53 157.2,133.53 156.99,133.33 147.12,133.33 146.61,133.84 139.03,133.84 138.21,133.02 118.79,133.02 117.88,133.93 117.88,134.29 v2(117.75,134.42)
CLK_PCIE_MINI2: length 301
  IN1 w0.097: v2(278.95,158.68) 278.81,158.82 278.81,159.81 278.04,160.58 271.37,160.58 269.52,162.43 266.84,162.43 262.52,166.75 238.94,166.75 236.5,164.31 229.29,164.31 226.2,161.22 197.01,161.22 195.45,159.66 192.15,159.66 191.55,159.06 187.5,159.06 185.09,156.65 179.76,156.65 179.35,156.24 177.09,156.24 176.55,156.78 173.85,156.78 168.46,162.17 157.84,162.17 154.02,158.36 147.56,158.36 145.15,155.95 143.86,155.95 143.36,155.44 136,155.44 129.44,148.89 129.44,147.11 119.7,137.37 119.7,136.2 118.82,135.32 115.78,135.32 113.7,133.24 111.84,133.24 109.76,131.16 109.76,122.9 110.21,122.44 110.21,120.19 108.3,118.29 108.3,113.07 104.76,109.53 102.03,109.53 95.15,102.65 95.15,99.73 93.32,97.9 93.32,94.76 92.75,94.2 92.75,91.74 87.55,86.55 87.55,83.83 87.28,83.55 87.28,81.92 87.52,81.68 87.52,68.27 88.09,67.69 88.09,65.6 88.32,65.36 88.32,58.72 89.25,57.79 89.25,54.87 89.76,54.37 89.76,51.12 89.61,50.98 89.37,50.98 v2(89.27,51.09)
  BOTTOM w0.102: v2(278.95,158.68) 278.79,158.52 278.79,158.26 279.06,158 JMINI1.13 ; v2(89.27,51.09) 89.36,50.99 94.31,50.99 95.11,50.19 95.11,48.01 96.63,46.49 97.48,46.49 RC60.2
CLK_PCIE_MINI2#: length 300.7
  IN1 w0.097: v2(278.37,158.68) 278.55,158.86 278.55,159.7 277.93,160.32 271.26,160.32 269.42,162.17 266.73,162.17 262.41,166.49 239.05,166.49 236.61,164.04 229.4,164.04 226.31,160.96 197.12,160.96 195.56,159.39 192.26,159.39 191.66,158.8 187.61,158.8 185.2,156.39 179.87,156.39 179.46,155.98 176.98,155.98 176.44,156.52 173.74,156.52 168.35,161.91 157.95,161.91 154.13,158.1 147.67,158.1 145.25,155.69 143.97,155.69 143.47,155.18 136.1,155.18 129.7,148.78 129.7,147 119.96,137.26 119.96,136.09 118.92,135.06 115.89,135.06 113.81,132.98 111.95,132.98 110.02,131.05 110.02,123.01 110.47,122.55 110.47,120.09 108.57,118.18 108.57,112.97 104.87,109.27 102.14,109.27 95.41,102.54 95.41,99.62 93.58,97.79 93.58,94.65 93.02,94.09 93.02,91.64 87.82,86.44 87.82,83.72 87.54,83.44 87.54,82.03 87.78,81.79 87.78,68.37 88.35,67.8 88.35,65.7 88.58,65.47 88.58,58.83 89.51,57.9 89.51,54.98 90.02,54.47 90.02,51.01 89.72,50.72 89.48,50.72 v2(89.27,50.5)
  BOTTOM w0.102: RC59.2 97.47,46.22 96.52,46.22 94.84,47.9 94.84,50.08 94.2,50.73 89.49,50.73 v2(89.27,50.5) ; JMINI1.11 278.26,158 278.53,158.26 278.53,158.52 v2(278.37,158.68)
CLK_PCIE_MMI: length 117.7
  IN3 w0.102: v2(97.99,41.26) 97.83,41.1 97.83,40.63 97,39.81 97,33.71 99.73,30.98 99.73,25 100.44,24.29 100.44,22.79 99.56,21.91 98.73,21.91 96.37,19.55 85.7,19.55 82.19,16.04 76.7,16.04 75.03,17.71 66.6,17.71 65.22,19.09 60.13,19.09 58.33,20.89 58.33,21.65 57.65,22.33 56.38,22.33 54.14,24.57 48.93,24.57 48.1,23.74 33.06,23.74 31.79,22.47 19.09,22.47 17.59,23.97 15.52,23.97 15.51,23.98 v2(15.41,23.87)
  BOTTOM w0.102: U27.3 13.56,25.09 13.63,25.02 13.63,24.77 14.37,24.03 15.25,24.03 v2(15.41,23.87) ; v2(97.99,41.26) 97.99,41.49 98.21,41.71 98.38,41.71 RC54.2
CLK_PCIE_MMI#: length 117.4
  IN3 w0.102: v2(15.41,24.46) 15.63,24.24 17.7,24.24 19.2,22.74 31.68,22.74 32.95,24.01 47.99,24.01 48.82,24.83 54.25,24.83 56.49,22.6 57.76,22.6 58.6,21.76 58.6,21 60.24,19.36 65.33,19.36 66.71,17.97 75.15,17.97 76.81,16.31 82.08,16.31 85.58,19.82 96.26,19.82 98.62,22.18 99.45,22.18 100.18,22.9 100.18,24.18 99.47,24.89 99.47,30.87 96.73,33.6 96.73,39.92 97.56,40.75 97.56,41.1 v2(97.4,41.26)
  BOTTOM w0.102: U27.2 13.96,25.09 13.9,25.02 13.9,24.88 14.48,24.3 15.25,24.3 v2(15.41,24.46) ; RC53.2 98.37,41.98 98.12,41.98 v2(97.4,41.26)
CLK_PEG_VGA: length 63.7
  TOP w0.102: v2(93.95,39.57) 94.21,39.32 94.63,39.32 94.74,39.43 RC179.2
  IN1 w0.097: 71.36,74.21 72.35,73.21 74.97,73.21 75.21,73.46 78.53,73.46 81.03,70.96 81.03,66.86 82.83,65.07 82.83,60.06 86.6,56.3 86.6,50.01 86.18,49.6 86.18,38.68 86.99,37.86 92.66,37.86 92.9,38.11 92.9,38.94 93.21,39.25 93.63,39.25 v2(93.95,39.57)
  IN1 w0.102: 71.36,74.21 71,74.56 67.75,74.56 66.88,75.43 66.88,75.9 67.12,76.14 67.42,76.14 67.47,76.09 67.47,75.87 v4(67.35,75.74)
  BOTTOM w0.1: UV1.AE8 66.94,75.35 67.33,75.74 v4(67.35,75.74)
CLK_PEG_VGA#: length 63.6
  TOP w0.102: v2(93.95,38.99) 94.02,39.05 94.55,39.05 RC157.2
  IN1 w0.097: v2(93.95,38.99) 93.32,38.99 93.17,38.83 93.17,38 92.77,37.6 86.89,37.6 85.92,38.57 85.92,49.71 86.33,50.12 86.33,56.19 82.57,59.95 82.57,64.96 80.77,66.76 80.77,70.86 78.43,73.2 75.32,73.2 75.08,72.95 72.24,72.95 71.07,74.13 71.07,74.12
  IN1 w0.102: 71.07,74.12 70.89,74.3 67.64,74.3 66.61,75.32 66.61,76.01 67.01,76.4 67.22,76.4 v4(67.35,76.53)
  BOTTOM w0.1: v4(67.35,76.53) 66.97,76.15 UV1.AD8
CLK_TP_SIO: length 49.6
  TOP w0.102: U38.A37 146.89,109.66 147.2,109.96 147.2,110.39 v2(147.67,110.86) ; v2(180.27,100.84) 180.45,101.02 180.45,101.14 180.31,101.27 179.88,101.27 R444.1
  BOTTOM w0.102: v2(147.67,110.86) 147.25,110.44 147.25,109.68 146.91,109.34 146.91,106.61 147.62,105.9 147.62,104.51 148.05,104.08 149.57,104.08 151.39,102.26 152.6,102.26 154.25,100.61 154.25,99.84 154.69,99.41 158.24,99.41 161.91,103.08 171.39,103.08 172.53,104.22 175.13,104.22 176.69,102.66 177.57,102.66 179.81,100.42 180.35,100.42 180.4,100.48 180.4,100.71 v2(180.27,100.84)
CLKA0: length 47.8
  TOP w0.102: v2(37.53,91.57) 37.27,91.32 37.27,91.21 37.01,90.94 36.29,90.94 35.98,90.63 35.11,90.63 35.02,90.54 35.02,90.29 35.2,90.11 UV5.J7
  IN1 w0.097: v4(53.27,93.14) 53.27,92.92 53.2,92.86 49.46,92.86 49.36,92.96 49.36,93.1 49.13,93.34 48.76,93.34 48.53,93.1 48.53,92.96 48.43,92.86 48.14,92.86 48.04,92.96 48.04,93.34 47.84,93.54 47.41,93.54 47.21,93.34 47.21,92.96 47.11,92.86 46.82,92.86 46.72,92.96 46.72,93.34 46.52,93.54 46.09,93.54 45.88,93.34 45.88,92.96 45.79,92.86 44.38,92.86 40.39,88.86 40.39,88.03 39.72,87.37 35.6,87.37 34.52,88.44 34.52,89.89 35.5,90.87 36.77,90.87 37.24,91.35 37.31,91.35 v2(37.53,91.57) 37.31,91.79 37.31,92.13 37.06,92.38 36.74,92.38 35.79,93.33 35.03,93.33 34.48,93.88 34.48,94.67 34.94,95.13 35.6,95.13 36.1,95.63 36.1,96.31 36.3,96.52 v2(36.3,96.53)
  BOTTOM w0.102: RV2707.2 36.49,97.73 RV2706.1 36.1,97.32 36.1,96.72 v2(36.3,96.53) ; v4(53.27,93.14) 53.29,93.12 53.29,93.12 53.66,92.75 UV1.D24 ; UV4.J7 35.23,93.28 35.23,93.12 35.28,93.07 35.53,93.07 35.67,92.93 36.16,92.93 37.22,91.86 37.22,91.58 37.35,91.46 37.42,91.46 v2(37.53,91.57)
CLKA0#: length 47.9
  TOP w0.102: v2(36.83,91.58) 37.06,91.36 37.06,91.26 36.93,91.13 36.21,91.13 35.9,90.82 35.04,90.82 34.84,90.62 34.84,90.49 UV5.K7
  IN1 w0.097: v4(53.25,92.33) 52.89,92.68 49.39,92.68 49.19,92.88 49.19,93.03 49.06,93.16 48.83,93.16 48.7,93.03 48.7,92.88 48.5,92.68 48.07,92.68 47.87,92.88 47.87,93.26 47.77,93.36 47.48,93.36 47.38,93.26 47.38,92.88 47.18,92.68 46.75,92.68 46.55,92.88 46.55,93.26 46.45,93.36 46.16,93.36 46.06,93.26 46.06,92.88 45.86,92.68 44.45,92.68 40.56,88.79 40.56,87.95 39.8,87.19 35.52,87.19 34.34,88.37 34.34,89.96 35.43,91.05 36.69,91.05 36.91,91.26 36.91,91.52 36.84,91.58 v2(36.83,91.58) 37.13,91.88 37.13,92.06 36.98,92.21 36.66,92.21 35.72,93.15 34.96,93.15 34.3,93.8 34.3,94.74 34.87,95.3 35.52,95.3 35.92,95.7 35.92,96.32 v2(35.72,96.53)
  BOTTOM w0.102: v2(36.83,91.58) 36.97,91.72 36.97,91.85 36.08,92.74 35.59,92.74 35.45,92.88 34.89,92.88 UV4.K7 ; v4(53.25,92.33) 53.25,92.38 52.87,92.76 UV1.D25 ; v2(35.72,96.53) 35.91,96.72 35.91,97.39 RV2706.2 35.6,97.73 RV2708.2
CLKA1: length 53
  TOP w0.102: UV7.J7 35.15,74.48 35.15,74.74 35.54,75.12 37.03,75.12 37.29,75.39 37.29,75.57 v2(37.54,75.82) ; RV2718.2 37.31,69.89 RV2717.1 36.93,70.3 36.93,70.64 v2(37.06,70.77)
  IN1 w0.097: v2(37.06,70.77) 36.85,70.98 36.85,71.24 36.62,71.47 35.2,71.47 34.42,72.25 34.42,73.98 35.56,75.13 37.01,75.13 37.26,75.38 37.26,75.54 v2(37.54,75.82) 37.25,76.12 37.25,76.38 36.99,76.64 36.74,76.64 36.29,77.08 33.45,77.08 33.32,77.21 33.32,78.85 33.43,78.96 34.02,78.96 34.25,79.19 34.25,79.56 34.02,79.79 33.43,79.79 33.32,79.9 33.32,80.24 33.45,80.37 38.63,80.37 39.21,80.94 44.76,80.94 49.75,85.93 55.18,85.93 55.32,86.07 55.59,86.07 55.71,85.95 v4(55.71,85.69)
  BOTTOM w0.102: UV1.N22 55.35,85.29 55.71,85.65 v4(55.71,85.69) ; v2(37.54,75.82) 37.43,75.71 37.36,75.71 37.24,75.83 37.24,76.1 36.16,77.18 35.68,77.18 35.54,77.32 35.29,77.32 35.24,77.37 35.24,77.53 UV6.J7
CLKA1#: length 53.3
  TOP w0.102: RV2719.2 36.42,69.89 RV2717.2 36.74,70.23 36.74,70.51 v2(36.48,70.77) ; UV7.K7 34.53,74.36 34.96,74.79 34.96,74.81 35.46,75.31 36.95,75.31 37.1,75.46 37.1,75.58 v2(36.84,75.83)
  IN1 w0.097: v2(36.48,70.77) 36.68,70.97 36.68,71.16 36.55,71.29 35.13,71.29 34.24,72.18 34.24,74.05 35.49,75.3 36.93,75.3 37.08,75.46 37.08,75.59 v2(36.84,75.83) 37.06,76.05 37.06,76.32 36.92,76.46 36.66,76.46 36.22,76.9 33.38,76.9 33.15,77.13 33.15,78.92 33.36,79.13 33.95,79.13 34.07,79.26 34.07,79.49 33.95,79.62 33.36,79.62 33.15,79.83 33.15,80.32 33.38,80.55 38.56,80.55 39.13,81.12 44.69,81.12 49.68,86.11 55.11,86.11 55.25,86.25 55.43,86.25 v4(55.69,86.51)
  BOTTOM w0.102: v4(55.69,86.51) 55.69,86.5 55.31,86.12 UV1.M22 ; UV6.K7 34.9,77.13 35.46,77.13 35.6,76.99 36.08,76.99 36.98,76.08 36.98,75.97 v2(36.84,75.83)
CLKRQ_GPU#: length 6.1
  TOP w0.102: v2(69.87,77.45) 69.88,77.45 v1(70.88,78.45) 72.06,79.63 RV2433.2 72.06,80.75 72.24,80.93 QC11.4
  BOTTOM w0.102: v2(69.87,77.45) 69.07,77.45 UV1.AC6
CLKRUN#: length 161.4
  TOP w0.102: v2(156.69,111.31) 156.53,111.15 U25.15 ; v2(151.38,109.3) 151.38,107.98 150.97,107.56 U38.A32 ; U37.B20 162.89,100.59 163.55,100.59 v2(163.55,100.59)
  IN1 w0.097: v2(117.17,64.7) 117.17,64.69 116.68,64.21 116.68,62.41 117.76,61.33 117.76,60 117,59.24 117,58.22 118.59,56.63 118.59,56.44 119.16,55.87 121.96,55.87 122.53,56.44 126.78,56.44 129.69,59.35 129.69,61.04 132.84,64.19 132.84,65.87 135.17,68.19 135.17,68.49 137.45,70.77 137.45,71.43 138.94,72.92 138.94,79.75 140.67,81.47 141.15,81.47 144.58,84.9 144.58,85.54 v2(145.01,85.97) 145.59,85.39 151.17,85.39 152.69,86.9 153.93,86.9 154.32,87.29 154.32,88.49 156.32,90.49 158.7,90.49 160.48,92.27 160.48,95.35 159.52,96.31 159.52,99.54 160.12,100.13 163.1,100.13 v2(163.55,100.59)
  IN3 w0.102: v2(156.69,111.31) 156.69,110.45 156.99,110.15 163.65,110.15 164.39,109.41 164.39,107.66 163.63,106.9 163.63,106.47 162.82,105.66 162.34,105.66 161.61,104.92 161.61,103.46 162.62,102.45 162.62,100.79 162.82,100.59 v2(163.55,100.59) ; v2(121.96,86.45) 122.44,86.94 123.09,86.94 123.85,86.17 135.89,86.17 136.63,86.91 140.37,86.91 141.11,86.17 144.8,86.17 v2(145.01,85.97)
  BOTTOM w0.076: v2(117.17,64.7) 117.05,64.58 UC1.V5
  BOTTOM w0.102: v2(151.38,109.3) 151.38,109.3 152.5,110.42 153.52,110.42 154.41,111.31 v2(156.69,111.31) ; RC80.2 v1(113.14,81.78) 112.19,82.73 112.19,83.29 111.04,84.45 111.04,86.37 111.76,87.1 114.53,87.1 115.06,87.62 117.13,87.62 117.54,87.21 121.2,87.21 v2(121.96,86.45)
CODEC_IRQ: length 1.8
  TOP w0.102: RC154.1 113.41,64.81 112.62,65.6 v2(112.62,65.65)
  BOTTOM w0.076: v2(112.62,65.65) 113.01,65.26 UC1.L4
CPU_DETECT#: length 199.6
  TOP w0.102: v2(106.52,28.38) 106.72,28.57 109.41,28.57 112.61,25.37 112.61,21.45 113.44,20.62 114.03,20.62 115.04,19.61 115.04,18.03 115.8,17.26 118.02,17.26 v2(118.66,17.9) ; U37.A3 170.23,103.48 169.96,103.75 169.96,104.13 v2(170.41,104.58) 170.22,104.77 R284.2
  IN2 w0.102: v2(118.66,17.9) 118.98,17.9 120.34,19.26 128.5,19.26 131.72,16.03 151.82,16.03 155.05,19.26 155.05,50.41 156.18,51.54 156.18,68.39 155.68,68.9 155.68,70.09 158.37,72.78 158.37,75.78 159.08,76.5 159.08,82.71 160.82,84.45 160.82,85.4 161.11,85.69 163.19,85.69 163.42,85.46 164.5,85.46 165.14,84.83 172.26,84.83 175.37,87.94 176.36,87.94 179.15,90.72 179.15,91.71 180.38,92.94 180.38,94.26 184.31,98.19 184.31,101.32 186.73,103.73 v2(186.73,111.43)
  BOTTOM w0.076: v2(106.52,28.38) 106.7,28.2 107.29,28.2 107.52,28.44 107.52,28.72 107.59,28.79 107.59,29.37 107.88,29.66 108.11,29.66 UC1.D61
  BOTTOM w0.102: v2(118.66,17.9) v1(118.66,17.31) ; v2(186.73,111.43) 186.22,110.93 184.38,110.93 181.01,107.56 178.28,107.56 175.49,104.77 172,104.77 171.55,104.32 170.66,104.32 v2(170.41,104.58)
CPU_DPB_AUX: length 65.9
  TOP w0.102: v2(115.54,92.43) 115.72,92.61 115.96,92.61 117.23,91.34 121.73,91.34 122.79,92.4 122.79,95.85 122.9,95.97 C19.1
  IN1 w0.097: v2(115.54,92.43) 115.42,92.55 114.55,92.55 113.1,91.11 108.22,91.11 106.88,89.76 104.77,89.76 103.19,88.17 100.5,88.17 97.95,85.62 97.95,84.32 96.72,83.09 96.72,78.15 96.99,77.89 96.99,70.31 98.21,69.09 98.21,68.13 98.04,67.96 97.67,67.96 v2(97.49,67.77)
  BOTTOM w0.076: 105.6,64.8 105.6,64.79 105.61,64.78 105.61,64.73 106.17,64.16 107.09,64.16 UC1.B5
  BOTTOM w0.102: 105.6,64.8 105.6,65.06 105.01,65.64 104.73,65.64 103.86,66.51 102.62,66.51 102.23,66.89 102.23,67.66 101.47,68.42 99.38,68.42 98.95,68 97.71,68 v2(97.49,67.77) 97.3,67.95 96.78,67.95 RC153.2
CPU_DPB_AUX#: length 65.9
  TOP w0.102: v2(115.54,93.02) 115.73,92.83 116.05,92.83 117.32,91.56 121.64,91.56 122.57,92.49 122.57,95.73 C20.1
  IN1 w0.097: v2(115.54,93.02) 115.29,92.76 114.46,92.76 113.02,91.32 108.14,91.32 106.79,89.97 104.69,89.97 103.1,88.38 100.42,88.38 97.74,85.71 97.74,84.41 96.51,83.18 96.51,78.06 96.78,77.8 96.78,70.22 98,69 98,68.21 97.95,68.17 97.67,68.17 v2(97.49,68.35)
  BOTTOM w0.076: 105.81,64.8 105.81,64.79 106.28,64.33 107.02,64.33 107.06,64.37 107.66,64.37 UC1.C5
  BOTTOM w0.102: 105.81,64.8 105.81,65.14 105.1,65.86 104.82,65.86 103.95,66.73 102.7,66.73 102.45,66.98 102.45,67.75 101.56,68.63 99.29,68.63 98.86,68.21 97.63,68.21 v2(97.49,68.35) 97.3,68.17 96.78,68.17 RC147.2
CPU_DPB_AUX#_C: length 4.7
  TOP w0.102: U6.H2 121.42,100.56 121.42,99.89 121.87,99.44 122.57,98.74 122.57,97.13 C20.2
CPU_DPB_AUX_C: length 4.6
  TOP w0.102: U6.H1 121.86,100.21 121.94,100.13 121.94,99.98 121.82,99.86 121.82,99.8 122.79,98.83 122.79,96.77 122.85,96.7 123.03,96.7 C19.2
CPU_DPB_CTRLCLK: length 12.5
  BOTTOM w0.076: 100.94,64.43 100.95,64.43 100.96,64.44 101.97,64.44 102.68,63.73 104.38,63.73 105.53,62.58 105.68,62.42 105.7,62.42 105.7,62.42 106.07,62.05 106.74,62.05 107.18,61.62 UC1.B9
  BOTTOM w0.102: 100.94,64.43 98.11,64.43 v3(97.65,64.89) 97.51,65.04 96.75,65.04 96.61,64.9 RP1.8
CPU_DPB_CTRLDAT: length 12.9
  BOTTOM w0.076: UC1.C9 107.2,61.86 106.85,62.22 106.17,62.22 105.89,62.5 105.89,62.5 105.67,62.73 104.46,63.94 v3(102.99,63.94) 102.77,63.94 102.05,64.65 101.25,64.65 101.24,64.66 100.94,64.66
  BOTTOM w0.102: RP1.7 96.68,65.4 96.82,65.26 97.6,65.26 98.21,64.66 100.94,64.66
CPU_DPC_AUX: length 7.4
  BOTTOM w0.076: 103.54,65.12 104.27,65.12 105.92,63.46 UC1.A6
  BOTTOM w0.102: 103.54,65.12 v1(101.08,65.12) 99.83,65.12 RC155.2
CPU_DPC_AUX#: length 15.3
  TOP w0.102: v2(97.18,69.25) v1(97.96,69.25)
  IN2 w0.102: v2(102.62,64.58) 101.07,64.58 98.91,66.75 98.91,68.25 97.91,69.25 v2(97.18,69.25)
  BOTTOM w0.076: v2(102.62,64.58) 102.98,64.94 104.21,64.94 106.05,63.1 UC1.B6
  BOTTOM w0.102: v2(97.18,69.25) 97.03,69.4 RC149.2
CPU_PWR_DEBUG#: length 44.4
  TOP w0.102: v2(110.97,21.45) 112.28,21.45 113.36,20.37 113.89,20.37 114.78,19.49 114.78,17.9 115.67,17.01 118.38,17.01 120.23,18.86 130.51,18.86 131.32,19.67 135.93,19.67 v1(137.28,18.32) 137.96,17.64 RC108.1
  BOTTOM w0.076: UC1.H59 110.39,30.89 110.39,29.84 110.26,29.71 110.26,28.94 110.43,28.78 110.43,27.47 110.59,27.31 110.59,25.9
  BOTTOM w0.102: 110.59,25.9 110.59,25.58 110.43,25.42 110.43,22.62 RC258.1 110.97,22.08 v2(110.97,21.45) RC253.2
CPU_PWR_DEBUG#_R: length 3
  TOP w0.102: RC108.2 137.65,14.79 JXDP1.45
CPU_VTT_ON: length 4.6
  TOP w0.102: R305.2 161.52,104.63 161.56,104.59 161.56,103.31 161.9,102.96 163.14,102.96 163.48,102.61 U37.B17
CPU_XDP_PRDY#: length 52.6
  TOP w0.076: v2(111.06,29.59) 113.29,27.36 113.29,25.9
  TOP w0.102: JXDP1.5 147.65,14.49 v1(140.85,21.3) 139.08,23.07 129.27,23.07 127.66,21.45 124.47,21.45 123.9,22.02 119.86,22.02 119.1,21.26 119.1,20.76 117.96,19.61 116.42,19.61 114.64,21.4 113.63,21.4 113.29,21.73 113.29,25.9
  BOTTOM w0.076: v2(111.06,29.59) 111.42,29.24 UC1.J62
CPU_XDP_PREQ#: length 52.2
  TOP w0.102: v2(113.76,21.83) 114.52,21.83 116.49,19.87 117.83,19.87 118.85,20.88 118.85,21.39 119.71,22.25 124,22.25 124.57,21.68 127.56,21.68 129.17,23.3 139.49,23.3 v1(144.18,18.61) 148.15,14.64 JXDP1.3
  BOTTOM w0.076: UC1.K62 112.66,28.79 112.66,28.79 112.67,28.78 112.67,28.28 112.49,28.1 112.49,27.04 112.6,26.94 112.6,25.9
  BOTTOM w0.102: RC120.2 v2(113.76,21.83) 113.76,21.84 112.6,23 112.6,25.9
