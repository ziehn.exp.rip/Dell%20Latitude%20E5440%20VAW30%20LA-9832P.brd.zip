# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 97,146.29 97,145.28 96.62,144.9 90.9,144.9 90.52,145.28 90.52,146.29 90.65,146.42 96.87,146.42
GND on TOP (solid shape): 100.49,167.44 100.49,166.55 100.37,166.42 97.19,166.42 97,166.62 97,167.38 97.19,167.57 100.37,167.57
GND on TOP (solid shape): 127.67,113.85 127.67,113.21 127.55,113.08 126.72,113.08 126.4,112.77 124.05,112.77 123.93,112.89 123.93,113.78 124.12,113.97 127.55,113.97
GND on TOP (solid shape): 138.19,42.35 138.19,41.7 138.01,41.52 137.2,41.52 136.77,41.95 134.34,41.95 134.21,42.07 134.21,42.65 134.28,42.72 137.82,42.72
GND on TOP (solid shape): 144.51,79.54 144.51,75.42 144.13,75.04 143.63,75.04 143.62,75.04 143.61,75.05 142.62,75.05 142.62,79.79 142.64,79.81 144.24,79.81
GND on TOP (solid shape): 163.3,124.32 163.3,122.86 163.17,122.74 162.09,122.74 162.09,124.39 162.28,124.58 163.04,124.58
GND on TOP (solid shape): 181.52,124.9 181.52,123.5 181.28,123.26 179.53,123.26 179.36,123.44 179.36,125.02 179.49,125.15 181.27,125.15
GND on TOP (solid shape): 183.23,81.59 183.23,78.92 183.11,78.79 181.39,78.79 180.76,79.43 180.76,81.53 181.01,81.78 183.04,81.78
GND on TOP (solid shape): 184.7,74.12 184.7,73.09 184.57,72.97 183.01,72.97 182.66,73.32 181.96,73.32 181.86,73.42 181.86,74.07 182.15,74.36 184.46,74.36
GND on TOP (solid shape): 314.17,154.93 314.17,154.55 314.04,154.42 312.08,154.42 311.95,154.55 311.95,154.87 312.01,154.93 312.39,154.93 312.58,155.12 313.98,155.12
GND on TOP (solid shape): 51.24,85 51.24,84.79 51.34,84.69 51.34,84.12 51.12,83.9 48.63,83.9 48.52,84.01 48.52,85.17 48.61,85.26 50.99,85.26
GND on TOP (solid shape): 72.68,84.51 72.68,83.24 72.62,83.18 69.32,83.18 69.13,82.99 68.43,82.99 68.11,83.3 68.11,84.38 71.92,84.38 72.17,84.64 72.55,84.64
GND on TOP (solid shape): 121.39,132.68 121.39,131.44 121.2,131.25 120.24,131.25 120.12,131.37 120.12,132.64 120.37,132.9 121.07,132.9 121.07,132.9 121.16,132.9
GND on TOP (solid shape): 157.01,56.38 157.01,50.54 156.69,50.22 150.91,50.22 146.28,54.85 146.28,61.08 146.91,61.71 151.68,61.71
GND on TOP (solid shape): 240.45,154.55 240.45,150.8 240.26,150.61 239.18,150.61 238.99,150.8 238.99,154.49 239.31,154.8 240.19,154.8
GND on TOP (solid shape): 19.34,82.41 19.34,81.59 17.88,81.59 17.63,81.33 15.91,81.33 15.79,81.46 15.79,82.29 15.98,82.48 19.28,82.48
GND on TOP (solid shape): 58.46,75.43 58.8,75.09 58.8,73.61 58.76,73.57 57.85,73.57 57.65,73.77 57.65,75.05 57.17,75.53 57.17,76.76 57.36,76.95 58.46,76.95
GND on TOP (solid shape): 89.57,109.53 89.57,107.43 89.45,107.31 88.81,107.31 88.75,107.37 88.75,107.94 88.18,108.51 88.18,109.47 88.37,109.66 89.45,109.66
GND on TOP (solid shape): 122.59,113.72 122.59,112.77 116.56,112.77 116.24,112.45 116.24,111.94 115.61,111.94 115.61,112.83 115.8,112.83 116.94,113.97 122.34,113.97
GND on TOP (solid shape): 214.92,127.31 215.18,127.31 215.37,127.12 215.37,126.67 214.79,126.1 210.67,126.1 207.24,129.53 207.24,132.39 209.84,132.39
GND on TOP (solid shape): 252.06,170.62 253.53,170.62 253.53,169.98 253.28,169.73 247.88,169.73 247.69,169.92 247.69,170.62 249.9,170.62 251.38,170.62
GND on TOP (solid shape): 17.12,101.34 17.12,94.23 16.8,93.91 16.17,93.91 16.17,96.77 15.4,97.53 15.4,101.53 15.72,101.85 16.61,101.85
GND on TOP (solid shape): 55.16,74.32 55.38,74.1 55.38,72.64 55.25,72.51 54.11,72.51 53.92,72.7 53.92,75.21 54.08,75.37 55.16,75.37
GND on TOP (solid shape): 72.7,89.61 72.7,89.18 72.58,89.06 69.57,89.06 69.22,88.71 68.94,88.71 68.8,88.86 68.8,89.2 69.61,90.02 69.61,90.16 69.74,90.29 72.02,90.29
GND on TOP (solid shape): 86.33,115.12 86.65,114.8 86.78,114.8 86.91,114.67 86.91,113.91 85.76,112.77 85.76,112.26 85.13,112.26 85.13,116.67 85.83,117.37 86.33,117.37
GND on TOP (solid shape): 115.73,156.52 116.3,155.95 116.3,153.28 116.18,153.15 114.72,153.15 114.46,153.41 114.46,157.41 114.72,157.66 115.73,157.66
GND on TOP (solid shape): 138.23,40.19 138.23,39.51 137.98,39.25 134.38,39.25 134.25,39.38 134.25,39.91 134.31,39.97 136.87,39.97 137.2,40.3 138.13,40.3
GND on TOP (solid shape): 174.92,127.63 174.92,127.05 174.85,126.99 173.71,126.99 173.46,126.74 173.46,126.17 172.95,126.17 172.95,127.69 173.07,127.82 174.73,127.82
GND on TOP (solid shape): 94.14,73.08 94.78,72.44 95.35,72.44 95.35,71.56 94.91,71.11 93.89,71.11 93.64,71.37 93.64,72.25 93.45,72.44 93.45,72.7 93.64,72.89 93.64,73.4 94.14,73.4
GND on TOP (solid shape): 181.01,129.91 181.01,128.9 180.76,128.64 177.77,128.64 177.27,129.15 177.27,129.85 177.39,129.98 179.81,129.98 179.93,130.1 180.82,130.1
GND on TOP (solid shape): 194.92,79.62 194.92,77.14 194.41,76.64 194.28,76.64 193.27,75.62 193.27,75.56 191.49,75.56 191.24,75.81 191.24,79.75 191.36,79.87 194.66,79.87
GND on TOP (solid shape): 123.29,165.91 123.29,163.31 123.04,163.06 121.26,163.06 121.2,163.12 121.2,165.77 120.25,166.71 120.25,168.2 120.31,168.25 120.95,168.25
GND on TOP (solid shape): 138.91,37.62 138.91,36.66 138.65,36.41 134.54,36.41 134.31,36.63 134.31,37.41 134.36,37.46 137.09,37.46 137.14,37.47 137.18,37.5 137.42,37.74 138.79,37.74
GND on TOP (solid shape): 177.96,117.34 177.96,116.96 177.84,116.83 177.08,116.83 176.82,116.58 176.82,116.13 176.44,115.75 175.61,115.75 175.61,117.28 176.19,117.28 176.38,117.47 177.84,117.47
GND on TOP (solid shape): 69.93,25.79 69.93,19.91 68.49,18.47 59.54,18.47 59.22,18.79 59.22,21.01 59.54,21.33 63.16,21.33 66.14,24.31 66.14,26.53 66.39,26.79 68.93,26.79
GND on TOP (solid shape): 201.39,149.09 201.39,147.31 201.27,147.18 199.49,147.18 199.36,147.06 199.36,145.66 199.49,145.53 199.74,145.53 199.87,145.41 199.87,144.77 199.81,144.71 194.73,144.71 194.66,144.77 194.66,149.15 195.08,149.57 200.92,149.57
GND on TOP (solid shape): 90.9,75.3 90.9,71.26 90.88,71.24 90.88,69.59 90.25,69.59 90.25,70.76 90.02,70.98 90.02,75.3 90.08,75.37 90.84,75.37
GND on TOP (solid shape): 95.1,97.4 96.24,97.4 96.3,97.34 96.3,96.32 96.18,96.19 95.41,96.19 95.29,96.32 95.29,96.7 94.72,97.27 94.21,97.27 94.08,97.4 94.08,97.65 94.21,97.78 94.72,97.78
GND on TOP (solid shape): 26.77,69.28 26.77,66.67 26.64,66.54 25.88,66.54 25.76,66.66 25.76,67.67 25.44,68 25.44,69.14 24.99,69.59 24.99,70.25 25.02,70.28 25.77,70.28
GND on TOP (solid shape): 111.48,102.73 111.48,102.35 111.8,102.04 113,102.04 113.26,101.78 113.26,101.27 111.67,101.27 111.42,101.53 110.27,101.53 110.15,101.65 110.15,102.1 109.45,102.8 108.81,102.8 108.81,103.43 110.78,103.43
GND on TOP (solid shape): 153.2,80.13 153.2,79.94 152.88,79.62 152.88,78.86 153.07,78.67 153.58,78.67 153.71,78.54 153.71,76.95 153.14,76.38 150.21,76.38 150.15,76.45 150.15,77.97 150.28,78.1 151.29,78.1 151.55,78.35 151.55,80.19 151.68,80.32 153.01,80.32
GND on TOP (solid shape): 85.76,71.56 85.85,71.4 86,71.31 87.35,69.97 87.35,68.57 87.16,68.38 86.27,68.38 85.95,68.7 84.62,68.7 84.37,68.44 84.05,68.44 81.95,70.54 81.95,71.24 83.03,72.32 85,72.32
GND on TOP (solid shape): 62.39,90.16 62.39,89.59 62.71,89.27 62.97,89.27 63.09,89.15 63.09,88.95 62.97,88.83 62.52,88.83 61.89,89.46 59.41,89.46 58.65,88.7 58.65,87.62 57.82,86.8 57.38,86.8 57.19,86.99 57.19,88.32 57.44,88.57 57.95,88.57 58.39,89.02 58.39,90.16 58.58,90.35 62.2,90.35
GND on TOP (solid shape): 62.67,78.22 62.67,77.69 62.56,77.58 61.56,77.58 61.31,77.34 61.31,76.47 61.82,75.96 61.82,73.52 62.01,73.33 62.01,73.02 61.89,72.89 61.13,72.89 60.57,73.45 60.57,76.04 60.44,76.17 60.44,78.13 60.54,78.23 61.25,78.23 61.47,78.45 62.44,78.45
GND on TOP (solid shape): 197.96,139.82 198.09,139.69 199.74,139.69 199.87,139.56 199.87,139.18 200.25,138.8 201.27,138.8 201.52,138.55 201.52,136.39 201.24,136.11 198.56,136.11 198.41,136.26 198.03,136.26 197.71,136.58 195.43,136.58 195.17,136.83 195.17,139.69 194.79,140.07 194.79,140.88 197.96,140.88
GND on TOP (solid shape): 175.28,83.91 175.28,82.9 175.28,82.89 175.28,82.82 175.32,82.78 175.65,82.78 175.87,82.99 175.87,83.91 175.92,83.96 176.04,83.96 176.1,83.91 176.1,83 176.02,82.92 176.02,82.92 175.97,82.87 175.97,81.18 174.36,81.18 174.36,82.78 175.02,82.78 175.05,82.82 175.05,83.91 175.13,83.99 175.21,83.99
GND on TOP (solid shape): 102.72,161.47 102.72,158.87 102.91,158.68 104.88,158.68 105.19,158.36 105.19,156.77 105.7,156.26 108.75,156.26 108.94,156.07 108.94,153.79 108.5,153.34 102.84,153.34 101.59,154.59 101.59,159.74 101.07,160.27 97.94,160.27 97.59,160.62 97.59,161.71 97.66,161.79 102.4,161.79
GND on TOP (solid shape): 179.56,115.31 179.56,112.66 178.98,112.08 176.31,112.08 176.3,112.1 175.9,112.1 175.61,112.23 175.33,112.1 173.8,112.1 173.48,112.42 173.48,113.91 173.54,113.97 174.22,113.97 174.41,114.16 174.41,114.42 175.87,114.42 176.12,114.67 176.12,114.85 177.15,115.87 179,115.87
GND on TOP (solid shape): 211.75,141.22 211.75,135.25 210.92,134.42 208.06,134.42 207.62,134.87 207.62,136.83 207.75,136.96 208.38,136.96 208.38,136.52 208.19,136.33 208.19,135.31 208.51,134.99 209.71,134.99 210.86,136.14 210.86,140.14 210.1,140.9 208.7,140.9 208.38,140.58 208.38,139.18 207.87,139.18 207.75,139.31 207.75,141.02 208.38,141.66 211.3,141.66
GND on TOP (solid shape): 128.69,105.91 128.82,105.78 129.26,105.78 129.64,105.4 129.64,105.27 131.42,103.5 131.42,103.31 131.67,103.05 131.67,101.72 131.8,101.59 132.36,101.59 132.37,101.59 132.75,101.59 133.13,101.21 133.64,101.21 133.64,99.75 133.13,99.75 133.13,100.19 132.88,100.45 131.1,100.45 130.53,101.02 128.43,101.02 128.18,101.27 128.18,103.05 128.69,103.05 128.69,102.67 128.94,102.42 129.77,102.42 130.09,102.1 130.91,102.1 131.04,102.23 131.04,103.18 129.77,104.45 128.94,104.45 128.69,104.19 128.18,104.19 128.18,106.54 128.69,106.54
GND on TOP (solid shape): 2.46,41.04 2.28,40.4 1.8,39.93 1.26,39.02 1.8,38.11 2.28,37.64 2.46,37 2.46,36.31 1.95,36.31 1.95,37 1.85,37.39 1.56,37.66 0.75,39.02 1.56,40.38 1.85,40.65 1.95,41.04 1.95,42.34 2.46,42.34
GND on TOP (solid shape): 10.42,90.13 10.53,89.95 10.69,89.82 10.69,89.26 12.44,87.51 12.44,85.54 13.16,84.82 13.88,84.82 14.39,84.32 14.39,83.29 15.2,81.88 13.95,80.84 13.21,80.84 13.21,81.1 13.28,81.28 13.45,81.35 13.95,81.35 14.71,82.1 13.95,82.86 3.13,82.86 2.97,82.94 2.9,83.1 2.9,86.56 2.98,86.73 3.15,86.8 7.8,86.8 9.93,86.8 10.67,87.42 10.18,88.26 10.18,90.17 10.41,90.17
GND on TOP (solid shape): 13.95,70.86 15.22,69.6 13.95,68.34 13.94,68.34 13.94,67.62 11.85,67.62 11.85,68.28 11.78,68.34 6.51,68.34 6.51,67.56 5.12,67.56 5.12,68.34 3.66,68.34 3.66,66.25 3.31,65.38 2.46,64.99 2.46,41.46 1.95,41.46 1.95,65.25 2.03,65.43 2.2,65.5 2.4,65.5 2.93,65.72 3.15,66.25 3.15,68.6 3.23,68.78 3.4,68.85 13.95,68.85 14.71,69.6 13.95,70.36 13.45,70.36 13.28,70.43 13.21,70.6 13.21,70.86
GND on TOP (solid shape): outline of 202 points within 87.53,77.37 93.31,83.25
GND on TOP (solid shape): outline of 225 points within 53.12,42.08 73.19,54.4
GND on TOP (solid shape): outline of 103 points within 0.25,99.44 86.89,175.05
GND on TOP (solid shape): outline of 201 points within 1.95,0.25 315.8,176.95
GND on BOTTOM (solid shape): 39.03,42.47 39.03,39.49 38.84,39.3 35.85,39.3 35.53,39.62 35.53,42.41 35.91,42.79 38.71,42.79
GND on BOTTOM (solid shape): 46.33,64 46.33,61.14 46.07,60.89 44.68,60.89 44.55,61.01 44.55,64 44.74,64.19 46.14,64.19
GND on BOTTOM (solid shape): 63.85,22.09 63.85,20.82 63.6,20.56 58.9,20.56 58.65,20.82 58.65,22.22 58.77,22.34 63.6,22.34
GND on BOTTOM (solid shape): 81.89,168.33 81.89,163.63 81.44,163.19 78.46,163.19 77.82,163.82 77.82,168.33 78.27,168.77 81.44,168.77
GND on BOTTOM (solid shape): 99.41,167.44 99.41,166.55 99.29,166.42 95.54,166.42 95.41,166.55 95.41,167.38 95.6,167.57 99.29,167.57
GND on BOTTOM (solid shape): 191.41,45.11 191.41,42.05 191.1,41.74 189.2,41.74 188.75,42.2 188.75,45.14 189.02,45.41 191.11,45.41
GND on BOTTOM (solid shape): 264.39,162.87 264.39,161.92 262.99,161.92 262.36,162.55 261.21,162.55 261.21,163.38 263.88,163.38
GND on BOTTOM (solid shape): 27.28,80.83 27.28,79.56 26.83,79.11 24.04,79.11 23.66,79.49 23.66,82.29 23.98,82.6 25.5,82.6
GND on BOTTOM (solid shape): 53.19,58.6 52.81,58.22 49.12,58.22 48.93,58.41 48.93,58.6 48.74,58.79 48.74,59.74 48.81,59.81 53.19,59.81
GND on BOTTOM (solid shape): 194.98,79.56 194.98,77.24 194.44,76.7 194.09,76.7 193.96,76.83 193.96,79.68 194.09,79.81 194.73,79.81
GND on BOTTOM (solid shape): 231.76,142.8 231.76,141.81 229.96,140.01 229.52,140.01 227.56,141.98 227.56,142.51 228.87,143.82 230.73,143.82
GND on BOTTOM (solid shape): 48.23,30.22 47.73,29.71 46.65,29.71 46.58,29.77 46.58,32.76 48.23,32.76
GND on BOTTOM (solid shape): 79.41,88 79.29,87.88 79.29,83.37 79.22,83.3 78.59,83.3 78.46,83.43 78.46,88.83 78.59,88.95 79.41,88.95
GND on BOTTOM (solid shape): 84.68,56.68 84.68,53.84 84.49,53.65 83.35,53.65 83.22,53.78 83.22,56.89 83.31,56.98 84.39,56.98
GND on BOTTOM (solid shape): 87.03,14.09 87.92,14.09 87.92,13.45 87.73,13.26 83.98,13.26 83.86,13.39 83.86,14.02 84.56,14.02 85.06,14.53 86.59,14.53
GND on BOTTOM (solid shape): 94.91,161.28 94.91,160.14 94.72,159.95 91.22,159.95 90.97,160.2 90.97,162.3 91.1,162.42 93.76,162.42
GND on BOTTOM (solid shape): 100.47,161.67 100.47,160.46 100.28,160.27 96.27,160.27 96.11,160.42 96.11,161.48 96.42,161.79 100.35,161.79
GND on BOTTOM (solid shape): 132.5,168.39 132.5,164.52 132.37,164.39 131.1,164.39 130.78,164.71 130.78,168.27 131.1,168.58 132.31,168.58
GND on BOTTOM (solid shape): 94.46,44 94.46,40.82 94.33,40.69 85.32,40.69 85.19,40.82 85.19,44.19 85.32,44.31 94.14,44.31
GND on BOTTOM (solid shape): 4.16,31.93 7.09,31.93 7.09,31.36 5.43,31.36 5.18,31.11 3.59,31.11 3.47,31.23 3.47,32.06 3.59,32.19 3.91,32.19
GND on BOTTOM (solid shape): 37.29,33.72 37.29,32.63 37.03,32.38 37.03,29.73 36.93,29.63 35.48,29.63 35.41,29.71 35.41,32.3 34.82,32.88 34.82,33.6 35,33.77 37.24,33.77
GND on BOTTOM (solid shape): 76.75,61.65 75.67,60.57 73.79,60.57 73.25,61.11 73.25,61.27 73.25,61.27 73.25,63.81 73.89,64.44 76.75,64.44
GND on BOTTOM (solid shape): 90.02,29.07 96.3,29.07 96.43,28.95 96.43,28.06 96.18,27.8 82.33,27.8 82.14,27.99 82.14,28.82 82.4,29.07 88.87,29.07 89.13,29.33 89.76,29.33
GND on BOTTOM (solid shape): 96.43,36.63 96.43,33.2 96.3,33.07 86.97,33.07 86.94,33.04 82.24,33.04 82.01,33.26 82.01,36.5 82.21,36.69 96.37,36.69
GND on BOTTOM (solid shape): 191.14,31.03 191.14,27.82 190.99,27.68 187.54,27.68 187.36,27.86 187.36,30.95 187.64,31.23 190.94,31.23
GND on BOTTOM (solid shape): 198.92,160.46 198.92,158.68 198.67,158.42 195.24,158.42 194.86,158.8 194.86,159.57 195.3,160.01 195.74,160.01 196.51,160.77 198.6,160.77
GND on BOTTOM (solid shape): 207.9,157.14 207.9,154.03 207.59,153.72 203.52,153.72 203.34,153.9 203.34,156.94 203.71,157.31 207.73,157.31
GND on BOTTOM (solid shape): 66.84,58.98 66.84,56.41 66.46,56.03 62.39,56.03 61.89,56.54 61.89,57.59 62.08,57.78 62.78,57.78 64.17,59.17 66.65,59.17
GND on BOTTOM (solid shape): 77.62,57.04 77.62,53.83 77.57,53.78 76.64,53.78 76.1,54.32 76.05,54.38 75.99,54.43 75.98,54.44 75.98,56.63 76.44,57.09 77.57,57.09
GND on BOTTOM (solid shape): 265.97,169.85 265.97,168.46 267.18,167.25 269.53,167.25 269.53,165.73 266.99,165.73 266.04,166.68 263.31,166.68 262.48,167.5 262.48,169.47 262.99,169.98 265.85,169.98
GND on BOTTOM (solid shape): 183.23,81.59 183.23,76.37 183.06,76.19 179.17,76.19 178.94,76.42 178.94,79.27 179.3,79.62 181.01,79.62 181.65,80.26 181.65,81.53 181.9,81.78 183.04,81.78
GND on BOTTOM (solid shape): 42.71,34.85 42.71,31.93 42.96,31.68 42.96,29.77 42.77,29.58 40.8,29.58 40.68,29.71 40.68,31.23 39.53,32.38 39.53,33.2 39.85,33.52 39.85,33.77 40.04,33.96 40.04,34.92 40.17,35.04 42.52,35.04
GND on BOTTOM (solid shape): 86.84,160.72 86.84,160.27 86.78,160.2 84.68,160.2 83.79,159.31 83.79,156.96 83.16,156.96 81.76,158.36 81.76,159.82 82.75,160.81 86.74,160.81
GND on BOTTOM (solid shape): 94.36,49.72 94.36,48.45 94.23,48.33 91.23,48.33 91.04,48.52 87.59,48.52 87.44,48.37 87.44,48.33 84.58,48.33 84.45,48.45 84.45,49.2 84.64,49.39 87.29,49.39 87.98,50.09 93.99,50.09
GND on BOTTOM (solid shape): 160.39,82.27 160.39,81.17 160.05,80.83 157.39,80.83 157.38,80.84 156.99,80.84 156.69,81.14 155.15,81.14 155.12,81.18 155.12,81.76 155.13,81.78 156.82,81.78 157.52,82.48 160.18,82.48
GND on BOTTOM (solid shape): 256.64,160.9 256.83,160.71 257.4,160.71 257.97,160.14 258.61,160.14 258.61,159.5 257.53,159.5 257.34,159.31 256.83,159.31 256.83,159.82 256.64,160.01 255.88,160.01 255.69,160.2 255.69,160.58 255.43,160.84 253.97,160.84 253.97,161.41 254.1,161.54 256.64,161.54
GND on BOTTOM (solid shape): 80.56,42.66 80.56,41.77 78.21,39.42 70.01,39.42 69.76,39.68 69.76,42.35 69.95,42.54 73.13,42.54 73.32,42.35 73.32,41.27 73.51,41.08 75.22,41.08 75.48,41.33 75.48,42.41 75.67,42.6 78.59,42.6 78.84,42.85 80.36,42.85
GND on BOTTOM (solid shape): 68.24,22.34 69.79,20.79 69.79,19.32 70.58,18.53 73.95,18.53 74.59,17.9 74.59,12.06 73.85,11.32 59.71,11.32 59.53,11.5 59.53,14.6 60.17,15.23 62.58,15.23 62.58,15.23 62.84,15.23 63.41,14.66 63.41,13.26 63.98,12.69 69.06,12.69 69.57,13.2 69.57,16.56 68.11,18.03 66.84,18.03 66.2,18.66 66.2,22.67 66.03,22.84 66.03,26.89 66.06,26.92 68.24,26.92
GND on BOTTOM (solid shape): 62.9,49.9 62.9,42.47 62.71,42.28 61.89,42.28 61.7,42.09 57.5,42.09 57.19,42.41 55.28,42.41 54.77,41.9 52.04,41.9 51.03,40.89 49.25,40.89 48.74,41.39 48.74,43.81 48.81,43.87 49.69,43.87 49.69,43.23 49.88,43.04 51.79,43.04 51.92,43.17 51.92,44.31 52.11,44.5 55.28,44.5 55.47,44.31 55.47,43.23 55.66,43.04 57.38,43.04 57.63,43.3 57.63,44.38 57.82,44.57 60.74,44.57 61.19,45.01 61.19,49.84 61.44,50.09 62.71,50.09
GND on BOTTOM (solid shape): 165.86,69.4 165.94,69.35 165.95,69.25 165.91,69.13 165.91,69.01 165.92,68.99 164.86,67.93 163.64,67.93 163.62,67.95 163.6,67.98 163.57,68.05 163.6,68.13 163.62,68.15 163.64,68.17 164.08,68.17 164.64,68.74 164.67,68.73 165.02,68.87 165.05,69.25 165.05,69.35 165.14,69.4
GND on BOTTOM (solid shape): 169.7,13.27 169.72,13.25 169.74,13.23 169.77,13.15 169.74,13.08 169.72,13.05 169.7,13.03 169.54,13.03 168.84,12.33 168.81,12.34 168.44,12.17 168.47,11.76 168.48,11.66 168.39,11.6 167.58,11.6 167.49,11.66 167.5,11.76 167.57,11.9 167.57,12.05 167.57,12.08 168.76,13.27
GND on BOTTOM (solid shape): 2.46,41.04 2.28,40.4 1.8,39.93 1.26,39.02 1.8,38.11 2.28,37.64 2.46,37 2.46,36.31 1.95,36.31 1.95,37 1.85,37.39 1.56,37.66 0.75,39.02 1.56,40.38 1.85,40.65 1.95,41.04 1.95,42.34 2.46,42.34
GND on BOTTOM (solid shape): 13.95,70.86 15.22,69.6 13.95,68.34 13.94,68.34 13.94,67.62 11.85,67.62 11.85,68.34 6.51,68.34 6.51,67.56 5.12,67.56 5.12,68.34 3.66,68.34 3.66,66.25 3.31,65.38 2.46,64.99 2.46,41.26 1.95,41.26 1.95,65.25 2.03,65.43 2.2,65.5 2.4,65.5 2.93,65.72 3.15,66.25 3.15,68.6 3.23,68.78 3.4,68.85 13.95,68.85 14.71,69.6 13.95,70.36 13.45,70.36 13.28,70.43 13.21,70.6 13.21,70.86
GND on BOTTOM (solid shape): 10.42,90.13 10.53,89.95 10.69,89.82 10.69,88.56 11.01,88.2 11.18,87.75 12.61,87.75 12.99,87.37 12.99,85.72 14.39,84.32 14.39,83.29 15.2,81.88 13.95,80.84 13.21,80.84 13.21,81.1 13.28,81.28 13.45,81.35 13.95,81.35 14.71,82.1 13.95,82.86 3.15,82.86 2.97,82.93 2.9,83.1 2.9,86.56 2.98,86.73 3.15,86.8 8.04,86.8 9.93,86.8 10.67,87.42 10.18,88.26 10.18,90.17 10.41,90.17
GND on BOTTOM (solid shape): 111.8,175.05 112.33,174.93 112.75,174.6 113.36,173.88 113.96,173.41 114.7,173.25 130.83,173.25 131.25,173.3 131.64,173.45 133.19,174.25 133.47,174.36 133.77,174.4 198.63,174.4 198.93,174.36 199.21,174.25 200.76,173.45 201.15,173.3 201.57,173.25 219.2,173.25 219.94,173.41 220.54,173.88 221.15,174.6 221.57,174.93 222.1,175.05 230.16,175.05 230.16,174.54 222.1,174.54 221.79,174.47 221.53,174.27 220.93,173.55 220.16,172.95 219.2,172.74 201.57,172.74 201.03,172.8 200.52,173 198.97,173.8 198.81,173.87 198.63,173.89 133.77,173.89 133.59,173.87 133.43,173.8 131.88,173 131.37,172.8 130.83,172.74 114.7,172.74 113.74,172.95 112.97,173.55 112.36,174.27 112.11,174.47 111.8,174.54 108.43,174.54 108.43,172.58 106.72,172.58 106.72,174.54 106.02,174.54 106.02,175.05
GND on BOTTOM (solid shape): outline of 96 points within 0.25,99.44 86.89,175.05
GND on BOTTOM (solid shape): outline of 445 points within 106.68,32.24 109.37,54.02
GND on BOTTOM (solid shape): outline of 153 points within 1.95,0.25 315.8,176.95
GND on BOTTOM (solid shape): outline of 5297 points within 159.17,47.62 185.65,69.78
GND on BOTTOM (solid shape): outline of 5411 points within 160.06,7.17 186.73,30.73
GND on IN1 (solid shape): 68.55,26.66 68.55,23.11 68.3,22.85 66.2,22.85 66.01,23.04 66.01,26.47 66.27,26.72 68.49,26.72
GND on IN1 (solid shape): 154.66,80.83 154.66,76.06 154.09,75.49 152.44,75.49 152.31,75.62 152.31,76.06 152.18,76.19 150.47,76.19 150.02,76.64 150.02,81.59 150.79,82.35 153.14,82.35
GND on IN1 (solid shape): 10.42,90.13 10.53,89.95 10.69,89.82 10.69,89.67 12.22,88.14 13.21,88.14 14.39,86.96 14.39,83.29 15.2,81.88 13.95,80.84 13.21,80.84 13.21,81.1 13.28,81.28 13.45,81.35 13.95,81.35 14.71,82.1 13.95,82.86 3.15,82.86 2.97,82.95 2.91,83.13 2.91,86.56 2.98,86.73 3.15,86.8 8.04,86.8 9.93,86.8 10.67,87.42 10.18,88.26 10.18,90.17 10.41,90.17
GND on IN1 (solid shape): outline of 100 points within 0.25,99.44 86.89,175.05
GND on IN1 (solid shape): outline of 244 points within 0.75,0.25 315.8,176.95
GND on IN2 (solid shape): 68.55,26.66 68.55,23.11 68.3,22.85 66.2,22.85 66.01,23.04 66.01,26.47 66.27,26.72 68.49,26.72
GND on IN2 (solid shape): 154.53,79.94 154.53,76.38 153.64,75.49 152.44,75.49 152.31,75.62 152.31,76.06 152.18,76.19 150.47,76.19 150.02,76.64 150.02,80.32 150.15,80.45 154.02,80.45
GND on IN2 (solid shape): 10.42,90.13 10.53,89.95 10.69,89.82 10.69,88.56 11.01,88.2 11.18,87.75 12.61,87.75 12.99,87.37 12.99,85.72 14.39,84.32 14.39,83.29 15.2,81.88 13.95,80.84 13.21,80.84 13.21,81.1 13.28,81.28 13.45,81.35 13.95,81.35 14.71,82.1 13.95,82.86 3.14,82.86 2.97,82.93 2.9,83.11 2.9,86.56 2.98,86.73 3.15,86.8 8.04,86.8 9.47,86.8 10,86.8 10.68,87.46 10.18,88.26 10.18,90.17 10.41,90.17
GND on IN2 (solid shape): outline of 100 points within 0.25,99.44 86.89,175.05
GND on IN2 (solid shape): outline of 662 points within 49.25,39.26 79.82,52.05
GND on IN2 (solid shape): outline of 244 points within 0.75,0.25 315.8,176.95
GND on IN3 (solid shape): 68.55,26.66 68.55,23.11 68.3,22.85 66.2,22.85 66.01,23.04 66.01,26.47 66.27,26.72 68.49,26.72
GND on IN3 (solid shape): 153.78,80.12 153.78,77.51 154.66,76.64 154.66,76.45 153.71,75.49 152.44,75.49 152.31,75.62 152.31,76 152.12,76.19 150.34,76.19 150.02,76.51 150.02,80 150.41,80.38 153.52,80.38
GND on IN3 (solid shape): 10.42,90.13 10.53,89.95 10.69,89.82 10.69,88.56 11.01,88.2 11.18,87.75 12.61,87.75 12.99,87.37 12.99,85.72 14.39,84.32 14.39,83.29 15.2,81.88 13.95,80.84 13.21,80.84 13.21,81.1 13.28,81.28 13.45,81.35 13.95,81.35 14.71,82.1 13.95,82.86 3.15,82.86 2.98,82.93 2.9,83.11 2.9,86.56 2.98,86.73 3.15,86.8 8.04,86.8 9.93,86.8 10.67,87.42 10.18,88.26 10.18,90.17 10.41,90.17
GND on IN3 (solid shape): outline of 452 points within 48.51,39.39 80.75,51.9
GND on IN3 (solid shape): outline of 105 points within 0.25,99.44 86.89,175.05
GND on IN3 (solid shape): outline of 244 points within 0.75,0.25 315.8,176.95
GND on GND1: outline of 211 points within 0.25,0.25 315.8,176.95 ; 1 cut-out
GND on VCC: 6.9,1.02 4.79,1.89 3.92,4 3.92,8.75 3.58,9.71 2.72,10.24 2.72,37 2.5,37.77 1.93,38.33 1.52,39.02 1.93,39.71 2.5,40.27 2.72,41.04 2.72,64.77 3.58,65.3 3.92,66.25 3.92,68.09 13.96,68.09 15.47,69.6 13.97,71.12 13.97,80.59 15.47,82.11 13.96,83.62 3.45,83.62 3.45,86.03 9.93,86.03 11.35,87.01 10.95,88.68 10.95,100.92 11.35,102.59 9.93,103.57 1.02,103.57 1.02,104.74 1.16,105.08 1.5,105.22 20.8,105.22 20.8,71.13 22.2,69.74 22.2,51.45 28.82,44.82 62.35,44.82 63.22,43.95 63.22,32.02 69.82,25.41 69.82,17.03 70.97,15.89 70.97,10.92 16.8,10.92 15.02,10.18 14.28,8.4 14.28,1.5 14.14,1.16 13.8,1.02
GND on VCC: 64.49,89.53 64.49,96.87 62.97,98.39 62.97,101.21 73.63,101.21 73.63,89.53
GND on VCC: 160.99,7.99 155.29,13.69 155.15,13.83 131.27,13.83 118.72,26.39 118.72,40.4 121.38,43.07 121.38,56.4 123.97,58.98 126.76,58.98 127.46,59.68 128.35,59.68 132.29,63.62 135.33,63.62 139.02,67.3 148.14,67.3 149.02,68.19 155.02,68.19 157.05,70.22 177.62,70.22 178,70.6 183.13,70.6 183.49,70.24 183.49,7.99
GND on GND2: outline of 212 points within 0.25,0.25 315.8,176.95
GNDA on TOP (solid shape): 314.17,153.53 314.17,153.15 314.04,153.03 312.14,153.03 312.01,153.15 312.01,153.53 312.14,153.66 314.04,153.66
GNDA on TOP (solid shape): 301.92,152.07 301.92,151.06 301.73,150.87 300.58,150.87 300.46,150.99 300.46,151.31 301.03,151.31 301.03,151.82 300.46,151.82 300.46,152.14 300.58,152.26 301.73,152.26
GNDA on BOTTOM (solid shape): 264.96,151.82 264.96,150.99 264.71,150.74 262.67,150.74 262.67,152.14 264.64,152.14
GNDA on GND1: 242.92,143.85 242.92,147.08 245.57,149.72 250.65,149.72 251.28,150.36 252.32,150.36 252.32,149.75 252.47,149.6 258.61,149.6 258.61,152.58 259.77,152.58 260.16,152.2 267.97,152.2 269.79,150.38 269.79,147.84 270.38,147.25 297.32,147.25 300.33,150.25 300.33,153.68 304.31,157.66 307.84,157.66 308.08,157.43 308.08,154.57 308.73,153.92 315.03,153.92 315.03,153.91 315.8,153.91 315.8,146.8 315.58,146.27 315.05,146.05 313.55,146.05 312.66,145.69 312.3,144.8 312.3,144.6 312.08,144.07 311.55,143.85
GNDA on VCC: 242.92,144.62 242.92,147.08 245.57,149.72 250.65,149.72 251.28,150.36 252.32,150.36 252.32,149.75 252.47,149.6 258.61,149.6 258.61,152.58 259.77,152.58 260.16,152.2 267.97,152.2 269.79,150.38 269.79,147.84 270.38,147.25 297.32,147.25 300.33,150.25 300.33,153.68 304.31,157.66 307.84,157.66 308.08,157.43 308.08,154.57 308.73,153.92 315.03,153.92 315.03,146.82 313.55,146.82 312.12,146.23 311.53,144.8 311.53,144.62
GNDA on GND2: 242.92,143.85 242.92,147.08 245.57,149.72 250.65,149.72 251.28,150.36 252.32,150.36 252.32,149.75 252.47,149.6 258.61,149.6 258.61,152.58 259.77,152.58 260.16,152.2 267.97,152.2 269.79,150.38 269.79,147.84 270.38,147.25 297.32,147.25 300.33,150.25 300.33,153.68 304.31,157.66 307.84,157.66 308.08,157.43 308.08,154.57 308.73,153.92 315.79,153.92 315.79,146.8 315.58,146.27 315.05,146.06 313.55,146.06 312.66,145.69 312.29,144.8 312.29,144.6 312.08,144.07 311.55,143.85
GNDA_CHG on TOP (solid shape): 114.15,151.12 114.15,150.23 113.58,150.23 113.58,149.72 114.15,149.72 114.15,149.03 113.83,148.71 112.11,148.71 112.09,148.74 112.09,150.64 111.8,150.93 110.21,150.93 109.89,150.61 109.89,148.77 109.38,148.77 109.38,149.6 109,149.98 107.1,149.98 107.1,151.18 107.35,151.44 113.83,151.44
GNDA_CHG on IN1 (solid shape): outline of 366 points within 106.53,139.82 116.43,150.93
VDDA18CR on TOP (solid shape): 172.69,127.5 172.69,125.15 172.44,124.9 172.44,123.75 172.38,123.69 172.25,123.69 172.19,123.75 172.19,125.4 171.93,125.66 171.93,127.5 172.06,127.63 172.57,127.63
VDDA18PLL on TOP (solid shape): 173.46,119.05 173.46,117.91 173.58,117.78 173.58,116.71 174.15,116.15 174.18,116.12 174.21,116.09 174.67,115.62 174.68,115.62 175,115.31 175.87,115.31 175.87,114.8 174.47,114.8 173.96,115.31 173.96,115.5 173.14,116.32 173.14,117.85 173.2,117.91 173.2,119.05 173.27,119.12 173.39,119.12
+AUX_LDO on BOTTOM (solid shape): 10.07,25.84 10.07,25.07 10.01,25.01 8.55,25.01 6.83,23.3 5.88,23.3 5.75,23.42 5.75,25.14 6.39,25.14 6.39,24.76 6.58,24.57 7.28,24.57 7.4,24.69 7.66,24.69 8.42,25.45 9.44,25.45 9.88,25.9 10.01,25.9
+BATT_SUM on TOP (solid shape): 133.04,162.27 133.04,158.82 132.69,158.46 131.62,158.46 131.16,158 131.16,154.42 129.38,152.64 129.38,150.61 128.5,149.72 126.08,149.72 125.83,149.98 125.83,151.45 124.16,153.12 123.2,153.12 122.4,153.91 122.4,157.09 124.18,158.87 124.18,162.2 124.66,162.68 132.64,162.68
+BL_PWR_SRC on TOP (solid shape): 95.1,137.09 95.1,136.77 95.29,136.58 96.43,136.58 96.56,136.45 96.56,135.37 96.49,135.31 95.29,135.31 95.03,135.06 95.03,134.8 94.84,134.61 93.89,134.61 93.7,134.8 93.7,137.09 93.89,137.28 94.91,137.28
+BL_PWR_SRC on BOTTOM (solid shape): 87.79,159.38 87.79,155.84 87.63,155.68 84.69,155.68 84.56,155.82 84.56,159.31 84.81,159.57 87.6,159.57
+BL_PWR_SRC on IN2 (solid shape): 88.19,157.59 88.19,155.78 88.1,155.69 84.66,155.69 84.49,155.85 84.49,157.13 84.5,157.14 84.5,157.54 84.73,157.77 88.01,157.77
+BL_PWR_SRC on IN2 (solid shape): 95.48,138.74 95.48,134.8 95.29,134.61 93.51,134.61 93.38,134.74 93.38,139.37 93.45,139.44 94.78,139.44
+DC1_PWR_SRC on TOP (solid shape): 202.6,145.15 202.6,139.31 202.39,139.1 200.36,139.1 200.32,139.14 200.32,139.82 200.19,139.94 198.47,139.94 198.35,140.07 198.35,140.83 197.96,141.21 194.86,141.21 194.41,140.77 194.41,140.39 193.52,140.39 193.52,141.15 194.28,141.15 194.66,141.53 194.66,144.45 194.73,144.52 200.12,144.52 200.19,144.52 200.32,144.64 200.32,145.22 202.54,145.22
+DC1_PWR_SRC on BOTTOM (solid shape): outline of 239 points within 195.24,141.15 202.09,152.07
+DC_IN on TOP (solid shape): 96.43,157.08 96.43,153.34 96.11,153.03 92.24,153.03 91.92,153.34 91.92,155.69 90.78,156.84 90.78,159.44 91.02,159.68 93.83,159.68
+DC_IN on BOTTOM (solid shape): 94.97,159.3 94.97,157.47 94.59,157.09 91.48,157.09 91.29,157.28 91.29,159.43 91.41,159.55 94.72,159.55
+DC_IN_SS on TOP (solid shape): 95.86,150.8 98.91,150.8 99.1,150.61 99.1,149.34 99.41,149.03 100.81,149.03 100.94,148.9 100.94,148.33 100.81,148.2 100.18,148.2 98.65,146.68 90.9,146.68 90.4,147.18 90.4,151.38 90.71,151.69 94.97,151.69
+DCIN on TOP (solid shape): 109.65,144.49 109.65,144.31 109.32,143.98 108.99,143.98 108.73,143.72 108.73,143.01 107.1,141.38 105.7,141.38 105.67,141.41 105.67,142.28 105.81,142.42 105.81,144.35 106.02,144.55 109.58,144.55
+DCIN_JACK on TOP (solid shape): 87.86,160.01 88.51,160.01 89.46,160.96 90,160.96 90.21,160.76 90.21,156.46 90.02,156.26 86.33,156.26 85.57,157.03 85.57,157.98 83.35,160.46 83.35,160.84 85.06,162.55 85.51,162.55
+DOCK_PWR_BAR on TOP (solid shape): outline of 107 points within 133.22,154.26 146.85,170.62
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 139 points within 132.88,163.63 146.85,172.08
+DOCK_PWR_BAR on VCC: 142.73,163.06 141.02,164.76 138.97,164.76 138.78,164.94 138.78,173.63 192.25,173.63 192.25,164.69 190.62,163.06
+FB_PLLAVDD on TOP (solid shape): 74.52,88.76 75.6,88.76 75.73,88.64 75.73,86.86 75.6,86.73 73.44,86.73 73.06,87.11 73.06,89.34 73.25,89.53 73.76,89.53
+FB_PLLAVDD on IN3 (solid shape): outline of 1540 points within 55.16,84.38 74.86,92.83
+GPU_CORE on TOP (solid shape): 64.17,69.66 64.17,69.14 64.43,68.89 64.43,68 64.24,67.81 49.83,67.81 49.61,68.04 49.61,69.87 49.78,70.04 63.79,70.04
+GPU_CORE on TOP (solid shape): outline of 820 points within 57,79.94 67.66,89.14
+GPU_CORE on BOTTOM (solid shape): 65.19,69.84 65.19,65.84 64.81,65.46 62.58,65.46 61.89,64.76 61.38,64.76 61.38,65.33 59.35,65.33 59.35,64.76 56.17,64.76 56.17,65.33 54.14,65.33 54.14,64.76 50.96,64.76 50.96,65.33 48.93,65.33 48.93,64.76 48.42,64.76 48.3,64.89 48.3,68.32 49.44,69.46 49.44,69.97 49.63,70.16 64.87,70.16
+GPU_CORE on BOTTOM (solid shape): outline of 1667 points within 57.47,79.83 67.41,89.02
+GPU_CORE on IN1 (solid shape): 64.55,69.76 64.55,68.32 64.36,68.13 49.8,68.13 49.61,68.32 49.61,69.92 49.83,70.15 64.17,70.15
+GPU_CORE on IN2 (solid shape): outline of 2107 points within 49.73,68.32 67.79,89.02
+GPU_CORE on IN3 (solid shape): outline of 3611 points within 49.85,68.44 73.95,89.02
+GPU_CORE on VCC: 48.36,63.62 48.36,71.39 49.23,72.25 55.96,72.25 57.5,73.8 57.5,88.66 57.86,89.02 73.63,89.02 73.63,88.02 73.63,74.01 73.63,72.4 73.63,71.39 73.63,66.9 73.63,66.52 70.73,63.62
+LCDVDD on TOP (solid shape): 94.33,101.34 94.97,101.34 95.16,101.15 95.16,99.31 94.97,99.11 93.45,99.11 92.75,99.81 92.75,101.63 92.93,101.81 93.86,101.81
+LCDVDD on TOP (solid shape): 96.54,121.48 96.54,120.18 96.37,120.01 94.21,120.01 93.95,120.26 93.95,121.28 94.08,121.4 95.13,121.4 95.29,121.56 96.47,121.56
+LCDVDD on IN3 (solid shape): 95.22,121.4 95.22,119.88 94.91,119.56 92.81,119.56 92.81,121.59 95.03,121.59
+LCDVDD on IN3 (solid shape): 94.02,101.21 94.02,100.38 93.76,100.13 92.24,100.13 91.16,101.21 91.16,102.48 91.48,102.8 92.43,102.8
+LOM_VCT on TOP (solid shape): 178.73,171.76 178.73,170.87 178.66,170.81 178.66,170.48 178.22,170.03 177.96,170.03 177.8,170.2 177.8,170.45 177.96,170.62 177.96,171.82 178.03,171.89 178.6,171.89
+LOM_VCT on BOTTOM (solid shape): 178.62,172.83 178.62,170.92 178.67,170.87 178.67,170.23 178.66,170.17 178.65,170.1 178.51,169.95 177.96,169.95 177.74,170.17 177.74,170.2 177.75,170.32 177.73,170.51 177.74,170.52 177.81,170.71 177.76,170.9 177.74,170.93 177.79,170.98 177.79,172.89 177.86,172.95 178.49,172.95
+PBATT on TOP (solid shape): 140.94,151.76 140.94,148.83 140.69,148.58 137.89,148.58 137.77,148.71 137.77,152.01 138.02,152.26 140.44,152.26
+PBATT on TOP (solid shape): 117.7,171.89 117.7,167.69 117.07,167.06 112.37,167.06 112.18,167.25 112.18,171.82 112.56,172.2 117.39,172.2
+PBATT on IN3 (solid shape): outline of 644 points within 111.23,148.01 139.42,171.31
+PBATT_IN_SS on TOP (solid shape): 133.3,157.73 133.3,154.26 133.77,153.79 136.62,153.79 137.13,153.28 137.13,149.22 136.24,148.33 136.24,145.28 136.12,145.15 134.85,145.15 134.34,145.66 134.34,147.35 134.13,147.55 130.76,147.55 129.89,148.42 129.89,152.39 131.67,154.17 131.67,157.67 131.8,157.8 133.22,157.8
+PCH_ASATA3PLL on BOTTOM (solid shape): 96.56,63.17 99.67,63.17 99.92,63.43 101.45,63.43 101.64,63.24 101.64,62.79 100.35,62.79 99.65,62.09 97.04,62.09 96.75,62.25 96.46,62.09 95.16,62.09 95.1,62.16 95.1,63.94 95.8,63.94
+PCH_DCPSUS1 on TOP (solid shape): outline of 152 points within 118.44,62.58 120.24,66
+PCH_DCPSUS4 on IN2 (solid shape): outline of 340 points within 107.72,61.41 112.88,62.97
+PCH_VCC1P05 on TOP (solid shape): outline of 479 points within 96.49,56.25 112.37,59.81
+PCH_VCCACLKPLL on TOP (solid shape): 99.8,56.87 99.8,56.13 99.99,55.93 102.34,55.93 102.62,56.21 102.62,56.48 102.69,56.56 103.07,56.56 103.22,56.4 103.22,55.11 102.65,54.54 100.11,54.54 99.72,54.93 96.03,54.93 95.87,55.09 95.87,56.81 96.01,56.95 99.72,56.95
+PNVVDD on BOTTOM (solid shape): 73,64.57 73,61.01 74.14,59.87 74.14,56.13 73.7,55.68 68.3,55.68 67.22,56.76 67.22,59.05 66.84,59.43 63.98,59.43 62.84,58.28 61.76,58.28 61.38,57.9 61.38,57.2 61.06,56.89 54.46,56.89 53.69,57.65 53.69,59.68 53.31,60.06 47.48,60.06 47.02,60.32 46.52,60.52 46.52,64.32 46.77,64.57 61.95,64.57 62.46,65.08 72.49,65.08
+PWR_SRC on TOP (solid shape): 191.74,84.64 191.74,82.41 191.3,81.97 185.88,81.97 185.66,82.19 185.66,84.68 185.8,84.83 191.55,84.83
+PWR_SRC on TOP (solid shape): 119.96,168.22 119.96,166.77 120.37,166.36 120.37,163.25 120.05,162.93 118.33,162.93 118.17,162.78 118.17,161.38 118.13,161.34 117.32,161.34 117.32,163.12 116.56,163.12 116.56,161.34 114.85,161.34 114.53,161.66 114.53,166.23 114.78,166.49 117.02,166.49 118.83,168.3 119.89,168.3
+PWR_SRC on TOP (solid shape): outline of 1810 points within 41.44,21.31 82.01,59.74
+PWR_SRC on BOTTOM (solid shape): 163.59,78.78 163.59,77.18 163.31,76.9 162.3,76.9 162.3,78.96 162.34,79 163.36,79
+PWR_SRC on BOTTOM (solid shape): 63.6,31.42 63.6,28.18 63.22,27.8 59.66,27.8 59.41,28.06 59.41,31.36 59.79,31.74 63.28,31.74
+PWR_SRC on BOTTOM (solid shape): 46.14,26.79 46.14,25.39 46.01,25.26 43.47,25.26 43.28,25.45 43.28,26.72 43.47,26.92 46.01,26.92
+PWR_SRC on BOTTOM (solid shape): 70.01,38.24 70.01,34.31 69.86,34.15 64.43,34.15 64.05,34.54 64.05,38.28 64.36,38.6 69.66,38.6
+PWR_SRC on BOTTOM (solid shape): outline of 166 points within 189.33,82.6 194.06,101.72
+PWR_SRC on BOTTOM (solid shape): outline of 14577 points within 75.09,57.2 202.09,165.79
+PWR_SRC on IN3 (solid shape): 191.49,84.45 191.49,82.93 191.02,82.46 188.84,82.46 187.68,83.62 187.68,84.76 188.06,84.76 188.12,84.83 191.11,84.83
+PWR_SRC on IN3 (solid shape): 172.41,80.18 172.41,78.83 170.33,76.75 163,76.75 162.63,77.12 162.63,78.17 162.77,78.31 169.61,78.31 171.78,80.47 172.12,80.47
+PWR_SRC_AC on TOP (solid shape): 142.72,161.66 142.72,160.65 143.23,160.14 143.23,159.76 143.1,159.63 141.32,159.63 141.07,159.38 141.07,154.68 140.81,154.42 136.25,154.42 136.24,154.42 136.24,157.98 136.63,158.36 136.63,162.04 136.88,162.3 142.09,162.3
+PWR_SRC_AC on TOP (solid shape): 97.37,161.83 97.37,160.61 98.09,159.88 101,159.88 101.19,159.69 101.19,159.68 101.42,159.45 101.42,156.62 101,156.2 98.97,156.2 98.97,157.98 98.21,157.98 98.21,156.2 97.07,156.2 96.87,156.39 96.87,157.12 94.04,159.96 92.2,159.96 91.82,160.34 91.82,163.02 91.99,163.19 96.01,163.19
+PWR_SRC_AC on BOTTOM (solid shape): 101.45,158.42 101.45,156.58 101.07,156.2 97,156.2 96.56,156.65 96.56,159.31 97.07,159.82 100.05,159.82
+PWR_SRC_AC on IN2 (solid shape): outline of 1478 points within 95.22,156.01 139.61,167.76
+RTC_CELL on TOP (solid shape): 140.75,95.37 140.75,94.61 139.93,93.78 139.93,92.89 139.74,92.7 139.04,92.7 138.98,92.76 138.98,92.89 138.66,93.21 138.09,93.21 136.94,94.35 136.94,94.99 137.45,94.99 137.45,94.61 137.77,94.29 138.02,94.29 138.59,93.72 138.98,93.72 139.99,94.73 139.99,95.37 140.05,95.43 140.69,95.43
+RTC_CELL on IN2 (solid shape): outline of 304 points within 107.61,59.56 112.69,61.05
+SD_IO_LDO on BOTTOM (solid shape): 9.33,34.22 9.33,33.61 9.33,33.61 9.33,32.67 10.07,31.93 10.07,31.17 10.02,31.12 9.92,31.12 9.19,31.85 9.19,31.96 8.42,32.73 8.42,33.28 8.24,33.46 8.24,34.18 8.4,34.34 9.2,34.34
+SDC_IN on TOP (solid shape): 98.21,153.47 98.27,153.41 98.91,153.41 98.97,153.47 98.97,155.19 100.62,155.19 100.94,154.87 100.94,151.44 100.88,151.38 97.32,151.38 97.19,151.5 97.19,152.45 96.75,152.9 96.75,154.99 96.94,155.19 98.21,155.19
+SWR_LX on TOP (solid shape): 109.12,112.16 108.97,112.01 106.72,112.01 106.65,112.07 105.7,112.07 105.64,112.13 105.64,112.2 105.7,112.26 106.65,112.26 106.72,112.32 107.03,112.32 107.25,112.54 107.58,112.54 108.19,113.15 109.12,113.15
+SWR_V12 on TOP (solid shape): 105.07,110.27 105.07,109.08 106.34,107.81 106.72,107.81 106.97,107.56 106.97,107.31 106.84,107.18 105.89,107.18 105.76,107.31 105.76,107.88 104.85,108.79 104.85,110.25 104.9,110.3 105.03,110.3
+SWR_V12 on TOP (solid shape): 111.61,112.89 111.61,111.88 109.77,110.04 107.23,110.04 107.06,110.2 107.06,110.81 106.63,111.24 105.7,111.24 105.64,111.31 105.64,111.43 105.7,111.5 106.63,111.5 106.65,111.52 107.52,111.52 107.99,111.05 108.94,111.05 109.07,111.18 109.07,111.88 109.26,112.07 109.26,113.08 109.38,113.21 111.29,113.21
+SWR_V12 on IN2 (solid shape): outline of 337 points within 95.8,107.21 108.43,114.04
+VCHGR on TOP (solid shape): 123.44,162.3 123.44,159.02 121.76,157.34 121.76,155.06 121,154.3 118.34,154.3 118.08,154.04 118.08,153.41 117.83,153.15 116.68,153.15 116.56,153.28 116.56,156.2 116.05,156.71 116.05,157.73 115.54,158.23 115.54,160.07 115.8,160.33 116.56,160.33 116.56,158.49 117.32,158.49 117.32,158.49 117.32,160.33 117.64,160.65 118.21,160.65 118.41,160.85 118.41,162.3 118.54,162.42 121.32,162.42 123.32,162.42
+VHDMI_VCC on TOP (solid shape): 15.02,97.59 14.71,97.27 13.82,97.27 12.67,98.42 12.22,98.42 12.04,98.59 12.04,99.89 13.01,100.85 14.03,100.85 14.32,101.15 15.02,101.15
+VLDOIN_1.35V on TOP (solid shape): 179.17,84.07 179.17,83.49 178.6,83.49 178.6,82.99 179.17,82.99 179.17,82.67 178.98,82.48 178.26,82.48 178.04,82.26 176.22,82.26 176.15,82.33 176.15,82.42 176.22,82.5 177.29,82.5 177.84,83.05 177.84,84 178.03,84.19 179.04,84.19
+VREFC_UV5 on TOP (solid shape): 34.01,99.81 34.01,97.46 33.88,97.34 33.31,97.34 33.18,97.46 33.18,99.75 33.31,99.88 33.94,99.88
+VREFD_UV5 on TOP (solid shape): 35.79,99.81 35.79,97.21 35.34,96.76 35.34,96.51 35.36,96.49 35.36,96.47 35.46,96.27 35.66,96.17 35.68,96.17 36.42,95.43 36.42,94.99 36.27,94.84 36.21,94.79 36.16,94.74 35.9,94.74 35.84,94.8 35.76,94.83 35.75,94.84 35.28,95.3 35.02,95.3 34.45,95.88 34.45,96.83 34.9,97.27 34.9,99.75 35.02,99.88 35.72,99.88
+VREFD_UV7 on TOP (solid shape): outline of 180 points within 32.85,79.05 36.23,83.75
-DCIN_JACK on TOP (solid shape): 90.97,164.33 90.97,162.81 88.81,160.84 88.43,160.84 85.51,164.01 85.51,164.9 86.65,166.04 86.84,166.04 87.35,166.55 88.75,166.55
-DCIN_JACK on BOTTOM (solid shape): outline of 87 points within 82.52,162.81 89.13,169.6
BST_3V on TOP (solid shape): 190.98,141.94 190.98,141.01 191.34,140.66 191.34,139.82 191.44,139.72 191.89,139.72 192,139.61 192,138.85 191.95,138.8 190.9,138.8 190.8,138.9 190.8,140.78 190.77,140.82 190.77,141.94 190.8,141.98 190.94,141.98
BST_5V on TOP (solid shape): 192.06,146.43 191.01,145.38 191.01,144.21 190.91,144.12 190.8,144.12 190.75,144.16 190.75,145.8 190.86,145.91 190.86,145.91 191.17,146.22 191.17,147.12 192.06,147.12
BST_+VDDRP on BOTTOM (solid shape): 38.24,30.1 38.24,29.39 37.67,28.82 37.67,28.06 37.54,27.93 36.69,27.93 36.64,27.98 36.64,28.82 37.32,29.49 37.32,30.1 37.4,30.18 38.16,30.18
CHAGER_SRC on TOP (solid shape): 97.03,166.17 100.43,166.17 101.07,166.81 105.89,166.81 106.08,166.62 106.08,162.55 105.57,162.04 97.54,162.04 96.2,163.38 92.05,163.38 91.87,163.55 91.87,166.84 92.23,167.2 96,167.2
CHAGER_SRC on BOTTOM (solid shape): 100.37,165.66 100.37,161.98 95.74,161.98 95.33,162.4 95.33,165.82 95.55,166.04 99.99,166.04
CHG_LGATE on TOP (solid shape): 110.4,156.07 110.4,153.98 110.15,153.72 109.64,153.72 109.38,153.98 109.38,154.93 109.57,155.12 109.57,156.14 109.7,156.26 110.21,156.26
CHG_LGATE on TOP (solid shape): 109.96,147.57 109.96,146.68 109.89,146.61 109.77,146.61 109.51,146.87 108.94,146.87 108.75,147.06 108.75,147.69 109,147.95 109.57,147.95
CHG_LGATE on IN3 (solid shape): 109.57,147.06 109.38,146.87 108.75,146.87 108.56,147.06 108.56,148.71 109.57,148.71
CHG_LGATE on IN3 (solid shape): 110.08,154.74 110.08,153.72 109.57,153.22 109.57,152.84 108.56,152.84 108.56,154.17 109.26,154.87 109.96,154.87
CHG_UGATE on TOP (solid shape): 109.45,166.93 109.45,165.92 109.32,165.79 108.5,165.79 108.11,166.17 107.1,166.17 106.91,166.36 106.91,166.81 107.16,167.06 109.32,167.06
CHG_UGATE on TOP (solid shape): 108.56,145.53 109.57,145.53 109.64,145.47 109.64,145.34 109.57,145.28 108.62,145.28 108.5,145.15 107.67,145.15 107.35,145.47 107.35,145.91 107.48,146.04 108.05,146.04
CHG_UGATE on IN3 (solid shape): 110.78,165.66 110.78,165.15 109.77,165.15 109.38,165.54 108.43,165.54 108.24,165.73 108.24,166.3 108.37,166.42 110.02,166.42
CHG_UGATE on IN3 (solid shape): 107.92,146.3 108.43,145.79 108.43,145.28 108.3,145.15 107.54,145.15 106.91,145.79 106.91,147.18 107.92,147.18
DH_1.35V on TOP (solid shape): 178.05,81.53 178.05,80.43 177.95,80.33 177.47,80.33 177.34,80.46 177.34,81.26 177.12,81.48 176.2,81.48 176.15,81.53 176.15,81.64 176.21,81.7 177.88,81.7
DH_1.35V on BOTTOM (solid shape): 188.44,82.73 188.44,80.26 188.25,80.06 186.66,80.06 186.54,80.19 186.54,82.92 186.66,83.05 188.12,83.05
DH_1.35V on BOTTOM (solid shape): 178.41,82.03 177.96,81.59 177.96,80.57 177.77,80.38 177.14,80.38 176.95,80.57 176.95,82.03 177.52,82.6 178.41,82.6
DL_1.35V on TOP (solid shape): 176.32,80.69 176.32,78.68 176.2,78.55 175.92,78.55 175.82,78.65 175.82,79.95 175.87,80 175.87,80.95 175.92,81 176.01,81
DL_1.35V on BOTTOM (solid shape): 180.92,80.91 180.92,80.2 180.64,79.92 179.16,79.92 177.77,78.54 176,78.54 175.87,78.67 175.87,79.68 176,79.81 177.58,79.81 178.78,81 180.82,81
GPU_B+ on BOTTOM (solid shape): 82.59,56.7 82.59,48.7 78.21,48.7 77.95,48.95 77.95,57.01 78,57.06 82.22,57.06
GPU_B+ on BOTTOM (solid shape): 67.47,42.03 67.79,41.71 67.79,41.14 68.3,40.63 68.3,38.98 68.11,38.79 67.09,38.79 67.09,39.36 65.06,39.36 65.06,38.79 63.6,38.79 63.28,39.11 63.28,50.47 62.97,50.79 62.97,55.05 63.28,55.36 67.47,55.36
GPU_B+ on IN3 (solid shape): 80.75,55.93 80.75,51.36 79.67,50.28 67.86,50.28 66.52,48.95 64.93,48.95 64.74,49.14 64.74,51.68 65.89,52.82 76.75,52.82 77.95,54.03 77.95,55.55 78.52,56.13 80.56,56.13
GPU_PVCC on BOTTOM (solid shape): 57.14,40.5 57.14,39.63 56.93,39.42 55.41,39.42 55.28,39.55 55.28,40.38 55.49,40.58 57.06,40.58
INT_SPK_L+ on TOP (solid shape): 205.27,122.42 205.27,122.1 205.14,121.97 203.3,121.97 203.05,121.72 203.05,121.4 202.41,121.4 202.41,122.29 202.67,122.55 205.14,122.55
INT_SPK_L+ on IN3 (solid shape): 206.35,122.17 206.09,121.91 204.32,121.91 204.19,122.04 204.19,122.48 204.32,122.61 206.35,122.61
INT_SPK_L+ on IN3 (solid shape): 250.09,151.65 250.09,151.25 249.96,151.12 248.34,151.12 248.31,151.15 248.31,151.76 249.99,151.76
INT_SPK_L- on TOP (solid shape): 203.05,123.94 203.49,123.5 205.14,123.5 205.27,123.37 205.27,123.05 205.14,122.93 202.79,122.93 202.41,123.31 202.41,124.2 203.05,124.2
INT_SPK_L- on BOTTOM (solid shape): 250.67,152.09 250.67,151.83 250.37,151.83 250.29,151.91 248.3,151.91 248.26,151.95 248.26,152.45 248.3,152.49 250.27,152.49
INT_SPK_L- on IN3 (solid shape): 250.09,152.42 250.09,152.01 249.96,151.88 248.34,151.88 248.31,151.91 248.31,152.52 249.99,152.52
INT_SPK_L- on IN3 (solid shape): 206.16,123.05 205.9,122.8 204.32,122.8 204.19,122.93 204.19,123.37 204.32,123.5 206.16,123.5
INT_SPK_R+ on TOP (solid shape): 205.36,126.23 205.36,125.85 205.23,125.72 203.3,125.72 203.05,125.47 203.05,125.16 202.41,125.16 202.41,126.15 202.62,126.36 205.23,126.36
INT_SPK_R+ on BOTTOM (solid shape): 250.24,153.46 250.24,153.23 249.17,153.23 248.74,153.66 248.74,153.89 248.87,154.02 249.68,154.02
INT_SPK_R+ on IN3 (solid shape): 206.03,125.85 205.97,125.78 204.38,125.78 204.25,125.91 204.25,126.29 204.38,126.42 206.03,126.42
INT_SPK_R+ on IN3 (solid shape): 249.81,153.89 249.81,153.18 249.35,152.72 248.69,152.72 248.69,153.33 248.74,153.38 248.74,153.89 248.89,154.04 249.66,154.04
INT_SPK_R- on TOP (solid shape): 203.05,127.65 203.4,127.3 205.23,127.3 205.36,127.17 205.36,126.84 205.18,126.66 202.79,126.66 202.41,127.04 202.41,127.91 202.44,127.93 203.05,127.93
INT_SPK_R- on BOTTOM (solid shape): 248.44,153.86 248.44,153.74 249.1,153.08 249.4,153.08 249.43,153.05 249.43,152.82 248.03,152.82 247.32,153.53 247.32,153.86 247.47,154.02 248.28,154.02
INT_SPK_R- on IN3 (solid shape): 205.97,126.67 204.38,126.67 204.25,126.8 204.25,127.18 204.38,127.31 205.97,127.31
INT_SPK_R- on IN3 (solid shape): 248.44,153.94 248.44,153.61 248.31,153.48 246.66,153.48 246.66,154.09 248.28,154.09
INT_SPKR_L+ on TOP (solid shape): 197.01,122.23 197.65,122.23 197.65,121.28 197.59,121.21 196.25,121.21 195.62,121.85 195.62,122.48 195.74,122.61 196.63,122.61
INT_SPKR_L+ on BOTTOM (solid shape): 197.46,121.76 197.32,121.62 196.16,121.62 195.62,122.17 195.62,122.55 195.74,122.67 196.89,122.67 197.01,122.8 197.46,122.8
INT_SPKR_L- on TOP (solid shape): 197.52,123.12 196.89,123.12 196.63,122.86 195.74,122.86 195.62,122.99 195.62,123.75 196,124.13 197.52,124.13
INT_SPKR_L- on BOTTOM (solid shape): 197.46,123.75 197.46,123.44 196.82,122.8 195.74,122.8 195.62,122.93 195.62,123.31 195.74,123.44 196.15,123.44 196.6,123.88 197.33,123.88
INT_SPKR_R+ on TOP (solid shape): 197.01,126.23 197.65,126.23 197.65,125.28 197.59,125.21 196.25,125.21 195.62,125.85 195.62,126.48 195.74,126.61 196.63,126.61
INT_SPKR_R+ on BOTTOM (solid shape): 197.2,125.98 197.2,125.66 197.1,125.55 196.97,125.55 196.84,125.42 196.37,125.42 195.62,126.17 195.62,126.55 195.74,126.67 196.51,126.67
INT_SPKR_R- on TOP (solid shape): 197.52,127.12 196.89,127.12 196.63,126.86 195.74,126.86 195.62,126.99 195.62,127.75 196,128.13 197.52,128.13
INT_SPKR_R- on BOTTOM (solid shape): 197.83,126.94 197.83,126.28 197.65,126.1 197.27,126.1 196.57,126.8 195.74,126.8 195.62,126.93 195.62,127.51 195.81,127.7 197.07,127.7
LG_3V on TOP (solid shape): 197.9,136.01 198.36,136.01 198.43,135.94 201.27,135.94 201.33,135.88 201.33,135.5 201.14,135.31 197.97,135.31 197.84,135.18 197.33,135.18 197.33,136.14 197.4,136.2 197.71,136.2
LG_3V on TOP (solid shape): 192.7,142.1 192.7,141.47 193.27,140.9 193.27,139.88 192.25,139.88 192.25,140.96 192,141.22 192,141.8 191.65,142.15 191.58,142.15 191.53,142.2 191.53,142.31 191.58,142.36 192.44,142.36
LG_5V on TOP (solid shape): 201.39,146.8 201.39,146.1 201.2,145.91 199.57,145.91 199.52,145.96 199.52,146.89 199.55,146.93 201.27,146.93
LG_5V on TOP (solid shape): 193.13,144.46 193.13,144.13 192.75,143.75 191.6,143.75 191.57,143.78 191.57,143.95 191.58,143.96 191.68,143.96 192.06,144.34 192.06,144.48 192.17,144.59 193,144.59
LG_5V on IN1 (solid shape): 200.51,146.74 200.51,145.85 199.74,145.09 199.24,145.09 199.11,145.22 199.11,146.36 199.68,146.93 200.32,146.93
LG_5V on IN1 (solid shape): 194.35,144.58 193.9,144.58 193.39,144.07 192.07,144.07 192,144.15 192,144.39 193.2,145.6 194.35,145.6
LG_+VDDRP on BOTTOM (solid shape): 39.79,34.92 39.79,34.09 39.6,33.9 39.6,33.65 39.22,33.27 39.22,32.31 38.84,31.93 37.44,31.93 37.38,32 37.38,32.25 37.5,32.38 38.39,32.38 38.58,32.57 38.58,34.79 38.84,35.04 39.66,35.04
LX_DGPU on BOTTOM (solid shape): 78.4,28.31 78.4,22.6 76.49,20.69 70.21,20.69 68.55,22.35 68.55,25.39 69.37,25.39 69.49,25.33 69.63,25.33 69.77,25.33 69.9,25.39 69.95,25.39 70.46,25.9 70.46,26.53 70.71,26.79 70.71,27.93 72.08,29.3 74.6,29.3 74.64,29.26 74.64,26.76 75.41,26.76 75.41,29.25 75.48,29.32 77.39,29.32
PBATT+_C on TOP (solid shape): 106.08,173.47 106.08,171.31 106.72,170.68 108.94,170.68 109.26,171 109.26,171.63 109.51,171.89 111.67,171.89 111.99,171.57 111.99,167.82 111.8,167.63 102.15,167.63 101.7,168.08 101.7,173.41 102.02,173.73 105.83,173.73
PBATT+_C on BOTTOM (solid shape): 106.08,173.47 106.08,171.31 106.72,170.68 109.26,170.68 109.51,170.43 109.51,166.87 109.26,166.62 102.08,166.62 101.7,167 101.7,173.41 102.02,173.73 105.83,173.73
RING2 on BOTTOM (solid shape): 305.57,156.01 307.38,156.01 307.44,155.95 307.44,155.34 307.39,155.29 305.64,155.29 305.28,154.93 304.75,154.93 304.62,155.06 304.62,156.07 304.75,156.2 305.38,156.2
RING2 on IN3 (solid shape): 305.54,156.01 305.54,155.12 305.35,154.93 304.9,154.93 304.65,154.68 303.63,154.68 303.63,155.38 304.39,156.14 305.41,156.14
RING2 on IN3 (solid shape): 257.97,148.77 257.72,148.77 257.59,148.64 257.59,147.6 257.4,147.41 256.72,147.41 256.64,147.49 256.64,148.64 256.59,148.7 256.59,149.42 256.96,149.79 257.97,149.79
RING2 on TOP: 305.97,157.51 306.64,157.51 306.93,157.21 306.93,155.61 306.53,155.21 305.75,155.21 305.51,154.97 304.98,154.97 304.84,155.11 304.84,155.96 305.17,156.29 305.42,156.29 305.66,156.53 305.66,157.2
SLEEVE on IN3 (solid shape): 306.81,157.22 306.81,155.82 305.79,155.82 305.79,156.33 305.6,156.52 305.15,156.52 305.03,156.65 305.03,157.47 305.15,157.6 306.42,157.6
