# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS2_CLK_TS: length 76.7
  TOP w0.102: JKB1.9 181.51,110.67 181.89,111.06 181.89,111.3 v2(181.71,111.47) ; v2(150.66,94.17) 150.68,94.19 JTP1.2 ; v2(164.45,76.37) 164.3,76.52 164.3,76.52 164.3,76.62 165,77.32 165,78.86 163.67,80.19 162.44,80.19 162.03,80.6 162.03,82.17 161.08,83.11 157.73,83.11 155.64,85.21 153.43,85.21 153.07,85.56 153.07,85.98 v2(153.24,86.15)
  IN1 w0.097: v2(164.45,76.37) 164.24,76.16 164.24,75.92 164.45,75.7 164.73,75.7 167.92,78.89 168.54,78.89 171.96,82.32 171.96,83.71 174.79,86.54 175.62,86.54 177.68,88.6 177.68,90.32 177.99,90.63 177.99,94.32 181.89,98.22 181.89,102.23 180.58,103.54 180.58,106.98 181.89,108.29 181.89,111.29 v2(181.71,111.47)
  IN3 w0.102: v2(153.24,86.15) 153.24,87.08 151.61,88.7 151.61,91.24 151.1,91.75 151.1,93.73 v2(150.66,94.17)
PS2_DAT_TS: length 77.4
  TOP w0.102: v2(163.85,76.37) 163.85,76.4 164.07,76.62 164.07,76.72 164.77,77.41 v3(164.77,78.51) 164.77,78.77 164.04,79.49 163.57,79.96 162.34,79.96 161.8,80.5 161.8,82.07 160.98,82.88 157.64,82.88 155.54,84.98 153.33,84.98 152.84,85.47 152.84,85.96 v2(152.65,86.15) ; v2(182.3,111.47) 182.12,111.3 182.12,111.06 182.51,110.67 JKB1.8 ; v2(150.66,93.54) 151.18,94.06 JTP1.3
  IN1 w0.097: v2(163.85,76.37) 164.01,76.21 164.01,75.82 164.36,75.48 164.82,75.48 168.01,78.67 168.63,78.67 172.19,82.22 172.19,83.62 174.88,86.32 175.71,86.32 177.9,88.51 177.9,90.22 178.22,90.54 178.22,94.23 182.12,98.13 182.12,102.32 180.8,103.64 180.8,106.88 182.12,108.2 182.12,111.29 v2(182.3,111.47)
  IN3 w0.102: v2(152.65,86.15) 152.65,87.22 151.29,88.58 151.29,91.05 150.66,91.69 v2(150.66,93.54)
PS_ID: length 29
  TOP w0.102: v2(128.47,118.24) 128.43,118.2 127.23,118.2 v1(127.13,118.3) 126.1,118.3 125.96,118.16 124.88,118.16 123.86,119.18 123.86,119.65 124.42,120.2 PU1.4 ; v2(138.56,104.48) 138.61,104.42 139.21,104.42 139.36,104.56 U38.A55
  IN3 w0.102: v2(128.47,118.24) 130.02,116.69 130.02,108.6 131.34,107.28 135.44,107.28 136.5,106.23 136.5,105.15 137.17,104.48 v2(138.56,104.48)
PSID_DISABLE#: length 82
  TOP w0.102: v2(166.34,90.8) 165.73,91.4 U37.A37 ; v1(168.31,113.58) 168.31,113.01 168.82,112.5 v2(168.82,112.45)
  TOP w0.254: v2(121.07,121.78) 120.81,121.53 120.81,121.2 PR13.2
  IN3 w0.102: v2(168.82,112.45) 168.59,112.22 168.59,107.29 168.27,106.97 168.27,105.25 168.39,105.14 168.39,102.61 168.16,102.38 168.16,100.25 168.66,99.75 168.66,93.36 168.28,92.98 167.74,92.98 166.75,91.99 166.75,91.21 v2(166.34,90.8)
  BOTTOM w0.102: v2(121.07,121.78) 122.27,122.99 128.18,122.99 128.33,123.14 129.16,123.14 130.13,122.18 131.99,122.18 132.5,121.67 137.17,121.67 137.45,121.39 146.35,121.39 147.37,120.36 158.3,120.36 160.25,118.42 160.25,117.21 160.85,116.61 165.74,116.61 168.82,113.53 v2(168.82,112.45)
PWM1: length 19
  TOP w0.102: v2(54.01,17.83) v1(53.26,17.83)
  IN2 w0.254: v2(54.01,17.83) 53.65,18.19 53.65,19.27 57.24,22.85 61.07,22.85 v2(65.28,27.05)
  BOTTOM w0.203: PU301.8 65.37,26.48 65.28,26.57 v2(65.28,27.05) ; v2(54.01,17.83) 53.92,17.74 PU300.6
PWR_DET#: length 158.4
  TOP w0.102: U37.B4 169.98,101.82 170.16,101.64 170.16,101.2 v2(170.6,100.77) ; v2(281.09,166.23) 281.05,166.27 JPWR1.5
  IN2 w0.102: v2(170.6,100.77) 171,101.17 171,101.62 176.35,106.97 176.35,108.61 183.51,115.78 183.51,121.24 191.11,128.83 210.95,128.83 213.46,131.34 213.46,133.86 214.21,134.61 216.01,134.61 218,136.61 219.79,136.61 225.94,142.76 225.94,145.17 232.37,151.6 232.37,152.17 237.33,157.13 237.33,158.16 241.4,162.23 246.23,162.23 246.86,162.87 253.66,162.87 254.86,161.66 260.88,161.66 262.98,159.57 265.59,159.57 266.64,158.53 274.76,158.53 275.37,157.92 280.71,157.92 v2(281.47,158.68)
  BOTTOM w0.102: v2(281.09,166.23) R479.1 280.36,164.7 v1(280.36,162.09) 280.36,160.79 281.25,159.91 281.25,158.89 v2(281.47,158.68)
PWR_SRC_ON: length 4.4
  BOTTOM w0.102: v1(90.7,158.94) 90.59,158.83 C438.2
  BOTTOM w0.254: C438.2 R2576.2 R2578.1 88.41,159.05 Q124.3
QSA0: length 27.8
  IN3 w0.102: v2(37.26,90.49) 37.26,90.29 37.36,90.19 37.53,90.19 37.7,90.37 37.7,90.87 38.64,91.81 46.98,91.81 51.57,96.4 54.66,96.4 55.15,95.9 55.15,95.22 56.18,94.19 56.57,94.19 57.1,93.66 57.1,92.22 57.27,92.04 57.43,92.04 57.51,92.13 v4(57.51,92.37)
  BOTTOM w0.102: v4(57.51,92.37) 57.85,92.03 UV1.E19 ; v2(37.26,90.49) 37.64,90.11 UV4.F3
QSA1: length 34.1
  TOP w0.102: UV5.F3 37.87,93.31 38.21,92.97 38.21,92.54 v2(37.83,92.15)
  IN1 w0.097: v2(37.83,92.15) 37.83,92.16 37.98,92.31 38.23,92.31 38.39,92.15 38.39,92.03 38.79,91.63 39.35,91.63 39.85,92.13 39.85,96 40.16,96.31 40.16,96.31 40.28,96.43 41.04,96.43 42.49,97.88 58.25,97.88 59.17,96.97 60.61,95.53 60.61,95.4 61.1,94.91 61.1,93.8 61.56,93.33 v4(61.56,93.14)
  BOTTOM w0.102: v4(61.56,93.14) 61.54,93.14 UV1.C15
QSA2: length 31.1
  TOP w0.102: v4(60.73,94.76) 60.36,95.13 60.36,95.46 59.97,95.85 59.97,96.99 57.94,99.02 57.05,99.02 56.84,98.81 56.84,98.77 56.71,98.65 56.46,98.65 56.33,98.77 56.33,99.02 56.09,99.26 55.68,99.26 55.45,99.02 55.45,98.75 55.35,98.65 55.04,98.65 54.94,98.75 54.94,99.02 54.7,99.26 54.29,99.26 54.05,99.02 54.05,98.75 53.95,98.65 53.65,98.65 53.55,98.75 53.55,98.81 53.34,99.02 v3(50.35,99.02) 48.7,99.02 46.18,96.5 46.18,94.57 44.28,92.68 42.54,92.68 41.36,91.5 40.74,91.5 40.23,91 40.23,90.24 40.1,90.11 UV5.C7
  BOTTOM w0.102: UV1.B16 60.73,94.75 v4(60.73,94.76)
QSA3: length 21
  BOTTOM w0.102: UV1.B22 55.37,94.6 54.98,94.99 54.98,96.2 54.02,97.16 53.18,98 47.77,98 41.85,92.09 40.58,92.09 40.21,92.46 40.21,93.16 UV4.C7
QSA4: length 23.5
  IN1 w0.097: v2(37.27,74.74) 37.27,74.82 38.13,75.67 39.14,75.67 39.8,76.33 41.68,76.33 41.77,76.43 41.77,77.15 41.98,77.35 42.41,77.35 42.61,77.15 42.61,76.43 42.71,76.33 45.36,76.33 49.4,80.37 49.66,80.37 52.84,83.56 52.84,84.07 52.74,84.17 52.58,84.17 v4(52.49,84.08)
  BOTTOM w0.102: UV1.R25 52.87,83.93 52.73,84.08 v4(52.49,84.08) ; v2(37.27,74.74) 37.18,74.65 37.18,74.51 37.41,74.29 37.6,74.29 UV6.F3
QSA5: length 20
  TOP w0.102: v2(54.01,80.72) 54.15,80.72 54.33,80.55 54.33,80.33 54.05,80.05 50.04,80.05 48.99,78.99 48.84,78.99 48.61,79.23 48.31,79.23 47.98,78.9 47.98,78.6 48.22,78.37 48.22,78.22 48,78.01 47.86,78.01 47.62,78.24 47.32,78.24 47,77.92 47,77.62 47.23,77.38 47.23,77.24 45.42,75.43 45.25,75.43 45.21,75.47 44.63,75.47 44.59,75.43 40.79,75.43 40.38,75.02 40.38,74.67 UV7.C7
  BOTTOM w0.102: v2(54.01,80.72) 54.07,80.72 54.47,80.33 UV1.W23
QSA6: length 17.6
  TOP w0.102: v2(37.84,76.4) 38.22,76.79 38.22,77.22 37.88,77.56 UV7.F3
  IN3 w0.102: v4(51.65,77.47) 51.36,77.76 44.83,77.76 42.94,75.87 38.8,75.87 38.31,76.36 38.31,76.57 38.23,76.65 37.91,76.65 37.84,76.58 v2(37.84,76.4)
  BOTTOM w0.102: v4(51.65,77.47) 52.03,77.85 UV1.AB26
QSA7: length 17.6
  BOTTOM w0.102: UV1.T26 51.68,82.42 49.42,82.42 47.6,80.6 47.6,77.58 46.16,76.14 40.72,76.14 40.25,76.62 40.25,77.39 UV6.C7
QSA#0: length 27.8
  IN3 w0.102: v4(57.5,91.54) 57.5,91.8 57.45,91.85 57.19,91.85 56.91,92.14 56.91,93.58 56.49,94 56.11,94 54.96,95.14 54.96,95.83 54.58,96.21 51.64,96.21 47.06,91.62 38.72,91.62 37.89,90.8 37.89,90.29 37.61,90 37.36,90 37.26,89.9 v2(37.26,89.7)
  BOTTOM w0.102: UV1.F19 57.85,91.19 v4(57.5,91.54) ; UV4.G3 36.86,90.1 v2(37.26,89.7)
QSA#1: length 34.3
  TOP w0.102: UV5.G3 36.88,93.33 37.2,93.33 37.3,93.24 37.3,92.64 37.43,92.5 37.68,92.5 37.82,92.64 v2(37.82,92.8)
  IN1 w0.097: v4(61.55,93.96) 61.34,93.96 61.27,94.02 61.27,94.99 60.79,95.47 60.79,95.6 59.24,97.15 58.33,98.06 42.42,98.06 40.97,96.61 40.21,96.61 39.98,96.39 39.98,96.38 39.78,96.18 39.77,96.18 39.67,96.07 39.67,96.02 39.67,96.02 39.67,96 39.67,96 39.67,92.2 39.28,91.81 38.87,91.81 38.57,92.11 38.57,92.22 38.29,92.49 38,92.49 37.82,92.67 v2(37.82,92.8)
  BOTTOM w0.102: v4(61.55,93.96) 61.43,93.84 61.43,93.72 61.65,93.5 61.92,93.5 UV1.C14
QSA#2: length 31
  TOP w0.102: v4(59.9,94.75) 60.17,95.02 60.17,95.38 59.78,95.78 59.78,96.91 57.86,98.83 57.13,98.83 57.03,98.73 57.03,98.7 56.79,98.46 56.38,98.46 56.14,98.7 56.14,98.94 56.02,99.07 55.76,99.07 55.63,98.94 55.63,98.67 55.42,98.46 54.96,98.46 54.75,98.67 54.75,98.94 54.62,99.07 54.37,99.07 54.24,98.94 54.24,98.67 54.03,98.46 53.57,98.46 53.36,98.67 53.36,98.73 53.26,98.83 50.68,98.83 50.65,98.8 50.06,98.8 50.03,98.83 48.78,98.83 46.36,96.42 46.36,94.49 44.36,92.49 42.63,92.49 41.45,91.3 40.86,91.3 40.46,90.9 40.46,90.08 40.52,90.02 40.77,90.02 UV5.B7
  BOTTOM w0.102: v4(59.9,94.75) 60.25,94.75 60.33,94.83 UV1.A16
QSA#3: length 20.9
  BOTTOM w0.102: UV4.B7 40.86,93.37 40.68,93.55 40.51,93.55 40.4,93.43 40.4,92.54 40.65,92.28 41.78,92.28 47.69,98.19 53.25,98.19 55.17,96.28 55.17,95.35 UV1.A22
QSA#4: length 23.6
  IN1 w0.097: v4(53.21,84.07) 53.13,84.07 53.02,83.97 53.02,83.48 49.73,80.19 49.47,80.19 45.43,76.15 42.64,76.15 42.43,76.35 42.43,77.07 42.34,77.17 42.05,77.17 41.95,77.07 41.95,76.35 41.75,76.15 39.88,76.15 39.21,75.49 38.2,75.49 37.72,75.01 37.72,74.63 37.23,74.15 v2(37.23,73.95)
  BOTTOM w0.102: UV6.G3 36.87,74.35 37.24,73.98 37.23,73.98 v2(37.23,73.95) ; v4(53.21,84.07) 53.21,84.1 52.87,84.44 UV1.P25
QSA#5: length 20
  TOP w0.102: UV7.B7 40.57,74.67 40.57,74.94 40.87,75.24 v3(44.92,75.24) 45.5,75.24 47.42,77.16 47.42,77.46 47.19,77.69 47.19,77.84 47.4,78.05 47.55,78.05 47.78,77.82 48.08,77.82 48.41,78.15 48.41,78.45 48.17,78.68 48.17,78.82 48.39,79.04 48.53,79.04 48.77,78.81 49.06,78.81 50.12,79.86 54.13,79.86 54.52,80.26 54.52,80.49 54.74,80.71 v2(54.84,80.71)
  BOTTOM w0.102: v2(54.84,80.71) 55.22,80.33 UV1.W22
QSA#6: length 17.5
  TOP w0.102: v2(37.83,77.05) 37.64,76.86 37.42,76.86 37.31,76.98 37.31,77.49 37.24,77.56 UV7.G3
  IN3 w0.102: v2(51.66,78.24) 51.65,78.24 51.36,77.95 44.75,77.95 42.86,76.06 38.88,76.06 38.5,76.43 38.5,76.65 38.31,76.84 37.91,76.84 37.83,76.92 v2(37.83,77.05)
  BOTTOM w0.102: UV1.AB27 51.27,77.85 v2(51.66,78.24)
QSA#7: length 17.6
  BOTTOM w0.102: UV1.T27 51.06,82.6 49.34,82.6 47.42,80.68 47.42,77.66 46.08,76.33 40.8,76.33 40.43,76.7 40.43,77.81 40.56,77.93 40.91,77.93 41.02,77.82 41.02,77.67 40.91,77.56 UV6.B7
RED_CRT: length 169.2
  TOP w0.102: U39.27 157.17,154.2 157.01,154.36 v2(157.01,154.74)
  IN3 w0.102: v2(194.66,160.2) 194.66,161.09 195.62,162.04 218.79,162.04 221.28,164.53 226.67,164.53 228.55,166.41 236.1,166.41 237.37,167.68 264.58,167.68 264.77,167.87 274.45,167.87 276.28,166.04 279.79,166.04 280.01,165.83 282.56,165.83 282.57,165.84 289.55,165.84 292.71,162.68 303.95,162.68 304.44,162.19 311.02,162.19 v2(312.01,163.19)
  BOTTOM w0.102: v2(157.01,154.74) 158.22,153.53 170.28,153.53 171.02,152.8 178.23,152.8 178.44,153 188.53,153 190.47,154.95 v1(190.47,156.48) 190.47,157.54 190.84,157.9 191.29,157.9 192.61,159.22 193.81,159.22 194.66,160.07 v2(194.66,160.2) ; v2(312.01,163.19) 311.8,163.4 JIO1.18
RED_DOCK: length 9.4
  TOP w0.102: v2(161.45,158.3) v1(158.77,158.3) 158.6,158.3 157.2,156.9 157.2,155.5 157.45,155.25 157.45,154.42 157.57,154.31 U39.26
  BOTTOM w0.102: L70.1 v2(161.45,158.3)
RED_DOCK_PI: length 3.4
  BOTTOM w0.102: JDOCK1.53 v1(161.45,161.56) 161.45,160.6 L70.2
REF_+1.05V_MP: length 5.1
  TOP w0.102: v1(155.13,74.74) PC156.2
  TOP w0.254: v2(151.93,75.75) 151.93,75.43 152.11,75.25 153.83,75.25 154.02,75.06 PC156.2
  BOTTOM w0.203: PU150.26 152.31,76.19 151.93,75.81 v2(151.93,75.75)
REGCTL_PNP10: length 2.4
  TOP w0.203: U21.7 178.9,134.63
  TOP w0.254: 178.9,134.63 178.92,134.61 178.92,133.39 L26.1
REM_DIODE1_N: length 92.8
  TOP w0.254: U38.B13 147.14,99.86 v2(147.29,100) ; v2(115.97,50.74) 116.23,50.49 116.23,50.24 115.83,49.84 115.83,45.6 C370.1 115.64,44.59 Q11.3 ; C358.1 147.87,95.1 147.87,94.74 v2(147.74,94.61)
  IN1 w0.254: v2(131.32,88.62) 131.44,88.5 131.44,88.41 127.01,83.98 127.01,83.63 126.28,82.89 126.28,82.59 125.61,81.93 122.9,81.93 122.12,81.16 120.42,81.16 118.25,78.99 116.31,78.99 115.63,79.66 114.51,79.66 113.54,78.7 113.54,76.64 113.72,76.46 113.72,74 112.18,72.46 112.18,71.43 112.5,71.12 112.5,69 111.6,68.1 111.6,65.31 111.87,65.04 111.87,62.84 112.5,62.21 112.5,61.77 112.19,61.46 112.19,58.13 112.88,57.44 112.88,56.06 113.34,55.6 116.26,55.6 116.48,55.38 116.48,51.25 v2(115.97,50.74) ; v2(147.29,100) 147.71,99.58 147.71,96.76 147.98,96.5 147.98,95.42 147.83,95.27 147.83,94.7 v2(147.74,94.61)
  IN3 w0.254: v2(131.32,88.62) 131.5,88.8 131.5,89.19 131.9,89.59 132.85,89.59 133.36,89.08 134.56,89.08 135.19,89.71 146.82,89.71 147.86,90.76 147.86,94.48 v2(147.74,94.61)
REM_DIODE1_P: length 92.4
  TOP w0.254: Q11.1 116.05,43.3 116.7,43.95 Q11.2 116.56,44.49 C370.2 116.22,45.75 116.22,49.68 116.61,50.08 116.61,50.55 v2(116.8,50.74) ; v2(148.37,94.61) 148.37,95.1 C358.2 ; U38.A13 147.39,97.68 148.12,96.96 v2(148.25,96.96)
  IN1 w0.254: v2(116.8,50.74) 116.86,50.81 116.86,55.54 116.42,55.98 113.5,55.98 113.26,56.22 113.26,57.6 112.57,58.29 112.57,61.31 112.88,61.62 112.88,64.57 111.98,65.47 111.98,67.95 112.88,68.84 112.88,71.27 112.56,71.59 112.56,72.3 114.1,73.84 114.1,76.62 113.92,76.8 113.92,78.54 114.66,79.28 115.47,79.28 116.15,78.6 118.41,78.6 120.58,80.78 122.28,80.78 123.06,81.55 125.77,81.55 126.66,82.44 126.66,82.73 127.39,83.47 127.39,83.82 131.83,88.26 131.83,88.5 v2(131.95,88.62) ; v2(148.25,96.96) 148.25,96.77 148.36,96.66 148.36,95.26 148.21,95.11 148.21,94.78 v2(148.37,94.61)
  IN3 w0.254: v2(131.95,88.62) 131.88,88.7 131.88,89.03 132.05,89.21 132.7,89.21 133.21,88.7 134.72,88.7 135.35,89.33 146.97,89.33 148.25,90.6 148.25,94.48 v2(148.37,94.61)
REM_DIODE2_N: length 88.7
  TOP w0.254: v2(146.02,94.67) 146.02,95.16 C359.1 ; v2(85.49,88.1) 85.38,87.99 83.23,87.99 79.95,84.7 78.62,84.7 v1(76.37,82.45) 75.86,81.94 75.86,81.47 C372.2 75.59,80.42 Q13.3 ; v2(148.05,99.94) 147.64,99.53 U38.B14
  IN3 w0.254: v2(146.02,94.67) 146.13,94.57 146.13,94.18 146.79,93.52 146.79,92.53 144.99,90.73 143.42,90.73 142.63,91.52 140.4,91.52 139.55,90.67 131.31,90.67 130.4,89.75 124.22,89.75 124,89.97 117.19,89.97 116.34,89.12 108.65,89.12 108.56,89.21 103.67,89.21 103.42,88.95 101.89,88.95 101.42,89.42 87.89,89.42 86.47,88 85.59,88 v2(85.49,88.1)
  BOTTOM w0.254: v2(148.05,99.94) 148.05,98.34 147.19,97.48 147.19,96.94 146.15,95.9 146.15,94.8 v2(146.02,94.67)
REM_DIODE2_P: length 88.6
  TOP w0.254: v2(148.2,97.59) 147.89,97.89 U38.A14 ; v2(146.66,94.67) 146.66,95.16 C359.2 ; v2(85.49,87.52) 85.41,87.61 83.39,87.61 80.11,84.32 78.78,84.32 77.11,82.66 77.11,82.62 76.24,81.74 76.24,81.47 C372.1 76.5,80.42 Q13.2 76.05,79.58 Q13.1
  IN3 w0.254: v2(85.49,87.52) 85.53,87.52 85.63,87.62 86.62,87.62 88.05,89.04 101.26,89.04 101.73,88.57 103.57,88.57 103.83,88.83 108.4,88.83 108.49,88.74 116.5,88.74 117.35,89.59 123.85,89.59 124.06,89.37 130.55,89.37 131.47,90.29 139.71,90.29 140.56,91.14 142.47,91.14 143.26,90.35 145.15,90.35 147.17,92.37 147.17,93.67 146.51,94.33 146.51,94.52 v2(146.66,94.67)
  BOTTOM w0.254: v2(146.66,94.67) 146.53,94.8 146.53,95.74 147.57,96.78 147.57,97.32 147.85,97.59 v2(148.2,97.59)
REM_DIODE3_N: length 42.6
  TOP w0.254: U38.A15 148.39,98.09 148.77,97.72 v2(148.77,97.46) ; v2(151.29,96.76) 151.5,96.97 151.91,96.97 C382.1
  BOTTOM w0.254: Q15.3 173.63,77.4 C383.2 173.86,80.52 173.86,81.78 173.19,82.45 169.47,82.45 168.78,83.14 168.78,85.17 168.31,85.63 168.31,87.27 167.3,88.28 165.59,88.28 163.99,89.88 163.99,91.82 163.09,92.73 160.66,92.73 159.86,93.53 158.79,93.53 158.59,93.33 155.39,93.33 154.82,93.91 153.64,93.91 151.93,95.62 151.93,96.8 151.78,96.94 151.47,96.94 151.29,96.76 ; v2(151.29,96.76) 151.29,96.76 ; 151.29,96.76 151.29,96.89 151.21,96.98 149.81,96.98 149.43,97.36 148.87,97.36 v2(148.77,97.46)
REM_DIODE3_P: length 46.5
  TOP w0.254: C382.2 152.04,97.46 v2(151.36,97.46) ; v2(148.16,100.55) 148.56,100.15 148.56,99.56 148.64,99.48 U38.B16
  BOTTOM w0.254: v2(148.16,100.55) 148.56,100.15 148.56,98.48 149.2,97.84 149.45,97.84 149.96,97.34 151.23,97.34 v2(151.36,97.46) 151.5,97.32 151.94,97.32 152.31,96.96 152.31,95.78 153.8,94.29 154.98,94.29 155.55,93.71 158.44,93.71 158.63,93.91 160.02,93.91 160.82,93.11 163.25,93.11 164.38,91.98 164.38,90.03 165.75,88.66 167.46,88.66 168.69,87.43 168.69,85.79 169.16,85.32 169.16,83.3 169.61,82.85 v1(172.26,82.85) 173.33,82.85 174.24,81.94 174.24,80.6 C383.1 174.28,80.03 Q15.1 174.28,78.05 Q15.2
REM_DIODE4_N: length 71.7
  TOP w0.254: Q14.3 167.49,140.3 167.01,139.83 167.01,139.64 C373.1 167.07,139.05 167.07,138.48 v2(167.17,138.38) ; v2(149.72,93.05) 149.62,93.15 149.32,93.15 148.82,93.66 148.82,94.34 149.2,94.72 149.2,96.43 C361.1 149.22,96.99 149.22,97.88 148.89,98.21 U38.A16
  IN1 w0.254: v2(164.47,118.94) 164.37,118.84 164.37,118.36 163.88,117.87 163.22,117.87 161.47,116.11 161.47,114.27 160.9,113.7 159.4,113.7 158.6,112.9 158.6,112.52 158.38,112.3 158.38,109.92 159.17,109.14 159.17,106.69 159.83,106.03 159.83,102.74 159.24,102.15 159.24,100.6 158.7,100.06 158.7,94.23 157.96,93.49 157.96,91.74 v2(158.06,91.64)
  IN3 w0.254: v2(167.17,138.38) 167.06,138.27 167.06,137.01 166.88,136.83 166.88,133.99 164.37,131.48 164.37,119.04 v2(164.47,118.94)
  BOTTOM w0.254: v2(149.72,93.05) 149.91,93.05 150.29,92.67 150.99,92.67 152.82,90.84 157.6,90.84 157.95,91.19 157.95,91.53 v2(158.06,91.64)
REM_DIODE4_P: length 73.5
  TOP w0.254: v2(166.59,138.38) 166.69,138.48 166.69,139.05 C373.2 166.63,139.53 166.63,139.83 166.19,140.27 Q14.2 166.19,140.72 166.84,141.37 Q14.1 ; U38.B17 149.33,99.03 149.33,98.35 149.58,98.1 149.58,98.07 149.61,98.04 149.61,96.94 C361.2 149.58,96.43 149.58,94.57 149.2,94.18 149.2,93.82 149.48,93.54 149.62,93.54 v2(149.72,93.64)
  IN1 w0.254: v2(163.88,118.94) 163.99,118.83 163.99,118.52 163.73,118.25 163.06,118.25 161.08,116.27 161.08,114.43 160.74,114.08 159.24,114.08 158.21,113.06 158.21,112.67 158,112.46 158,109.77 158.79,108.98 158.79,106.53 159.45,105.87 159.45,102.9 158.86,102.31 158.86,100.76 158.32,100.22 158.32,94.39 157.58,93.65 157.58,91.74 v2(157.48,91.64)
  IN3 w0.254: v2(163.88,118.94) 163.99,119.04 163.99,131.64 166.5,134.15 166.5,136.99 166.68,137.17 166.68,138.29 v2(166.59,138.38)
  BOTTOM w0.254: v2(157.48,91.64) 157.57,91.55 157.57,91.34 157.45,91.22 152.98,91.22 151.15,93.05 150.45,93.05 150.07,93.43 150.06,93.43 149.86,93.64 v2(149.72,93.64)
RES_BIAS: length 3.8
  TOP w0.102: R185.1 183.31,134.86 v1(182.84,134.86) 181.2,134.86 180.9,135.17 U21.12
RESET_OUT#: length 90.3
  TOP w0.102: v2(148.06,114.05) 147.88,114.23 R373.2 ; U38.B39 147.14,108.26 147.34,108.07 v2(147.34,107.76) ; RC263.2 137.92,67.75 v2(137.54,68.13)
  IN1 w0.097: v2(147.34,107.76) 147.34,108.81 148.35,109.82 148.35,111.96 147.36,112.96 147.36,113.47 147.94,114.05 v2(148.06,114.05)
  IN2 w0.102: v2(137.54,68.13) 139.93,68.13 141.83,70.03 141.83,70.71 142.42,71.29 144.06,71.29 145.06,70.29 148.88,70.29 149.33,70.73 151.76,70.73 152.07,70.43 154.54,70.43 157.34,73.23 157.34,75.1 158.85,76.62 158.85,82.86 160.36,84.37 v2(160.36,85.3)
  IN3 w0.102: v2(148.06,114.05) 148.36,114.35 148.94,114.35 153.51,109.78 153.51,107.92 154.63,106.8 154.63,96.08 155.76,94.95 155.76,91.67 159.28,88.15 159.28,87.63 160.36,86.55 v2(160.36,85.3)
  BOTTOM w0.076: 137.01,69.84 137.03,69.82
  BOTTOM w0.102: 136.82,70.03 137.01,69.84 ; 136.82,70.03 v1(136.37,70.03) 134.48,70.03 RC88.1 ; 136.82,70.03 137.01,70.22 RC84.1 ; v2(137.54,68.13) 137.54,69.31 137.03,69.82
REXTB: length 3.5
  TOP w0.102: U83.7 302.48,168.53 302.55,168.45 v1(302.55,166.65) R2644.1
RF_+VDDRP: length 3.2
  BOTTOM w0.102: PR705.1 34.24,33.85 v1(34.8,34.41)
  BOTTOM w0.254: PU700.5 34.28,32.04 34.04,32.29 34.04,33.06 PR705.1
RING2: length 55.8
  IN3 w1.016: 304.14,154.93 304.14,151.18 299.63,146.68 267.56,146.68 266.86,147.37 260.9,147.37 258.99,149.28 257.53,149.28
  BOTTOM w0.254: U17.28 256.68,148.41 v2(256.83,148.26) 256.83,148.26 v2(256.83,147.63) 257.15,147.31 R187.1
  vias: v1(304.76,155.6) v2(305.28,155.86) v2(305.27,155.27)
ROM_SCLK: length 7.4
  BOTTOM w0.102: RV89.2 60.62,98.2 61,97.82 v1(61.07,97.82) 62,97.82 64.03,95.79 64.03,93.97 UV1.C12
ROM_SI: length 8.8
  BOTTOM w0.102: v1(57.76,98.78) RV90.2 58.84,97.97 59.65,97.16 61.84,97.16 63.21,95.78 63.21,94.75 UV1.B12
ROM_SO: length 6.4
  BOTTOM w0.102: UV1.A12 63.61,95.83 61.98,97.46 60.01,97.46 v1(59.8,97.67) 59.73,97.74 RV92.2
RSMRST#: length 12.4
  TOP w0.102: U41.3 145.85,118.55 U42.2 143.58,118.55 143.46,118.67 143.46,119.5 143.74,119.78 143.74,121.53 143.54,121.72 141.37,121.72 139.97,120.32 v1(139.97,120.01) 139.97,119.08 139.99,119.06 R440.2
RTD2136_SCL: length 12.8
  TOP w0.102: U52.48 99.42,110.57 99.21,110.35 98.97,110.35 v2(98.82,110.2) ; v2(94.78,104.04) 94.96,104.22 95.26,104.22 95.49,103.99 95.49,103.65 R2592.2 R2590.1
  IN1 w0.097: v2(98.82,110.2) 98.64,110.37 98.1,110.37 95.7,107.98 95.7,104.61 95.31,104.22 94.96,104.22 v2(94.78,104.04)
RTD2136_SDA: length 13.3
  TOP w0.102: U52.47 99.5,110.97 99.12,110.58 99.01,110.58 v2(98.82,110.78) ; v2(94.78,104.63) 94.96,104.45 95.35,104.45 95.72,104.08 95.72,103.65 R2593.2 R2591.1
  IN1 w0.097: v2(98.82,110.78) 98.63,110.6 98.01,110.6 95.48,108.07 95.48,104.7 95.22,104.45 94.96,104.45 v2(94.78,104.63)
RUN_ON: length 313.4
  TOP w0.102: v2(209.9,150.36) 210.9,150.36 211.21,150.68 R426.1 ; R418.1 86.48,72.04 v2(86.1,71.66) ; U37.A11 166.23,103.89 166.98,104.64 167.14,104.64 167.3,104.8 167.73,104.8 R303.2 167.66,105.65 167.66,106.44 170.28,109.06 v2(170.79,109.06) 171.17,109.44 172.59,109.44 v5(173.65,108.38) 173.96,108.07 Q5.2
  TOP w0.254: R154.1 249.71,173.23 250,173.52 272.48,173.52 273.46,172.55 273.46,164.02 v2(273.91,163.57)
  IN2 w0.102: v2(86.1,71.66) 86.35,71.9 86.35,75.06 86.65,75.37 86.65,78.1 86.33,78.41 86.33,85.72 90.33,89.72 92.81,89.72 94.47,91.38 116.64,91.38 117.42,92.17 121.32,92.17 122.27,93.12 129.68,93.12 130.15,93.59 135.86,93.59 137.45,95.18 141.39,95.18 142.28,94.29 143.8,94.29 145.57,92.52 146.16,92.52 147.09,93.45 147.09,94.92 147.47,95.3 148.01,95.3 150.8,98.1 152.57,98.1 153.71,99.24 155.11,99.24 156.95,101.08 156.95,101.87 160.23,105.16 166.48,105.16 170.38,109.06 v2(170.79,109.06) 171.17,109.44 172.23,109.44 174.07,111.28 174.07,112.52 174.97,113.43 177.16,113.43 181.01,117.28 181.01,117.97 180.63,118.36 180.63,121.72 189.8,130.89 204.53,130.89 205.9,132.26 210.48,132.26 211.4,133.19 211.4,135.55 212.37,136.52 212.37,139.69 210.87,141.19 210.87,149.39 v2(209.9,150.36)
  IN3 w0.102: v2(209.9,150.36) 209.4,150.87 209.4,153.15 213.98,157.74 220.64,157.74 224.71,161.81 227.95,161.81 229.75,163.62 237.74,163.62 238.57,164.46 254.23,164.46 254.74,163.95 257.78,163.95 258.61,164.77 267.25,164.77 268.32,163.69 273.79,163.69 v2(273.91,163.57)
  BOTTOM w0.254: v2(273.91,163.57) 273.91,166.3 272.83,167.38 PR206.1
RUN_ON#: length 4.1
  TOP w0.102: 175.73,105.28 Q5.6 Q5.5 ; 175.73,105.28 175.26,105.74 175.26,106.71 v1(175.78,107.23) ; 175.73,105.28 R36.2
RUNPWROK: length 243.8
  TOP w0.102: v2(148.22,103.39) 148.64,103.81 U38.B26 ; v2(110.06,16.54) 110.06,16.3 110.66,15.7 v2(110.66,15.7) ; Q5.3 173.31,107.64 173.14,107.81 v1(171.61,107.81) v2(170.66,106.86) 170.03,106.86 169.73,106.57 U37.A4 ; v2(152.83,106.42) 152.83,106.55 153.52,107.24 R35.2 ; v2(105.64,16.58) 105.65,16.58 108.33,13.89 v2(108.33,13.05)
  IN2 w0.102: v2(189.36,113.53) 189.2,113.38 189.2,105.15 185.2,101.15 185.2,98.11 181.09,94 181.09,92.64 179.83,91.38 179.83,90.42 176.27,86.86 176.27,86.48 173.33,83.53 170.46,83.53 168.3,81.37 168.3,77.94 163.3,72.94 163.3,65.21 162.28,64.19 162.28,36.88 159.68,34.28 159.68,18.53 152.82,11.68 129.96,11.68 128.12,13.52 123.65,13.52 119.01,8.88 115.04,8.88 113.86,10.05 112.74,10.05 112.08,10.72 112.08,11.84 v2(111.67,12.25) 110.71,12.25 109.91,13.05 v2(108.33,13.05)
  IN3 w0.102: v2(152.83,106.42) 153.2,106.05 153.2,104.49 152.37,103.66 152.37,102.73 152.25,102.61 150.21,102.61 149.14,103.68 148.5,103.68 v2(148.22,103.39)
  BOTTOM w0.102: UC6.4 106.2,15.94 106.11,16.03 106.11,16.22 105.75,16.58 v2(105.64,16.58) ; UC6.10 109.96,16.44 v2(110.06,16.54) ; 110.05,14.94 110.05,14.04 110.4,13.68 110.4,13.03 111.19,12.25 v2(111.67,12.25) ; 110.05,14.94 UC6.13 ; 110.05,14.94 110.66,15.56 v2(110.66,15.7) ; v2(189.36,113.53) 188.85,113.02 184.57,113.02 181.27,109.72 178.66,109.72 176.22,107.28 171.08,107.28 v2(170.66,106.86) 169.66,106.86 169.16,106.37 163.3,106.37 162.65,105.72 156.37,105.72 156.06,105.4 153.84,105.4 v2(152.83,106.42) ; v2(108.33,13.05) 107.71,13.67 UC6.1
S5_1.35V: length 4.4
  TOP w0.203: PU100.8 172.54,81.98 v1(172.53,81.97) 172.53,81.69 171.92,81.08 PR107.2
  TOP w0.254: PR108.2 PC115.1 PR107.2
SATA_ACT#: length 142.2
  TOP w0.102: Q24.4 170.49,4.2 170.13,4.56 v1(170.13,4.95) 170.13,5.71 v2(170.11,5.73)
  IN2 w0.102: v2(169.65,73.68) 169.99,73.34 169.99,50.65 171.12,49.51 174.48,49.51 175.92,48.07 175.92,7.95 173.63,5.66 170.18,5.66 v2(170.11,5.73)
  IN3 w0.076: v2(115.21,68.88) 115.51,68.88 116.86,67.53 117.42,67.53 117.68,67.28 119.46,67.28 119.56,67.18 129.52,67.18 130.61,68.27 133.86,68.27 134.24,67.88 134.99,67.88 135.75,68.64 135.75,69.08 136.38,69.71 136.38,69.84
  IN3 w0.102: v2(169.65,73.68) 169.07,74.25 164.37,74.25 164.02,73.9 163.84,73.9 162.65,72.71 158.39,72.71 158.29,72.81 154.08,72.81 153.29,72.03 142.49,72.03 141.68,71.21 139.55,71.21 139.04,70.7 137.03,70.7 136.38,70.06 136.38,69.84
  BOTTOM w0.076: v2(115.21,68.88) 115.28,68.88 115.84,68.32 115.84,67.46 115.71,67.34 115.71,67.09 115.88,66.92 116.06,66.92 116.3,66.69 116.3,66.17 UC1.U3
SATA_COMP: length 7.1
  BOTTOM w0.203: 105.53,60.47 106.69,60.47 107.04,60.12 107.71,60.12 UC1.C12
  BOTTOM w0.305: 105.53,60.47 104.71,61.3 103.89,61.3 v1(103.41,61.78) 103.04,62.14 RC19.1
SATA_IREF: length 8.7
  BOTTOM w0.127: RC14.2 100.27,62.14 v1(99.41,61.29)
  BOTTOM w0.254: UC1.A12 105.35,60.1
  BOTTOM w0.305: RC14.2 100.56,61.78 100.81,61.52 101.76,61.52 101.99,61.75 102.8,61.75 103.65,60.9 104.54,60.9 105.35,60.1
SATA_ODD_PRX_DTX_N2: length 3.4
  BOTTOM w0.102: CS3.2 194.91,30.77 196.21,30.77 196.74,30.24 JSATA2.5
SATA_ODD_PRX_DTX_N2_C: length 129.3
  IN3 w0.102: v2(191.98,30.53) 192.1,30.65 192.45,30.65 192.69,30.9 192.69,31.67 192.03,32.34 191.98,32.39 189.21,32.39 186.55,35.05 186.55,37.27 184.8,39.02 184.8,52.98 182.9,54.88 177.89,54.88 176.5,56.27 176.5,70.81 175.02,72.29 166.53,72.29 165.79,73.03 165.79,73.09 165.3,73.57 164.19,73.57 162.96,72.34 154.31,72.34 153.51,71.54 145.28,71.54 144.04,70.3 139.66,70.3 139.26,69.9 137.51,69.9 137,69.4 136.99,69.4 136.89,69.3 136.89,69.27 134.92,67.3 132.94,67.3 132.88,67.36 131.8,67.36 131.48,67.68 130.63,67.68 129.77,66.82 121.11,66.82 120.71,66.43 120.71,64.88 120.39,64.55 120.39,62.64 119.87,62.13 112.69,62.13 112.37,61.81 111.56,61.81 111.35,62.02 111.35,63.21 v2(111.4,63.26)
  BOTTOM w0.076: v2(111.4,63.26) 111.76,63.61 UC1.J6
  BOTTOM w0.102: CS3.1 193.43,30.62 192.07,30.62 v2(191.98,30.53)
SATA_ODD_PRX_DTX_P2: length 3.3
  BOTTOM w0.102: JSATA2.6 196.78,31.51 196.27,31 194.85,31 CS4.2
SATA_ODD_PRX_DTX_P2_C: length 129.1
  IN3 w0.102: v2(110.82,63.26) 111.14,62.95 111.14,61.93 111.47,61.6 112.46,61.6 112.78,61.92 119.96,61.92 120.6,62.55 120.6,64.46 120.93,64.79 120.93,66.34 121.2,66.6 129.86,66.6 130.72,67.47 131.39,67.47 131.71,67.15 132.79,67.15 132.85,67.09 135.01,67.09 137.6,69.68 139.36,69.68 139.75,70.07 144.13,70.07 145.38,71.31 153.6,71.31 154.41,72.12 163.06,72.12 164.29,73.35 165.2,73.35 165.56,72.99 165.56,72.94 166.43,72.06 174.93,72.06 176.28,70.72 176.28,56.18 177.8,54.65 182.8,54.65 184.57,52.89 184.57,38.93 186.32,37.18 186.32,34.95 189.11,32.16 191.88,32.16 191.93,32.11 192.47,31.58 192.47,30.99 192.35,30.88 192.22,30.88 192.12,30.97 v2(191.98,31.11)
  BOTTOM w0.076: UC1.H6 111.11,63.55 v2(110.82,63.26)
  BOTTOM w0.102: CS4.1 193.19,30.85 192.25,30.85 v2(191.98,31.11)
SATA_ODD_PTX_DRX_N2: length 3.6
  BOTTOM w0.102: JSATA2.3 196.8,27.7 196.36,27.26 194.65,27.26 CS2.2
SATA_ODD_PTX_DRX_N2_C: length 140.5
  IN3 w0.089: 108.3,58.11 108.33,58.11 108.33,58.1 113.71,58.1 113.74,58.13
  IN3 w0.102: v2(103.46,60.2) 103.27,60.2 103.19,60.13 103.19,59.8 103.45,59.53 105.79,59.53 107.21,58.11 108.3,58.11 ; 113.74,58.13 119.57,58.13 120.47,59.03 122.41,59.03 122.84,59.46 126.15,59.46 127.73,61.05 128.55,61.05 129,61.51 130.13,61.51 132.69,64.06 135.19,64.06 136.88,65.76 136.88,66.11 138.69,67.92 139.56,67.92 140.16,68.52 144.43,68.52 144.96,69.05 153.8,69.05 155.35,70.6 158.41,70.6 159.17,71.36 165.93,71.36 166.16,71.12 174.73,71.12 175.78,70.07 175.78,55.34 177.7,53.42 182.78,53.42 184.03,52.17 184.03,36.09 190.9,29.22 190.9,28.15 191.98,27.07 192.15,27.07 v2(192.5,27.43)
  BOTTOM w0.076: v2(103.46,60.2) 103.32,60.2 103.01,59.9 103.01,59.68 103.42,59.28 104.85,59.28 105.03,59.1 105.87,59.1 106.07,58.89 106.78,58.89 107.02,58.65 107.11,58.65 107.18,58.72 UC1.B14
  BOTTOM w0.102: v2(192.5,27.43) 192.5,27.42 192.79,27.13 193.2,27.13 193.38,27.31 CS2.1
SATA_ODD_PTX_DRX_P2: length 3.6
  BOTTOM w0.102: CS1.2 194.66,27.03 196.36,27.03 196.96,26.43 JSATA2.2
SATA_ODD_PTX_DRX_P2_C: length 140.6
  IN3 w0.089: 113.83,57.92 113.81,57.9 108.33,57.9 108.33,57.89 108.3,57.89
  IN3 w0.102: v2(102.81,60.2) 103,60.02 103,59.68 103.36,59.31 105.7,59.31 107.12,57.89 108.3,57.89 ; v2(192.5,26.85) 191.89,26.85 190.68,28.06 190.68,29.13 183.81,36 183.81,52.07 182.69,53.19 177.61,53.19 175.55,55.25 175.55,69.98 174.64,70.9 166.05,70.9 165.81,71.13 159.26,71.13 158.51,70.38 155.45,70.38 153.9,68.83 145.06,68.83 144.53,68.29 140.26,68.29 139.66,67.69 138.78,67.69 137.1,66 137.1,65.67 135.28,63.85 132.78,63.85 130.22,61.29 129.09,61.29 128.64,60.84 127.82,60.84 126.24,59.25 122.93,59.25 122.5,58.82 120.56,58.82 119.66,57.92 113.83,57.92
  BOTTOM w0.076: v2(102.81,60.2) 102.84,60.17 102.84,59.62 103.35,59.11 104.78,59.11 104.96,58.93 105.8,58.93 106.01,58.73 106.71,58.73 106.95,58.49 107.53,58.49 UC1.C15
  BOTTOM w0.102: v2(192.5,26.85) 192.56,26.9 193.14,26.9 CS1.1
SATA_PRX_DKTX_N0: length 4.1
  TOP w0.102: C313.2 162.26,168.74 162.26,169.36 161.81,169.82 161.81,170.05 v2(161.99,170.23)
  BOTTOM w0.102: JDOCK1.56 161.95,171.2 161.81,171.06 161.81,170.42 v2(161.99,170.23)
SATA_PRX_DKTX_N0_C: length 151.9
  TOP w0.102: v2(159.76,159.88) 159.57,160.07 159.57,160.8 161.71,162.93 161.71,166.25 161.95,166.49 161.95,166.85 C313.1
  IN1 w0.097: v2(159.76,159.88) 159.57,159.7 159.57,156.37 158.72,155.52 158.72,154.51 156.46,152.24 156.46,149.13 153.73,146.4 152.42,146.4 150.4,144.39 150.4,140.17 143.81,133.57 142.13,133.57 141.2,132.64 141.2,132.11 140.05,130.96 139.33,130.96 138.44,130.08 137.4,130.08 133.93,126.61 133.93,125.98 133.12,125.17 132.39,125.17 131.62,124.4 131.62,123.49 129.99,121.86 129.99,120.92 129.09,120.01 129.09,117.66 129.42,117.33 129.42,116.26 128.41,115.26 128.41,107.47 127.35,106.42 127.35,104 126.93,103.58 126.93,100.91 122.8,96.79 122.8,91.92 121.33,90.45 116.84,90.45 115.34,88.94 109.3,88.94 108.06,87.69 106.54,87.69 104.43,85.59 102.72,85.59 100.26,83.13 100.26,81.8 99.26,80.8 99.26,77.76 99.1,77.6 99.1,71.66 100.75,70.01 100.75,67.52 100.58,67.35 100.58,67.22 100.65,67.14 v2(101.05,67.14)
  IN3 w0.102: v2(101.05,67.14) 101.23,66.96 101.51,66.96 101.92,66.55 106.96,66.55 108.48,65.03 111.02,65.03 111.3,64.75 111.3,64.31 v2(111.42,64.19)
  BOTTOM w0.076: v2(111.42,64.19) 111.76,64.52 UC1.J5
SATA_PRX_DKTX_P0: length 4.1
  TOP w0.102: v2(161.41,170.23) 161.59,170.05 161.59,169.73 162.04,169.27 162.04,168.74 C312.2
  BOTTOM w0.102: JDOCK1.54 161.45,171.2 161.59,171.06 161.59,170.42 v2(161.41,170.23)
SATA_PRX_DKTX_P0_C: length 152
  TOP w0.102: C312.1 161.74,167.46 161.74,166.58 161.49,166.34 161.49,163.02 159.36,160.89 159.36,160.07 v2(159.17,159.88)
  IN1 w0.097: v2(101.05,66.56) 100.68,66.93 100.57,66.93 100.37,67.13 100.37,67.43 100.54,67.6 100.54,69.92 98.89,71.58 98.89,77.69 99.05,77.85 99.05,80.89 100.05,81.88 100.05,83.22 102.63,85.8 104.34,85.8 106.45,87.91 107.97,87.91 109.22,89.15 115.25,89.15 116.76,90.66 121.25,90.66 122.59,92 122.59,96.87 126.72,101 126.72,103.67 127.14,104.09 127.14,106.5 128.2,107.56 128.2,115.34 129.21,116.35 129.21,117.24 128.88,117.57 128.88,120.1 129.78,121.01 129.78,121.94 131.41,123.57 131.41,124.49 132.3,125.38 133.03,125.38 133.72,126.07 133.72,126.69 137.32,130.29 138.36,130.29 139.24,131.18 139.97,131.18 140.99,132.19 140.99,132.73 142.04,133.79 143.72,133.79 150.19,140.26 150.19,144.48 152.33,146.61 153.64,146.61 156.25,149.22 156.25,152.33 158.51,154.59 158.51,155.61 159.36,156.46 159.36,159.7 v2(159.17,159.88)
  IN3 w0.102: v2(110.78,64.22) 110.96,64.22 111.09,64.34 111.09,64.66 110.93,64.81 108.39,64.81 106.87,66.34 101.83,66.34 101.42,66.74 101.23,66.74 v2(101.05,66.56)
  BOTTOM w0.076: v2(110.78,64.22) 111.11,64.55 UC1.H5
SATA_PRX_DTX_N1: length 8.6
  BOTTOM w0.102: JSATA1.5 84.94,112.41 84.94,112.41 83.88,112.41 83.79,112.5 83.79,112.91 83.67,113.03 83.43,113.03 82.94,112.55 82.94,111.11 82.96,111.1 82.96,110.57 82.94,110.55 82.94,110.09 v3(82.15,109.29) 81.17,108.31 81.17,108.16 C109.1
SATA_PRX_DTX_N1_C: length 85.4
  IN1 w0.097: v2(85.25,64.73) 85.06,64.53 84.48,64.53 84.25,64.76 84.25,65.65 83.03,66.87 83.03,72.3 82.45,72.88 82.45,81.64 83.22,82.41 83.22,84.3 84.53,85.61 84.53,88.58 85.04,89.09 85.04,89.53 88.96,93.46 88.96,97.8 84.11,102.65 84.11,104.26 83.43,104.94 81.46,104.94 81.17,105.23 81.17,105.4 v2(81.36,105.59)
  IN3 w0.076: v2(112.4,62.94) 112.4,62.7 112.31,62.6 112.18,62.6 112,62.78 112,64.96 112.01,64.98 112.01,65
  IN3 w0.102: v2(85.25,64.73) 85.45,64.53 85.72,64.53 85.89,64.7 95.13,64.7 95.73,65.29 97.42,65.29 97.85,64.86 98.45,64.86 98.91,65.32 98.91,65.92 100.73,67.74 101.2,67.74 101.3,67.83 102.37,67.83 102.8,67.4 109.05,67.4 110.88,65.56 111.76,65.56 112.01,65.31 112.01,65
  BOTTOM w0.076: UC1.J8 112.17,62.71 v2(112.4,62.94)
  BOTTOM w0.102: C109.2 81.19,106.59 81.19,105.76 v2(81.36,105.59)
SATA_PRX_DTX_P1: length 8.6
  BOTTOM w0.102: C108.1 80.96,108.16 80.96,108.4 81.8,109.25 81.8,109.26 82.17,109.64 82.19,109.64 82.73,110.18 v3(82.73,110.83) 82.73,112.64 83.34,113.25 83.59,113.25 84.02,113.68 85.03,113.68 JSATA1.6
SATA_PRX_DTX_P1_C: length 85.5
  IN1 w0.097: v2(85.25,64.14) 85.07,64.32 84.39,64.32 84.04,64.67 84.04,65.56 82.82,66.78 82.82,72.22 82.24,72.8 82.24,81.73 83.01,82.49 83.01,84.39 84.31,85.7 84.31,88.67 84.83,89.18 84.83,89.62 88.75,93.54 88.75,97.72 83.9,102.56 83.9,104.17 83.34,104.73 81.37,104.73 80.96,105.14 80.96,105.4 v2(80.77,105.59)
  IN3 w0.076: 111.8,65 111.8,64.99 111.81,64.97 111.81,62.7 111.86,62.65 v2(111.86,62.22)
  IN3 w0.102: v2(85.25,64.14) 85.42,64.32 85.81,64.32 85.98,64.48 95.22,64.48 95.82,65.08 97.33,65.08 97.76,64.65 98.54,64.65 99.12,65.23 99.12,65.83 100.82,67.53 101.29,67.53 101.39,67.62 102.28,67.62 102.72,67.18 108.96,67.18 110.79,65.35 111.67,65.35 111.8,65.22 111.8,65
  BOTTOM w0.076: v2(111.86,62.22) 111.85,62.22 111.36,62.71 UC1.H8
  BOTTOM w0.102: v2(80.77,105.59) 80.97,105.79 80.97,106.56 C108.2
SATA_PRX_MSATATX_N3: length 62.4
  TOP w0.102: R2663.1 167.83,132.29 v2(167.36,132.29) 166.89,132.29 R67.1
  IN1 w0.097: v2(167.36,132.29) 168.35,132.29 169.46,131.17 176.18,131.17 177.33,132.33 181.38,132.33 181.79,132.73 184.19,132.73 184.45,132.99 187.56,132.99 189.95,130.59 200.79,130.59 201.74,131.54 209.06,131.54 210.65,133.13 210.65,135.08 212.57,137 212.57,139.49 214.22,141.14 214.22,142.61 214,142.83 v2(213.31,142.83)
  BOTTOM w0.102: v2(213.31,142.83) 213.05,142.57 212.89,142.57 212.64,142.32 212.64,142.04 212.49,141.9 JMINI2.25
SATA_PRX_MSATATX_N3_M: length 2.3
  TOP w0.102: R67.2 165.49,132.47 165.32,132.47 164.59,133.2 164.5,133.2 164.36,133.06 U91.15
SATA_PRX_MSATATX_P3: length 62.5
  TOP w0.102: R2662.1 167.83,132.87 v2(167.36,132.87) 166.89,132.87 R68.1
  IN1 w0.097: v2(167.36,132.87) 167.73,132.5 168.44,132.5 169.55,131.39 176.09,131.39 177.24,132.54 181.29,132.54 181.7,132.94 184.11,132.94 184.36,133.2 187.65,133.2 190.04,130.8 200.7,130.8 201.65,131.75 208.97,131.75 210.44,133.21 210.44,135.16 212.36,137.09 212.36,139.58 214.01,141.23 214.01,142.52 213.91,142.62 213.67,142.62 213.31,142.26 v2(213.31,142.25)
  BOTTOM w0.102: JMINI2.23 212.42,141.1 212.56,141.24 212.56,141.66 212.85,141.95 212.85,142.23 212.98,142.36 213.2,142.36 v2(213.31,142.25)
SATA_PRX_MSATATX_P3_M: length 2.3
  TOP w0.102: R68.2 165.49,132.69 165.41,132.69 164.68,133.42 164.5,133.42 164.36,133.56 U91.16
SATA_PTX_DKRX_N0: length 8
  TOP w0.102: v2(163.49,170.23) 163.31,170.05 163.31,166.44 163.02,166.15 163.02,164.81 C315.1
  BOTTOM w0.102: JDOCK1.62 163.45,171.2 163.31,171.06 163.31,170.42 v2(163.49,170.23)
SATA_PTX_DKRX_N0_C: length 158.4
  TOP w0.102: C315.2 163.12,163.31 163.12,162.35 163.65,161.81 163.68,161.81 164.06,161.43 164.06,161.41 164.59,160.87 164.59,158.27 164.75,158.11 v2(165.26,158.11)
  IN1 w0.097: v2(104.22,58.65) 104.06,58.49 104.06,58.15 103.82,57.91 101.85,57.91 101.55,58.21 101.55,59.28 100.98,59.85 100.98,61.44 102,62.46 102,66.05 102.31,66.37 102.31,69.17 99.58,71.89 99.58,74.91 99.92,75.25 99.92,79.16 100.95,80.18 100.95,81.66 101.19,81.91 101.19,82.84 102.67,84.32 103.88,84.32 106.67,87.11 109.99,87.11 111.34,88.46 115.56,88.46 116.94,89.85 121.43,89.85 123.28,91.7 123.28,96.59 127.41,100.72 127.41,103.34 127.93,103.86 127.93,106.15 128.94,107.17 128.94,115.02 129.89,115.97 129.89,117.61 129.56,117.94 129.56,119.71 130.47,120.62 130.47,121.56 132.12,123.22 132.12,124.09 132.54,124.51 133.24,124.51 134.66,125.94 134.66,126.63 137.18,129.15 138.23,129.15 139.27,130.19 140.01,130.19 141.72,131.89 141.72,132.44 142.32,133.04 144.06,133.04 150.91,139.9 150.91,144.2 152.63,145.91 154.02,145.91 156.06,147.95 162.55,147.95 164.49,149.89 164.49,157.92 164.69,158.11 v2(165.26,158.11)
  BOTTOM w0.076: UC1.B15 106.84,58.27 106.84,58.36 106.64,58.56 104.83,58.56 104.52,58.25 104.21,58.25 104.1,58.36 104.1,58.52 v2(104.22,58.65)
SATA_PTX_DKRX_P0: length 8
  TOP w0.102: C314.1 162.81,164.81 162.81,166.24 163.09,166.53 163.09,170.05 v2(162.91,170.23)
  BOTTOM w0.102: JDOCK1.60 162.95,171.2 163.09,171.06 163.09,170.42 v2(162.91,170.23)
SATA_PTX_DKRX_P0_C: length 158.3
  TOP w0.102: C314.2 162.81,163.55 162.9,163.47 162.9,162.26 v3(163.7,161.46) 164.38,160.79 164.38,158.18 164.66,157.9 164.9,157.9 v2(165.26,157.53)
  IN1 w0.097: v2(165.26,157.53) 164.89,157.9 164.77,157.9 164.71,157.83 164.71,149.8 162.64,147.74 156.14,147.74 154.11,145.7 152.72,145.7 151.12,144.11 151.12,139.81 144.15,132.83 142.4,132.83 141.93,132.36 141.93,131.8 140.1,129.98 139.36,129.98 138.32,128.94 137.27,128.94 134.87,126.54 134.87,125.85 133.32,124.3 132.63,124.3 132.33,124 132.33,123.13 130.68,121.48 130.68,120.53 129.78,119.63 129.78,118.03 130.1,117.7 130.1,115.88 129.15,114.93 129.15,107.08 128.14,106.06 128.14,103.77 127.62,103.25 127.62,100.63 123.49,96.5 123.49,91.61 121.51,89.64 117.03,89.64 115.65,88.25 111.43,88.25 110.08,86.9 106.76,86.9 103.97,84.11 102.76,84.11 101.4,82.75 101.4,81.82 101.16,81.58 101.16,80.1 100.13,79.07 100.13,75.16 99.79,74.82 99.79,71.98 102.52,69.26 102.52,66.28 102.21,65.97 102.21,62.37 101.19,61.36 101.19,59.94 101.76,59.36 101.76,58.3 101.94,58.12 103.73,58.12 103.85,58.24 103.85,58.55 103.75,58.65 v2(103.57,58.65)
  BOTTOM w0.076: v2(103.57,58.65) 103.73,58.65 103.93,58.45 103.93,58.3 104.14,58.09 104.59,58.09 104.9,58.4 105.17,58.4 105.35,58.22 105.5,58.22 105.68,58.4 105.78,58.4 105.96,58.22 106.12,58.22 106.3,58.4 106.41,58.4 UC1.A15
SATA_PTX_DRX_N1: length 5.9
  BOTTOM w0.102: C106.1 82.73,106.32 v3(82.73,107.33) 82.73,108.79 83.35,109.4 83.79,109.4 84.25,109.87 85.03,109.87 JSATA1.3
SATA_PTX_DRX_N1_C: length 76.7
  IN1 w0.097: v2(85.67,58.35) 85.35,58.67 84.91,58.67 83.9,59.68 83.9,63.31 83.33,63.89 83.33,65.28 82.13,66.48 82.13,70.25 81.55,70.83 81.55,82.54 82.32,83.3 82.32,84.67 83.63,85.98 83.63,90.01 88.05,94.43 88.05,97.42 82.74,102.72 82.74,103.82 v2(82.55,104.01)
  IN3 w0.102: v2(85.67,58.35) 86.02,58.69 86.42,58.69 86.59,58.53 92.04,58.53 92.87,57.69 100.85,57.69 101.08,57.92 105.46,57.92 105.64,57.74 105.64,57.55 v2(105.29,57.2)
  BOTTOM w0.076: v2(105.29,57.2) 105.66,57.57 105.99,57.57 106.19,57.37 106.39,57.37 UC1.A17
  BOTTOM w0.102: v2(82.55,104.01) 82.64,104.1 82.64,104.83 C106.2
SATA_PTX_DRX_P1: length 5.6
  BOTTOM w0.102: C105.1 82.95,106.32 82.95,107.05 82.96,107.07 82.96,107.6 82.95,107.61 82.95,108.7 83.44,109.19 83.66,109.19 84.25,108.6 84.81,108.6 JSATA1.2
SATA_PTX_DRX_P1_C: length 76.8
  IN1 w0.097: v2(85.67,58.93) 85.63,58.88 85,58.88 84.11,59.77 84.11,63.4 83.54,63.97 83.54,65.37 82.34,66.57 82.34,70.34 81.76,70.92 81.76,82.45 82.53,83.22 82.53,84.59 83.84,85.89 83.84,89.92 88.26,94.34 88.26,97.51 82.96,102.81 82.96,103.84 v2(83.13,104.01)
  IN3 w0.102: v2(105.85,57.2) 105.85,57.83 105.55,58.13 100.99,58.13 100.76,57.9 92.96,57.9 92.13,58.74 86.68,58.74 86.51,58.91 85.7,58.91 v2(85.67,58.93)
  BOTTOM w0.076: UC1.B17 107.17,57.18 106.11,57.18 106.09,57.2 v2(105.85,57.2)
  BOTTOM w0.102: C105.2 83.08,105.27 82.92,105.27 82.85,105.21 82.85,104.29 v2(83.13,104.01)
SATA_PTX_MSATARX_N3: length 61.6
  TOP w0.102: C280.1 214.83,144.6 215.04,144.6 v2(215.22,144.42) ; R62.1 167.1,134.27 167.15,134.27 v2(167.36,134.07) 167.52,134.23 167.66,134.23 R2664.1
  IN1 w0.097: v2(215.22,144.42) 215.1,144.54 214.25,144.54 212.44,142.74 212.44,140.83 211.28,139.67 211.28,138.55 210.84,138.12 210.84,136.26 208.97,134.39 208.97,133.49 207.73,132.25 201.46,132.25 200.51,131.3 190.23,131.3 187.85,133.69 183.96,133.69 183.69,133.42 181.5,133.42 181.09,133.01 177.04,133.01 176.63,132.6 174.28,132.6 172.69,134.19 167.49,134.19 v2(167.36,134.07)
SATA_PTX_MSATARX_N3_C: length 2.6
  TOP w0.102: v2(212.91,144.41) 213.02,144.52 213.32,144.52 C280.2
  BOTTOM w0.102: v2(212.91,144.41) 212.72,144.59 212.37,144.59 212.08,144.3 JMINI2.31
SATA_PTX_MSATARX_N3_M: length 2
  TOP w0.102: U91.17 164.67,134.06 164.82,134.2 165.53,134.2 R62.2
SATA_PTX_MSATARX_P3: length 61.4
  TOP w0.102: R2665.1 167.83,134.65 v2(167.36,134.65) 166.89,134.65 R61.1 ; v2(215.22,145) 215.04,144.82 214.83,144.82 C256.1
  IN1 w0.097: v2(215.22,145) 214.98,144.75 214.16,144.75 212.23,142.83 212.23,140.92 211.07,139.75 211.07,138.64 210.63,138.2 210.63,136.35 208.76,134.48 208.76,133.58 207.65,132.46 201.37,132.46 200.42,131.51 190.32,131.51 187.93,133.9 183.87,133.9 183.6,133.63 181.41,133.63 181.01,133.22 176.95,133.22 176.54,132.81 174.37,132.81 172.78,134.4 167.61,134.4 v2(167.36,134.65)
SATA_PTX_MSATARX_P3_C: length 2.7
  TOP w0.102: v2(212.91,144.99) 213.13,144.77 213.19,144.77 C256.2
  BOTTOM w0.102: JMINI2.33 212.08,145.1 212.37,144.81 212.72,144.81 v2(212.91,144.99)
SATA_PTX_MSATARX_P3_M: length 2
  TOP w0.102: U91.18 164.67,134.56 164.82,134.42 165.44,134.42 R61.2
SC48M_CLK_EN: length 93.8
  TOP w0.102: JEXP1.39 88.5,24.3 88.3,24.5 87.67,24.5 87.29,24.12 v1(85,24.12) v2(80.49,24.12)
  IN2 w0.102: v2(81.73,68.7) 81.44,68.41 81.44,65.4 80.87,64.82 80.87,61.78 82.73,59.92 82.73,39.25 79.55,36.07 79.55,25.06 v2(80.49,24.12)
  IN3 w0.102: v2(115.63,66.21) 114.91,66.21 113.99,67.13 111.94,67.13 111.02,68.05 110.41,68.05 110.02,68.44 102.73,68.44 102.51,68.66 101.15,68.66 100.94,68.87 100.29,68.87 99.92,69.24 98.54,69.24 98.13,69.65 97.01,69.65 94.77,67.41 94.09,67.41 93.9,67.22 88.44,67.22 87.72,67.94 86.02,67.94 85.26,68.7 v2(81.73,68.7)
  BOTTOM w0.076: UC1.T3 115.33,65.91 v2(115.63,66.21)
SD/MMCCD#: length 52.9
  IN3 w0.102: v2(7.53,28.95) 8.1,29.51 8.17,29.51 9.56,30.9 9.56,33.9 10.68,35.02 20.2,35.02 29.11,43.93 29.11,53.83 30.64,55.36 v2(33.88,55.36)
  BOTTOM w0.102: JSD1.18 33.05,54.6 v5(33.38,54.92) 34.78,54.92 C273.1 ; v2(33.88,55.36) 34.82,55.36 C273.1 ; C273.1 R299.1 ; v2(7.53,28.95) 7.94,29.35 8.51,29.35 8.67,29.51 U27.21
SD/MMCCLK: length 43.8
  IN3 w0.102: v2(19.53,28.5) 21.74,28.5 21.87,28.63 21.87,32.89 22,33.02 24.92,33.02 25.02,33.12 25.02,33.78 24.92,33.88 23.16,33.88 23.06,33.99 23.06,34.29 23.16,34.39 24.92,34.39 25.02,34.49 25.02,34.8 24.92,34.9 24.21,34.9 24.08,35.03 24.08,35.28 24.21,35.41 24.92,35.41 25.02,35.51 25.02,38.82 32.27,46.07 32.27,52.4 31.22,53.46 v2(30,53.46)
  BOTTOM w0.102: R230.2 17.94,27.6 C255.1 19.07,27.6 19.53,28.06 v2(19.53,28.5) ; JSD1.5 30.26,53.19 v2(30,53.46)
SD/MMCCLK_R: length 2.1
  BOTTOM w0.102: U27.43 15.72,28.31 15.98,28.06 16.29,28.06 16.8,27.55 R230.1
SD/MMCCMD: length 43.9
  IN1 w0.097: v2(24.48,47.5) 24.46,47.53 21.06,47.53 20.93,47.4 20.93,47.09 21.06,46.96 23.06,46.96 23.19,46.84 23.19,46.59 23.06,46.46 21.06,46.46 20.93,46.33 20.93,46.08 21.06,45.95 23.09,45.95 23.21,45.82 23.21,45.53 23.11,45.42 21.13,45.42 20.96,45.25 20.96,28.79 20.16,27.99 16.52,27.99 16.16,27.64 v2(16.16,27.42)
  BOTTOM w0.102: v2(24.48,47.5) 24.49,47.5 24.57,47.58 30.27,47.58 30.35,47.49 JSD1.2 ; v2(16.16,27.42) 16.07,27.51 U27.45
SD/MMCDAT2: length 2
  BOTTOM w0.102: R341.1 16.63,26.11 15.95,26.11 15.75,26.31 U27.48
SD/MMCDAT2_R: length 41.8
  IN1 w0.097: v2(24.56,44.7) 24.56,42.61 24.46,42.51 21.77,42.51 21.66,42.41 21.66,41.9 21.76,41.81 24.44,41.81 24.54,41.71 24.54,41.4 24.44,41.3 21.76,41.3 21.66,41.21 21.66,40.9 21.76,40.8 24.46,40.8 24.59,40.68 24.59,40.43 24.46,40.3 21.76,40.3 21.66,40.2 21.66,28.15 20.18,26.66 v2(19.28,26.66)
  BOTTOM w0.102: JSD1.9 24.57,44.7 v2(24.56,44.7) ; v2(19.28,26.66) 18.39,25.77 R341.2
SD/MMCDAT3: length 1.9
  BOTTOM w0.102: R410.1 16.79,26.47 16.1,26.47 15.86,26.71 U27.47
SD/MMCDAT3_R: length 42.9
  IN1 w0.097: v2(18.64,26.66) 16.89,26.66 16.79,26.76 16.79,27.39 16.89,27.49 20.35,27.49 21.31,28.46 21.31,42.85 21.41,42.95 22.76,42.95 22.88,43.08 22.88,43.33 22.76,43.45 21.44,43.45 21.31,43.58 21.31,43.83 21.44,43.96 23.7,43.96 23.8,44.05 23.8,44.36 23.7,44.46 21.44,44.46 21.31,44.59 21.31,44.82 21.44,44.95 24.13,44.95 v2(24.54,45.36)
  BOTTOM w0.102: JSD1.1 24.66,46.1 24.54,45.97 v2(24.54,45.36) ; v2(18.64,26.66) R410.2
SD_RCLK+: length 19.2
  IN1 w0.089: v2(16.09,30.22) 16.04,30.17 15.77,30.17 15.7,30.24 15.7,30.53 15.62,30.6 15.25,30.6 12.69,33.16 11.91,33.16 11.8,33.05 11.8,32.99 12.04,32.76 v2(12.06,32.76)
  IN3 w0.089: v2(12.06,32.76) 11.93,32.88 11.93,33.02 12.07,33.16 18.11,33.16 18.26,33.01 19.96,33.01 20.29,33.34 20.29,33.46 v2(20.5,33.66)
  BOTTOM w0.089: v2(16.09,30.22) 16,30.31 U27.38 ; R231.1 20.66,34.88 L46.4 20.66,34.16 20.38,33.89 20.38,33.77 v2(20.5,33.66) ; U27.30 11.96,32.24 11.96,32.24 11.96,32.66 v2(12.06,32.76)
SD_RCLK+_D: length 28.8
  IN3 w0.089: v2(28.69,55.36) 28.59,55.26 28.59,46.17 20.39,37.98 20.39,37.75 v2(20.52,37.63)
  BOTTOM w0.089: R231.2 20.66,35.96 L46.3 20.66,36.84 20.4,37.09 20.4,37.5 v2(20.52,37.63) ; JSD1.7 30.2,57.39 30.05,57.54 30.05,58.02 29.9,58.17 29.29,58.17 28.59,57.46 28.59,55.47 v2(28.69,55.36)
SD_RCLK-: length 19.2
  IN1 w0.089: v2(11.47,32.76) 11.47,33.19 11.77,33.49 12.82,33.49 15.38,30.94 15.96,30.94 v2(16.09,30.81)
  IN3 w0.089: v2(19.91,33.66) 19.96,33.6 19.96,33.48 19.83,33.34 18.4,33.34 18.25,33.49 11.94,33.49 11.6,33.16 11.6,32.88 v2(11.47,32.76)
  BOTTOM w0.089: U27.29 11.56,32.66 v2(11.47,32.76) ; U27.37 16,30.71 v2(16.09,30.81) ; R297.1 19.81,34.88 L46.1 19.81,34.11 19.99,33.93 19.99,33.73 v2(19.91,33.66)
SD_RCLK-_D: length 28.9
  IN3 w0.089: v2(28.11,55.36) 28.26,55.22 28.26,46.31 20.06,38.11 20.06,37.75 v2(19.94,37.63)
  BOTTOM w0.089: v2(19.94,37.63) 20.01,37.56 20.01,37.09 19.81,36.89 L46.2 19.81,35.96 R297.2 ; JSD1.8 30.38,58.79 30.15,58.56 29.13,58.56 28.19,57.62 28.19,55.45 v2(28.11,55.36)
SD_UHS2_D0N: length 7.1
  BOTTOM w0.089: U27.34 13.57,31.57 13.57,32.38 14.17,32.98 14.29,33.1 v1(17.41,33.1) 17.78,33.47 17.78,34.12 17.58,34.33 L47.1 17.58,34.88 R315.1
SD_UHS2_D0N_D: length 41.2
  IN3 w0.089: v2(17.69,37.95) 17.82,38.08 17.82,38.26 17.64,38.43 15.51,38.43 15.23,38.72 15.23,40.2 15.1,40.33 14.86,40.33 14.73,40.2 14.73,38.72 14.45,38.43 13.86,38.43 13.58,38.72 13.58,42.05 13.49,42.14 13.17,42.14 13.08,42.05 13.08,38.72 12.8,38.43 12.21,38.43 11.93,38.72 11.93,42.05 11.84,42.14 11.52,42.14 11.43,42.05 11.43,38.72 11.15,38.43 10.56,38.43 10.28,38.72 10.28,42.05 10.19,42.14 9.87,42.14 9.78,42.05 9.78,38.72 9.5,38.43 7.28,38.43 6.98,38.73 6.98,39.15 v2(6.9,39.23)
  BOTTOM w0.089: JSD1.12 6.05,37.5 6.45,37.9 6.45,38.28 6.97,38.8 6.97,39.16 v2(6.9,39.23) ; R315.2 17.58,35.96 L47.2 17.58,36.89 17.78,37.09 17.78,37.86 v2(17.69,37.95)
SD_UHS2_D0P: length 7.1
  BOTTOM w0.089: R306.1 18.43,34.88 L47.4 18.43,34.33 18.18,34.07 18.18,33.31 17.58,32.71 v1(16.01,32.71) 14.45,32.71 13.96,32.22 U27.35
SD_UHS2_D0P_D: length 41.2
  IN3 w0.089: v2(7.49,39.23) 7.31,39.06 7.31,38.87 7.42,38.76 9.36,38.76 9.45,38.85 9.45,42.19 9.73,42.47 10.32,42.47 10.61,42.19 10.61,38.85 10.69,38.76 11.01,38.76 11.1,38.85 11.1,42.19 11.38,42.47 11.97,42.47 12.26,42.19 12.26,38.85 12.35,38.76 12.66,38.76 12.75,38.85 12.75,42.19 13.03,42.47 13.63,42.47 13.91,42.19 13.91,38.85 14,38.76 14.31,38.76 14.4,38.85 14.4,40.34 14.72,40.66 15.24,40.66 15.56,40.34 15.56,38.85 15.65,38.76 17.78,38.76 18.15,38.4 18.15,38.08 v2(18.27,37.95)
  BOTTOM w0.089: v2(18.27,37.95) 18.18,37.86 18.18,37.09 18.43,36.84 L47.3 18.43,35.96 R306.2 ; JSD1.11 7.15,37.51 6.84,37.81 6.84,38.12 7.37,38.64 7.37,39.11 v2(7.49,39.23)
SD_UHS2_D1N: length 5.6
  BOTTOM w0.089: U27.33 13.16,32.17 13.27,32.27 13.27,32.61 14.1,33.44 v1(14.92,33.44) 15.62,33.44 15.95,33.78 15.95,34.18 16.15,34.37 L48.4 16.15,34.88 R337.1
SD_UHS2_D1N_D: length 40
  BOTTOM w0.089: R337.2 16.15,35.96 L48.3 16.15,44.57 10.85,49.87 10.85,60.87 10.53,61.19 9.96,61.19 9.83,61.32 9.83,61.66 9.96,61.79 10.53,61.79 10.85,62.11 10.85,62.85 10.53,63.17 9.78,63.17 9.4,63.55 9.4,66.96 8.88,67.48 7.28,67.48 6.05,66.25 JSD1.15
SD_UHS2_D1P: length 5.6
  BOTTOM w0.089: U27.32 12.76,32.19 12.87,32.29 12.87,32.77 v1(13.55,33.45) 13.93,33.84 15.46,33.84 15.56,33.94 15.56,34.13 15.3,34.39 L48.1 15.3,34.88 R333.1
SD_UHS2_D1P_D: length 40
  BOTTOM w0.089: JSD1.16 7.15,66.82 7.42,67.09 8.71,67.09 9,66.79 9,63.39 9.61,62.78 10.36,62.78 10.45,62.69 10.45,62.27 10.36,62.18 9.79,62.18 9.44,61.82 9.44,61.15 9.79,60.8 10.36,60.8 10.45,60.71 10.45,49.71 15.75,44.41 15.75,39.15 15.63,39.03 15.42,39.03 15.3,38.9 15.3,38.68 15.42,38.56 15.63,38.56 15.75,38.43 15.75,38.19 15.63,38.07 15.42,38.07 15.3,37.94 15.3,37.7 15.42,37.57 15.67,37.57 15.75,37.48 15.75,37.18 15.66,37.09 15.39,37.09 15.3,37 L48.2 15.3,35.96 R333.2
SDWP: length 53.7
  IN3 w0.102: v2(30,52.76) 31.22,52.76 31.91,52.06 31.91,46.23 20.34,34.66 10.82,34.66 9.92,33.75 9.92,30.48 8.38,28.95 v2(8.17,28.95)
  BOTTOM w0.102: U27.20 8.78,29.11 8.61,28.95 v2(8.17,28.95) ; v2(30,52.76) 27.7,55.06 27.7,59 28.99,60.29 30.17,60.29 30.26,60.2 31.46,60.2 JSD1.19
