# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_M_JTAG: length 26.6
  TOP w0.508: 102.15,17.38 102.15,17.9 v2(103.35,19.1) ; 102.15,17.38 v2(100.9,17.38) ; 102.15,17.38 102.64,16.88 103.73,16.88 104.09,17.24 106.23,17.24 106.97,16.5 106.97,16.04 109.09,13.92 v2(110.87,13.92)
  IN3 w0.254: v2(113.77,17.2) 113.04,17.92 112.17,17.92 111.76,17.52 111.76,15.88 110.87,14.99 v2(110.87,13.92)
  BOTTOM w0.102: RC16.2 111.61,13 112.29,12.32 v1(112.29,12.08)
  BOTTOM w0.254: v2(113.77,17.2) 113.77,16.77 RC20.2
  BOTTOM w0.508: RC16.2 111.26,13.92 v2(110.87,13.92) ; v2(100.9,17.38) 101.08,17.2 RC18.2 RC10.2 ; v2(103.35,19.1) RC17.2
+1.05V_MODPHY: length 16
  IN2 w0.508: v2(93.76,58.35) 94.53,59.11 94.53,62.77 90.93,66.36 90.93,67.3 91.34,67.71 92.43,67.71 93.99,69.27 v2(94.21,69.27)
  BOTTOM w0.508: v2(93.76,58.35) 94.21,57.9 LC1.1
  vias: v2(94.21,70.48) v2(94.21,69.88) v5(95.59,69.79)
+1.05V_MODPHY_PCH: length 2.8
  BOTTOM w0.254: v2(113.35,61.45) 113.44,61.45 v2(113.93,60.95) ; v2(113.35,61.45) UC1.M9 ; v2(113.35,61.45) 113.17,61.45 UC1.L10 112.43,62.18 UC1.K9
  vias: v1(100.57,69.22)
+1.05V_MP: length 21.8
  TOP w0.254: 141.45,80.32 142.15,81.02 148.08,81.02 148.4,81.33 153.77,81.33 154.79,80.32 156.18,80.32 156.95,79.56 v1(156.95,78.52) 156.95,77.72 156.5,77.27 v2(155.1,77.27)
  BOTTOM w0.203: v2(155.1,77.27) 155.04,77.27 154.59,77.72 PU150.22
  vias: v2(79.05,80.88) v2(79.05,80.27) v2(79.68,80.89) v2(79.68,80.28) v2(139.7,79.4) v2(139.7,78.76) v2(139.7,78.13) v2(139.7,77.49) v2(139.7,76.86) v2(139.7,76.22) v2(139.7,75.59) v2(140.19,79.71) v2(140.19,79.08) v2(140.19,78.45) v2(140.19,77.81) v2(140.19,77.18) v2(140.19,76.54) v2(140.19,75.91)
+1.5V_RUN: length 280.7
  TOP w0.254: v2(161.26,131.69) 161.53,131.96 U91.11 ; U91.26 162.53,138.82 162.23,139.12 162.23,139.63 ; v2(161.14,138.93) 161.14,138.87 161.53,138.47 U91.28 ; U91.9 159.79,133.56 v2(159.69,133.66) ; U91.13 162.53,131.82 v2(162.66,131.69) ; v2(165.01,135.06) U91.19
  TOP w0.508: v2(93.89,59.91) 94.06,60.07 RC254.1
  TOP w0.559: 162.23,139.63 162.6,139.63 162.85,139.37 v2(162.85,139.25)
  IN2 w0.508: v2(93.89,59.91) 92.77,59.91 92.75,59.94
  IN2 w1.016: 97.19,25.65 97.19,26.52 97.95,27.28 97.95,29.64 99.54,31.23 99.54,42.04 100.62,43.12 100.62,54.92 98.14,57.4 93.32,57.4 92.75,57.97 92.75,62.92 89.06,66.6 ; 161.45,102.86 161.39,102.8 159.37,102.8 158.62,102.05 158.62,100.6 155.99,97.97 ; 257.72,173.09 241.26,173.09 240.16,171.98 230.83,171.98 226.52,167.67 226.52,165.95 224.89,164.33 223.3,164.33 220.36,161.38 218.13,161.38 211.81,155.06 211.81,141.22 214.3,138.73 214.3,136.64 212.09,134.43 212.09,132.76 210.9,131.56 206.35,131.56 204.99,130.2 190.19,130.2 181.33,121.34 181.33,118.67 181.71,118.29 181.71,117.01 177.44,112.74 175.26,112.74 174.75,112.24 174.75,109.34 173.2,107.79 170.37,107.79 169.8,107.22 169.8,106.19 169.05,105.44 ; 89.38,72.32 89.38,78.44 90.92,79.98 90.92,85.65 94.86,89.59 106.14,89.59 106.78,90.24 117.11,90.24 117.9,91.02 122.5,91.02 123.04,91.56 125.12,91.56 125.83,90.85 139.19,90.85 139.95,91.61 142.53,91.61 ; 167.83,102.9 163.11,102.9
  BOTTOM w0.127: v5(96.28,24.43) 96.63,24.78 v2(96.72,24.78)
  vias: v2(97.33,24.78) v2(157.64,121.91) v2(158.15,122.29) v2(158.15,121.53) v2(158.66,121.91) v2(159.3,112.33) v2(159.39,111.75) v2(159.94,112.27) v2(159.98,111.68) v2(162.03,104.32) v2(162.03,103.69) v2(162.66,104.32) v2(162.66,103.69) v2(258.25,172.14) v2(258.86,172.14)
+1.05V_RUN: length 181.5
  TOP w0.254: JXDP1.43 138.15,14.28 138.96,15.09 CC11.1 ; JXDP1.44 138.15,4.35 CC10.1 ; v2(120.02,62.8) 120.02,62.66 119.58,62.22 CC37.1
  TOP w0.381: v2(148.66,116.32) 148.66,115.78 R403.1
  TOP w0.508: v2(138.85,4.31) 138.84,4.31 CC10.1 ; v2(140.5,114.61) 140.5,115.29 R335.1 ; CC11.1 139.1,14.53 v2(138.91,14.34) ; v2(135.8,112.07) R374.2 ; v2(120.87,55.17) 121.12,55.42 121.12,56.87 121.13,56.89 ; CC31.1 114.63,62.58 v2(114.22,62.98) ; RC280.1 v2(135.43,2.78)
  IN1 w0.508: v2(128.26,5.12) 128.26,5.13 129.78,6.65 129.78,11.26 126.35,14.68 121.18,14.68 119.51,16.36 116.15,16.36 113.74,18.77 v2(113.74,19.69)
  IN2 w0.508: 140.5,114.99 v2(140.5,114.61) ; 140.5,114.99 140.82,115.31 146.09,115.31 146.34,115.56 148.31,115.56 148.66,115.91 v2(148.66,116.32) ; 140.5,114.99 140.25,115.24 138.97,115.24 v2(135.8,112.07) 135.67,112.07 133.67,110.06 133.67,109.19 129.32,104.84 129.32,100.58 126.72,97.97 124.68,97.97 122.98,96.27 115.3,96.27 114.21,95.18 110.9,95.18 v2(109.87,94.15) ; v2(135.43,2.78) 130.59,2.78 v2(128.26,5.12) ; v2(94.02,55.87) 94.99,54.89 94.99,31.11 95.83,30.28 96.82,30.28 v2(97,30.09) 97,28.63 96.05,27.68 96.05,24.31 96.3,24.06 99.55,24.06 v2(99.68,23.93) 100.59,23.93 104.65,19.87 v2(109.45,19.87) 110.02,20.44 112.99,20.44 v2(113.74,19.69)
  BOTTOM w0.254: UC1.AG17 121.33,57.53 v2(121.7,57.91) 121.69,57.92 121.69,57.92 121.33,58.28 UC1.AG16 ; v2(114.22,62.98) 113.87,62.63 113.86,62.63 ; UC1.N8 113.86,62.63 ; 113.86,62.63 UC1.P9 ; v2(110.8,60.4) 110.8,60.5 UC1.H11 111.11,60.77 v2(111.48,60.4) 111.76,60.68 UC1.J11 ; v2(120.02,62.8) 120.19,62.63 UC1.AE8 ; UC1.H15 111.11,58.8 v2(110.77,58.46) ; UC1.T21 115.55,55.53 v2(115.18,55.15) 114.81,55.53 UC1.R21 ; UC1.J17 111.76,57.85 v2(111.43,57.52) ; UC1.AF22 v2(120.87,55.17)
  BOTTOM w0.508: RC119.1 RC118.1 100.04,23.93 v2(99.68,23.93) ; v2(113.74,19.69) 113.74,20.27 RC120.1 ; v2(109.45,19.87) 109.46,19.85 RC122.1 RC253.1 ; v2(97,30.09) 97.19,29.9 RC242.2 ; v2(138.91,14.34) 137.64,13.07 137.64,6.79 138.85,5.58 v2(138.85,4.31) 136.96,4.31 v2(135.43,2.78)
  vias: v2(91.19,62.48) v2(91.19,61.4) v2(91.19,60.06) v2(91.26,70.09) v2(91.26,69.5) v2(91.26,68.92) v2(91.26,68.34) v2(91.79,69.23) v2(91.79,68.64) v2(91.79,62.48) v2(91.79,61.4) v2(91.79,60.06) v2(93.41,55.87) v2(103.86,87.18) v2(104.3,87.56) v2(104.75,87.94) v2(105.19,88.32) v2(114.78,56.57) v2(115.61,56.57) v2(120.24,57.27) v5(89.38,58.63)
+1.5V_RUNP: length 13.7
  TOP w0.254: v2(265.59,171.7) v1(265.59,168.93) 265.59,166.55 268.9,163.25 v2(270.74,163.25)
  BOTTOM w0.254: PC202.1 PR202.1 270.55,162.68 270.74,162.87 v2(270.74,163.25)
+1.5V_THERMAL: length 15.5
  TOP w0.102: v2(95.86,59.8) v1(94.74,59.8)
  TOP w0.508: v2(95.86,59.8) 95.86,60.3 95.76,60.41 RC254.2
  IN2 w0.508: v2(95.86,59.8) 95.86,59.81 98.53,59.81 100.43,57.9 104.62,57.9 104.88,58.16 107.29,58.16
  BOTTOM w0.254: v2(111.47,58.46) 111.76,58.75 UC1.J15
+1.05V_VCCST: length 154.6
  TOP w0.508: 138.02,52.76 140.96,52.76 145.13,56.94 v5(145.13,64.15) 145.43,64.44 145.43,68.38 144.98,68.83 142.92,68.83 RC243.2 ; v2(99.03,23.27) 99.03,25.59 v2(98.59,26.03) 99.16,26.6 100.43,26.6 101.26,27.43 102.73,27.43 103.02,27.73 103.81,27.73 104.05,27.49 107.61,27.49 110.08,25.01 110.08,20.69 113.07,17.71 v2(113.07,17.2)
  IN2 w0.508: v2(120.06,55.15) 120.06,54.8 119.66,54.4 112.11,54.4 110.9,53.18 109.09,53.18 107.35,51.44 107.35,40.21 106.02,38.88 106.02,30.98 102.53,27.49 102.53,26.53 102.02,26.03 v2(98.59,26.03)
  IN3 w0.508: v2(56.87,23.75) 62.83,23.75 67.16,19.42 76.17,19.42 79.29,22.53 83.33,22.53 84.09,21.77 86.27,21.77 86.59,22.09 89.81,22.09 90.58,22.85 92.39,22.85 93.61,21.63 96.49,21.63 98.13,23.27 v2(99.03,23.27)
  BOTTOM w0.381: UC1.AE22 120.06,54.51 UC1.AE23 120.46,53.29 v2(120.76,52.99) ; UC1.AE22 v2(120.06,55.15) ; UC1.AE22 UC1.AC22
  BOTTOM w0.508: R24.1 98.97,23.33 v2(99.03,23.27) ; v2(113.07,17.2) 113.07,17.39 112.88,17.58 RC114.1 RC113.1 RC249.1 115.03,17.02 RC244.1 ; RC255.1 98.26,26.36 v2(98.59,26.03) ; v2(56.87,23.75) PC319.1 PR330.1 PR331.1
+1.05V_VMM_VDD: length 8.5
  TOP w0.203: U6.F12 v4(120.09,107.68) ; U6.H8 v4(122.04,105.08) ; U6.E6 v4(119.44,103.13) ; U6.H9 v4(122.04,105.73) ; U6.H7 v4(122.04,103.78) ; U6.H6 v4(122.04,103.13) ; U6.C8 v4(118.14,105.08) ; U6.E9 v4(119.44,105.73) ; U6.C9 v4(118.14,105.73) ; U6.G12 v4(121.39,107.68) ; U6.E5 v4(119.44,102.48) ; U6.E7 v4(119.44,103.78) ; U6.E3 v4(119.44,101.18) ; U6.G3 v4(121.39,101.18) ; U6.E8 v4(119.44,105.08)
  TOP w0.508: v2(120.62,111.43) 120.56,111.49 C11.1 C9.1
  vias: v1(126.14,105.39) v2(111.73,99.75) v2(112.37,99.75) v2(113,99.75) v2(124.74,104.36)
+1.05V_VMM_VDDTX: length 6.9
  TOP w0.203: U6.D3 v4(118.79,101.18) ; U6.J2 v4(122.04,101.18) U6.H3 ; U6.K9 v4(123.34,105.73) ; U6.C7 v4(118.14,103.78) ; U6.E10 119.77,106.06 v4(119.44,106.38) ; U6.K10 v4(123.34,106.38) ; U6.D12 v4(119.44,107.03) ; U6.F3 v4(120.09,101.18) ; U6.H11 v4(122.04,107.03) ; U6.C6 v4(118.14,103.13) ; U6.E12 v4(119.44,107.68) ; U6.J3 v4(122.69,101.18) ; U6.J10 v4(122.69,106.38) ; U6.K8 v4(123.34,105.08)
  vias: v1(119,110.94) v2(112.37,98.86) v2(113,98.86) v2(113.64,98.86) v2(118.97,110.35)
+1.8V_RUN_CARD: length 58.4
  TOP w0.127: v5(15.86,66.86) 15.72,66.72 v2(15.72,64.57)
  TOP w0.508: v2(15.72,64.57) 14.52,63.36 6.52,63.36 v2(4.95,64.94)
  IN3 w0.508: v2(4.95,64.94) 4.95,39.72 6.11,38.56 6.11,35.74 6.58,35.27 6.58,33.09 6.18,32.69 v2(5.24,32.69)
  BOTTOM w0.508: C247.1 17.93,66.92 C246.1 18.25,65.26 17.56,64.57 v2(15.72,64.57) ; JSD1.14 v2(4.95,64.94) ; v2(8.38,31.68) C229.1 7.73,31.88 6.92,32.69 C228.1 v2(5.24,32.69)
+1.35V_MEM: length 132.3
  TOP w0.508: RD3.1 187.63,22.68 187.03,23.28 187.03,30.3 187.04,30.31 ; v2(155.68,13.11) 156.65,13.11 157.01,12.75 RC130.1 RC217.1 ; RC67.1 162.15,30.34
  IN2 w0.508: v2(155.68,13.11) 161.56,13.11 162.53,14.09 162.53,30.91 v2(161.13,32.31)
  BOTTOM w0.178: UC1.AN33 124.75,47.18 v2(125.01,46.92)
  BOTTOM w0.203: v2(126.39,37.91) 126.38,37.92 126.38,38.03 UC1.AR48 ; v2(130.16,46.79) 129.7,46.34 129.19,46.34 UC1.AY35 ; UC1.AY44 129.17,40.06 129.73,40.06 v2(130.16,40.49)
  BOTTOM w0.229: v2(128.88,37.33) 128.88,37.2 UC1.AY50
  BOTTOM w0.254: UC1.AP43 125.4,41.15 v2(125.73,40.83) ; v2(121.59,47.44) UC1.AJ33 ; v2(121.59,51.34) 121.59,51.76 UC1.AH26 ; v2(121.59,48.74) UC1.AJ31 ; UC1.AY40 129.16,43.33 v2(129.45,43.62) ; v2(121.59,44.84) UC1.AJ37
  BOTTOM w0.356: v2(185.43,46.65) 185.43,47.13 184.91,47.65 JDIMM1.124 ; v2(185.46,44.05) JDIMM1.112 ; v2(159.95,45.46) 159.95,46.63 160.68,47.35 JDIMM2.123 ; JDIMM1.117 174.72,45.55 174.09,44.92 v2(174.09,43.87) 174.21,43.75 JDIMM1.111 ; JDIMM1.81 174.24,34.75 174.01,34.52 v2(174.01,33.65) 174.01,33.18 174.24,32.95 JDIMM1.75 ; JDIMM1.82 185.2,35.05 185.55,34.71 v2(185.55,33.6) 185.2,33.25 JDIMM1.76 ; JDIMM2.112 169.24,44.05 v2(168.6,43.41) ; JDIMM1.118 182.65,45.85 v2(182.41,46.09) ; v2(161.05,43.28) 161.52,43.75 JDIMM2.111 ; v2(172.22,46.7) 172.22,47.32 171.9,47.65 JDIMM2.124 ; JDIMM2.117 161.29,45.55 v2(161.2,45.46) ; JDIMM2.94 172.39,38.65 v2(172.82,38.22) 172.82,37.65 172.02,36.85 JDIMM2.88 ; JDIMM1.87 174.58,36.55 v2(174.03,36) ; JDIMM1.100 185.05,40.45 185.38,40.78 v2(185.38,40.84) 185.38,41.81 184.94,42.25 JDIMM1.106 ; JDIMM2.75 161.53,32.95 161.13,32.56 v2(161.13,32.31) ; JDIMM2.105 161.37,41.95 161.01,41.58 v2(161.01,41.45) 161.01,40.38 161.23,40.15 JDIMM2.99 ; v2(172.31,36) 172.31,35.42 171.94,35.05 JDIMM2.82 ; JDIMM2.106 169.34,42.25 v2(168.98,41.89) ; v2(169.36,45.51) 169.7,45.85 JDIMM2.118 ; v2(178.28,46.92) 177.85,47.35 JDIMM1.123 ; JDIMM2.81 163.57,34.75 163.67,34.85 164.5,34.85 164.89,34.46 v2(164.89,34.27) ; v2(173.11,33.66) 172.7,33.25 JDIMM2.76 ; JDIMM1.88 185,36.85 185.38,37.23 v2(185.38,37.46) 185.38,38.32 185.05,38.65 JDIMM1.94 ; v2(174.34,38.03) 174.67,38.35 JDIMM1.93 ; v2(173.9,40.63) 174.38,40.15 JDIMM1.99 ; v2(172.5,40.63) 172.11,40.63 171.93,40.45 JDIMM2.100 ; JDIMM1.105 177.32,41.95 v2(177.57,41.7) ; JDIMM2.87 161.41,36.55 160.91,37.05 v2(160.91,37.9) 161.36,38.35 JDIMM2.93
  vias: v2(186.22,57.46) v2(186.22,56.82) v2(186.22,56.19) v2(186.22,55.55) v2(186.22,54.92) v2(186.22,54.28) v2(186.85,57.46) v2(186.85,56.82) v2(186.85,56.19) v2(186.85,55.55) v2(186.85,54.92) v2(186.85,54.28) v2(187.88,35.81) v2(187.88,35.17) v2(187.88,34.54) v5(174.37,63.5)
+1.35V_MEN_P: length 84.6
  TOP w0.102: v1(189.66,55.17) 190.22,55.73 v3(190.22,57.01)
  TOP w0.203: PU100.5 174.37,84.52 174.53,84.69 PR105.2
  TOP w0.508: v2(173.77,84.57) 173.01,84.57 172.76,84.83 PC114.1 PC113.2 PR105.2
  IN3 w0.305: v3(192.76,62.92) 193.46,62.92 193.84,63.3 193.84,67.57 191.87,70.69 191.87,73.46 192.58,74.87 192.58,87.8 191.93,88.45 186.66,88.45 186.56,88.55 179.81,88.55 179.11,87.85 179.11,86.35 177.7,84.94 174.14,84.94 v2(173.77,84.57)
  IN3 w1.016: 181.43,84.24 182.21,85.02 184.57,85.02 188.82,80.76 190.73,80.76 191.59,79.9 191.59,75.09 190.98,73.9 190.98,70.41 191.81,69.04 191.81,64
  vias: v3(180,83.62) v3(180.63,83.62) v3(190.22,59.3) v3(190.22,58.54) v3(190.22,57.78) v3(190.98,59.3) v3(190.98,58.54) v3(190.98,57.78) v3(190.98,57.01) v3(192,62.92) v3(192,62.16) v3(192,61.4) v3(192,60.63) v3(192,59.87) v3(192,59.11) v3(192.76,62.16) v3(192.76,61.4) v3(192.76,60.63) v3(192.76,59.87) v3(192.76,59.11)
+3.3V_ALW: length 525.9
  TOP w0.102: R389.1 73.7,81.32
  TOP w0.254: RP18.1 155.59,103.64 v2(155.68,103.55) ; RP17.7 141.13,94.61 v2(141.32,94.42) 141.63,94.72 RP17.8 ; v2(131.67,108.64) RP15.7 ; RP2.7 135.15,119.76 134.97,119.93 v2(134.8,119.93) 134.66,119.79 134.66,119.63 135.03,119.26 RP2.8 ; RP2.5 135.09,120.76 v2(134.89,120.55) 135.18,120.26 RP2.6 ; R343.1 155.03,95.29 155.36,95.62 v2(155.36,95.94)
  TOP w0.305: JUDB1.7 89.47,84.55 v2(89.27,84.35)
  TOP w0.381: PC500.2 139.24,131.53 139.17,131.45 PU500.5 ; PR449.1 120.7,117.58 120.13,118.15 PU405.5 ; PC502.2 142.54,127.72 142.47,127.64 PU502.5 ; R272.2 181.33,171.37 181.65,171.06 v2(181.65,170.43) ; R302.1 179.03,92.12 179.48,92.57 184.38,92.57 185.33,91.62 188.51,91.62 189.6,90.53 C404.1 190.17,90.53 190.49,90.21 U47.5 ; UC4.5 141.23,70.49 CC24.1 141.63,70.46 141.95,70.78 v2(143.1,70.78) ; v2(155.1,113.85) 154.86,113.85 R402.1
  TOP w0.406: CV87.1 76.23,77.34 UV14.5 ; C386.1 141.01,117.9 U42.5
  TOP w0.457: R392.1 v2(143.93,91.3) R386.1
  TOP w0.508: R302.1 178.11,91.88 R322.1 178.1,91.38 177.84,91.11 176.89,91.11 176.12,91.88 v2(176.12,93.21) 175.74,93.21 175.31,93.64 R283.1 R292.1 R286.1 ; v2(129.54,83.87) 129.54,82.81 129.19,82.46 RC267.1 ; PC500.2 139.24,132.97 v2(139.67,133.4) ; v2(172.6,76.5) 171.42,76.5 170.65,77.28 PR104.1 ; R478.2 182.9,5.44 v2(182.28,4.82) ; PR504.1 139.45,135.35 v2(139.45,135.7) ; PU403.8 105.56,127.91 v2(106.1,128.44) ; 73.7,81.32 74.51,81.32 v2(74.52,81.33) ; v2(156.02,87.74) 156.42,87.34 R296.1 ; v2(162.91,106.76) 162.9,106.75 162.86,106.75 162.41,106.3 R481.2 ; v2(124.31,124.83) 124.13,124.65 PR8.1 ; R317.2 176.39,99.75 v2(176.88,99.75) ; PR506.1 142.08,123.69 v2(142.59,123.18) ; PC502.2 143.48,128.77 v2(143.55,128.83) ; R432.1 175.36,3.88 R428.1 176.05,3.81 v2(176.06,3.8) ; 194.35,134.1 193.84,134.61 189.27,134.61 188.31,135.56 188.31,137.91 188.17,138.05 PR58.1 ; R293.1 158.46,105.21 v2(157.82,105.21) ; PR156.1 v2(150.47,73.32) ; v2(143.15,67.81) 143.15,67.33 143.72,66.76 143.72,61.68 140.54,58.49 RC264.1 ; R393.1 136.37,91.05 136.14,91.28 136.14,91.28 135.91,91.5 135.91,91.51 135.8,91.62 135.8,92.64 134.73,93.7 130.46,93.7 129.14,92.38 v2(129.07,92.38) ; R288.1 R285.1 R282.1 v2(162.15,87.75) ; v2(177.96,106.61) 177.53,106.18 R36.1 ; v2(165.8,87.56) 165.8,88.47 R295.1 165.84,88.5 R291.1 ; v2(129.14,141.91) PR553.2 ; PR449.1 122.47,116.84 PC433.1 123.48,116.64 123.63,116.79 v2(124.31,116.79) ; v2(140.94,117.34) C386.1 R440.1 ; R477.2 176.62,158.18 v2(176.57,158.23) ; R391.1 166.14,106.92 v2(166.02,106.8) R298.1 ; PR567.2 118.37,147.47 v2(118.89,146.95) ; PR2.1 125.2,130.24 v2(125.2,130.17) ; v2(149.83,128.9) 149.44,128.5 R397.1 ; R363.1 R340.1 149.02,113.64 v2(148.88,113.78) ; v2(144.78,129.72) 143.99,130.51 PR500.2 ; CV87.1 77.21,77.48 v2(77.38,77.65) ; R289.1 171.5,106.11 v2(171.37,106.24) 171.25,106.11 R284.1 ; v2(179.49,108.89) C375.1 179.95,108.27 180.5,108.83 182.85,108.83 183.51,109.48 JKB1.7
  IN2 w0.381: v2(185.46,163.82) 185.46,164.82 182.09,168.18 182.09,169.79 181.65,170.23 v2(181.65,170.43)
  IN2 w0.508: v2(129.07,92.38) 133.01,92.38 133.64,93.02 135.93,93.02 137.64,94.73 141.01,94.73 v2(141.32,94.42) ; v2(176.57,158.23) 176.57,159.5 178.47,161.41 179.93,161.41 182.34,163.82 v2(185.46,163.82) ; v2(313.73,161.03) 313.09,160.39 308.14,160.39 306.42,162.11 304.56,162.11 303.66,161.2 292.33,161.2 291.43,162.11 283.88,162.11 v2(282.8,161.03) 282.8,162.55 281.02,164.33 272.45,164.33 269.59,167.19 259.82,167.19 ; v2(176.06,3.8) 177.08,4.82 v2(182.28,4.82) 183.81,6.34 183.81,9.58 183.49,9.9 183.49,51.68 182.41,52.76 176.72,52.76 175.23,54.25 175.23,71.81 172.6,74.44 v2(172.6,76.5) ; v2(89.27,84.35) 90.03,83.59 90.03,80.35 88.47,78.78 88.47,76.58 v2(88.48,76.57) ; v2(143.15,67.81) 143.15,68.75 142.59,69.31 142.59,70.27 v2(143.1,70.78)
  IN2 w1.016: 82.9,26.34 82.9,25.01 84.05,23.87 85,23.87 85.64,23.23 ; 85.52,66.54 88.75,63.31 88.75,54.03 90.52,52.25 90.52,29.52 ; 256.7,168.08 255.88,168.9 234.66,168.9 224.8,159.04 224.8,156.23 225.78,155.25 225.78,152.77 225.08,152.07 225.08,149.41 223.43,147.76 219.81,147.76 218.99,148.58 216.45,148.58
  IN3 w0.508: v2(76.87,102.29) 72.11,102.29 70.9,103.5 63.98,103.5 61.89,101.4 60.62,101.4 59.63,100.41 44.18,100.41 42.53,98.76 36.56,98.76 35.15,100.17 27.19,100.17 26.48,99.46 v2(25.84,99.46) ; v2(124.31,124.83) 124.05,124.58 124.05,122.86 125.07,121.85 125.07,118.42 124.31,117.66 v2(124.31,116.79) ; v2(185.46,163.82) 186.92,162.36 190.54,162.36 194.09,165.92 200.19,165.92 v2(200.95,166.68)
  BOTTOM w0.508: RV2805.1 24.91,99.13 25.25,99.46 v2(25.84,99.46) ; v2(313.73,161.03) 314.24,160.52 314.24,156.4 R476.2 ; v2(129.54,83.87) v5(129.54,84.67) 129.54,86.44 129.07,86.91 v2(129.07,92.38) ; R479.2 281.09,163.83 v5(281.86,163.07) 282.65,162.27 282.65,161.18 v2(282.8,161.03) R228.2
  vias: v2(85.13,68.25) v2(85.13,67.62) v2(85.09,20.67) v2(88.48,75.94) v2(88.48,75.35) v2(88.48,74.77) v2(88.49,21.1) v2(88.49,20.51) v2(132.31,103.88) v2(139.74,114.61) v2(147.42,123.82) v2(147.74,123.31) v2(148.06,123.82) v2(149.52,118.74) v2(149.95,119.24) v2(160.44,87.81) v2(161.07,87.81) v2(194.92,134.17) v2(194.92,132.9) v2(195.24,133.53) v2(195.55,134.17) v2(195.55,132.9) v2(195.87,133.53) v2(196.19,134.17) v2(196.19,132.9) v2(196.51,133.53) v2(196.82,134.17) v2(196.82,132.9) v2(197.14,133.53) v2(197.46,132.9) v2(197.78,133.53) v2(203.24,150.49) v2(203.62,149.98) v2(203.94,150.49) v2(208.83,135.56) v2(208.89,139.69) v2(208.89,139.06) v2(208.89,137.09) v2(208.89,136.45) v2(209.33,135.88) v2(209.52,139.69) v2(209.52,139.06) v2(209.52,137.09) v2(209.52,136.45) v2(213.33,149.53) v2(213.33,148.9) v2(213.97,149.53) v2(213.97,148.9) v2(213.97,148.26) v2(214.6,149.53) v2(214.6,148.9) v2(214.6,148.26) v2(215.24,148.9) v2(215.24,148.26) v2(256.96,167.19) v2(257.59,167.19) v2(258.23,167.19) v2(258.86,167.19) v3(92.87,106.1) v3(93.26,105.46) v3(93.57,106.1) v3(96.87,98.1) v3(96.87,97.46) v3(97.51,98.73) v3(97.51,98.1) v3(97.51,97.46) v5(256.77,166.36)
+3.3V_ALW2: length 421.9
  TOP w0.203: PU51.3 188,143.06 v2(187.74,142.8)
  TOP w0.254: R367.2 133.01,99.12 132.69,98.8 v2(132.37,98.8)
  TOP w0.305: PR446.1 v2(103.67,124.83)
  TOP w0.381: PC515.1 145.76,132.11 PU506.5 ; PU503.5 143.92,151.34 PC507.1 ; PC510.1 141.94,155.63 PU505.5 ; PU504.5 144.38,154.51 PC508.1
  TOP w0.508: PR557.1 130.48,137.13 v2(130.48,136.39) 130.48,135.25 v5(128.66,133.44) 127.85,132.63 PR550.1 127.23,132.2 v2(127.48,131.94) ; v2(187.74,140.07) 187.43,139.75 PC51.2 ; v2(144.5,155.25) 144.37,155.12 PC508.1 ; PR539.2 133.82,121.45 133.26,120.9 130.98,120.9 130.54,121.34 130.54,121.98 130.9,122.34 PR526.2 130.11,122.93 129.22,122.04 v2(128.69,122.04) ; R108.1 97.89,82.57 v2(98.1,82.36) ; PC510.1 v2(142.01,156.38) ; v2(124.31,130.99) 124.31,131.25 123.34,132.21 PR538.1 ; v2(119.53,147.36) 118.88,148.01 PR508.1 117.93,148.42 PR568.2 ; v2(141.96,141.98) 141.95,141.99 PR518.2 PR522.1 ; PR505.1 138.15,137.96 138.66,138.47 PR532.1 v2(139.91,138.47) ; PC515.1 145.35,132.16 145.06,131.87 v2(145.06,131.72) ; PR440.1 114.92,120.46 114.59,120.13 v2(114.34,120.13) ; v2(143.8,152.07) PC507.1 PR521.1
  IN1 w0.508: v2(119.53,147.36) 119.76,147.13 119.76,143.44 v2(119.39,143.07)
  IN2 w0.508: v2(145.06,131.72) 145.06,134.65 142.55,137.16 141.22,137.16 v2(139.91,138.47) ; v2(79.73,106.99) 79.73,101.4 81.51,99.62 81.51,90.59 v2(82.91,89.19) ; v2(151.29,84.64) 148.56,81.91 143.59,81.91 143.14,82.35 142.53,82.35 141.32,81.14 139.45,81.14 136.64,78.34 136.64,75.76 136.24,75.37 v2(135.93,75.37) ; v2(93.69,124.83) v2(103.67,124.83) 106.34,124.83 108.24,122.93 111.54,122.93 v2(114.34,120.13) ; v2(124.31,130.99) 124.18,131.12 124.18,132.26 124.62,132.71 126.72,132.71 v2(127.48,131.94) ; v2(80.17,78.29) 78.84,78.29 78.33,77.78 78.33,76.32 77.58,75.57 77.58,74.08 78.54,73.13 78.54,69.28 76.94,67.68 76.24,67.68 75.28,66.73 72.43,66.73 70.18,64.48 43.51,64.48 v2(41.63,62.6)
  IN3 w0.508: 143.04,151.95 143.04,146.49 141.96,145.41 v2(141.96,141.98) 140.69,140.71 140.69,139.25 v2(139.91,138.47) ; v2(93.69,124.83) 92.39,124.83 84.72,117.16 84.72,110.21 83.72,109.21 81.95,109.21 v2(79.73,106.99) ; v2(80.17,78.29) 80.43,78.29 84.05,81.91 87.26,81.91 88.65,80.52 89.66,80.52 91.49,82.35 98.09,82.35 v2(98.1,82.36) ; v2(131.66,111.69) 131.66,114.76 132.13,115.23 132.13,120.44 132.25,120.56 132.25,122.11 131.81,122.55 130.09,122.55 129.58,122.04 v2(128.69,122.04) 128.09,122.04 127.74,122.39 127.74,131.69 v2(127.48,131.94) 127.48,132.66 125.07,135.07 125.07,135.72 120.97,139.82 120.97,142.08 119.98,143.07 v2(119.39,143.07)
  BOTTOM w0.381: UC7.5 136.42,75.37 v2(135.93,75.37) 135.72,75.16 CC82.1
  BOTTOM w0.508: v2(128.69,122.04) 128.46,122.04 127.94,122.56 122.74,122.56 121.12,120.93 115.39,120.93 114.59,120.13 v2(114.34,120.13) ; v2(41.63,62.6) 41.63,62.92 40.01,64.54 RTCD1.3 ; v2(151.29,84.64) 151.02,84.64 147.33,88.33 143.13,88.33 142.37,87.57 141.59,87.57 140.91,88.26 137.67,88.26 135.18,90.75 135.18,92.57 134.75,93 133.5,93 132.65,93.85 132.65,98.52 v2(132.37,98.8) 131.48,98.8 130.59,99.69 130.59,111.24 131.04,111.69 v2(131.66,111.69) ; v2(82.91,89.19) 82.91,88.62 83.86,87.67 83.86,84.89 83.67,84.7 83.67,79.94 82.02,78.29 v2(80.17,78.29) ; v2(141.96,141.98) 144.16,141.98 145.69,140.45 155.55,140.45 156.76,141.66 156.76,144.58 158.15,145.98 173.01,145.98 175.81,148.77 182.16,148.77 187.74,143.18 v2(187.74,142.8) v2(187.74,140.07) ; v2(130.48,136.39) 130.48,136.14 130.79,135.82 132.4,135.82 133.63,137.05 136.71,137.05 138.14,138.47 v2(139.91,138.47)
+3.3V_ALW_5048: length 58.8
  TOP w0.254: U37.A54 173.26,96.34 173.47,96.13 173.9,96.13 174.22,96.45 C331.1 ; v2(169.76,101.4) 169.76,101.54 169.48,101.82 U37.B5
  TOP w0.279: U37.A17 159.06,101.34 C334.1 ; C330.1 168.73,89.76 v1(168.73,90.83) U37.A43
  TOP w0.305: v2(164.26,96.13) 164.26,95.95 163.9,95.59 U37.B30
  TOP w0.381: v2(159.68,94.54) 159.13,94.54 C329.1
  TOP w0.508: v2(173.71,96.7) 174.14,96.7 C331.1 ; C334.1 159.24,101.41 v2(159.74,101.91) 159.34,102.3 C332.1 ; v2(169.72,90.51) 169.72,90.36 169.07,89.71 C330.1
  IN2 w0.254: 168.71,100.07 169.23,100.59 169.23,101.17 169.45,101.4 v2(169.76,101.4)
  IN2 w0.508: v2(173.71,96.7) 174.34,96.06 174.34,92.73 173.16,91.55 172.92,91.55 171.88,90.51 v2(169.72,90.51) ; v2(159.74,101.91) 163.2,101.91 163.3,102.01 166.63,102.01 167.11,101.53 167.11,100.46 167.5,100.07 168.71,100.07
  IN3 w0.508: v2(159.09,92.7) 158.98,92.82 158.98,98.44 158.63,98.78 158.63,99.37 157.43,100.57 v2(157.43,101.72)
  BOTTOM w0.508: v2(157.43,101.72) 157.62,101.91 v2(159.74,101.91) ; v2(169.72,90.51) 169.72,90.86 168.51,92.07 168.51,94.7 168.1,95.11 165.23,95.11 164.26,96.09 v2(164.26,96.13)
  vias: v2(159.73,92.7)
+3.3V_ALW_5075: length 73.8
  TOP w0.102: v1(146.65,116.48) 147.75,117.58 PJP7.2
  TOP w0.254: C355.1 143.93,110.99 144.25,110.67 144.25,110.37 144.6,110.01 v2(144.92,110.01) ; C356.1 145.95,97.07 146.5,97.62 v2(146.55,97.62)
  TOP w0.279: U38.A41 144.89,109.99 v2(144.92,110.01) ; v2(138.97,106.06) U38.A52 ; U38.A11 146.39,97.77 v2(146.55,97.62) ; v2(151.4,104.76) 151.2,104.56 U38.A26 ; U38.B3 142.14,99.59 142.24,99.69 v2(142.24,100.09)
  TOP w0.305: v2(149.9,109.02) 149.51,109.02 149.14,108.65 U38.B35
  TOP w0.508: v2(149.9,111.18) C351.1 ; R461.1 136.04,100.37 135.94,100.27 135.94,99.25 135.1,98.42 133.26,98.42 132.94,98.1 129.96,98.1 v2(129.7,98.35) ; C354.1 137.82,107.69 v2(137.88,107.75) ; v2(152.88,109.3) 153.16,109.02 C350.1 ; v2(155.1,100.7) R336.1 ; C349.1 v2(142.72,95.32)
  IN2 w0.508: v2(129.7,98.35) 130.15,98.35 130.72,98.92 130.72,104.13 131.8,105.21 133.07,105.21 133.79,104.49 v2(134.33,104.49)
  IN3 w0.406: 140.94,99.24 141.96,99.24 142.24,99.52 v2(142.24,100.09)
  IN3 w0.508: v2(138.97,106.06) 139.52,106.06 140.31,105.27 140.31,99.88 140.94,99.24 ; v2(146.55,97.62) 146.32,97.62 145.95,97.25 145.95,96.18 144.88,95.11 142.93,95.11 v2(142.72,95.32) ; v2(151.4,104.76) 151.14,104.76 150.41,105.49 150.41,108.51 v2(149.9,109.02)
  BOTTOM w0.457: v2(142.72,95.32) 142.89,95.48 142.89,99.44 v2(142.24,100.09)
  BOTTOM w0.508: 137.77,106.73 138.78,106.73 138.97,106.54 v2(138.97,106.06) ; 137.77,106.73 137.77,107.64 v2(137.88,107.75) ; 137.77,106.73 135.53,104.49 v2(134.33,104.49) ; v2(151.4,104.76) 152.12,104.04 153.15,104.04 154.15,103.04 154.15,101.46 154.91,100.7 v2(155.1,100.7)
  vias: v2(149.33,116.32) v2(149.96,116.32)
+3.3V_ALW_PCH: length 176.6
  TOP w0.254: v2(131.26,70.65) 131.9,70.65 133.07,71.83 RP12.5 133.27,72.2 133.43,72.36 133.43,72.55 133.27,72.7 RP12.6 ; v2(117.39,84.07) 117,84.07 RP10.8 ; RC186.2 119.78,84.51 v2(119.78,83.99)
  TOP w0.305: JAPS1.1 152.19,67.64 151.97,67.86 146.94,67.86 145.92,68.88 145.92,69.73 144.99,70.66 144.99,71.31 144.65,71.64 143.74,71.64 143.39,71.3 141.64,71.3 141.45,71.11 v2(138.61,71.11)
  TOP w0.381: v2(120.64,79.22) 120.65,79.22 120.61,79.25 120.61,80.48 RC30.1 ; CC44.1 120.19,55.92 119.68,56.43 v2(119.68,56.55) ; RC192.2 118.07,84.75 v2(117.39,84.07)
  TOP w0.508: RC190.1 114.65,82.79 v2(114.65,82.79) ; RC102.2 135.27,17.07 133.97,18.38 v2(131.69,18.38) ; RC265.1 128.24,82.21 v2(128.5,82.46) ; RC28.1 124.21,82.02 v2(124.7,82.52) ; RC74.1 v2(116.94,82.8) ; CC28.1 118.39,59.35 v2(118.15,59.11) ; v2(128.5,72.52) 129.76,72.52 130.56,73.32 v2(130.56,74.06)
  TOP w0.559: v2(138.28,66.56) 138.85,65.99 v5(138.85,61.41) 138.85,60.33 137.9,59.38 RC261.1
  IN2 w0.508: v2(138.28,66.56) 138.93,65.9 145.58,65.9 146.28,66.6 153.87,66.6 154.91,65.56 154.91,52.63 153.83,51.55 153.83,20.61 152.57,19.35 132.65,19.35 v2(131.69,18.38) ; v2(138.61,71.11) 138.15,71.57 133.34,71.57 132.42,70.65 v2(131.26,70.65)
  IN3 w0.381: v2(131.26,70.65) 131.98,71.37 131.98,72.04 131.67,72.35 129.04,72.35 128.88,72.51 128.51,72.51 v2(128.5,72.52)
  BOTTOM w0.229: RP14.1 128.45,80.14 128.65,79.94 129.21,79.94 129.45,80.17 RP14.3
  BOTTOM w0.254: UC1.AE21 120.06,55.93 UC1.AE20 120.06,56.14 119.68,56.51 v2(119.68,56.55) ; 129.45,81.18 129.45,81.52 v2(128.5,82.46) ; 129.45,81.18 129.86,81.18 129.95,81.09 RP14.4 ; 129.45,81.18 RP14.3 ; UC1.AC9 UC1.AA9 118.1,62.17 118.1,61.44 ; UC1.AH14 122.01,59.02 122.64,58.39 122.64,58.33 v2(122.64,58.33) ; v2(130.73,80.38) 130.73,79.06 131.24,78.55 133.45,78.55 133.64,78.36 RC70.1
  BOTTOM w0.381: 120.61,79.22 120.6,79.22 120.6,79.3 120.61,79.32 120.61,79.96 120.83,80.18 RC175.2 ; 120.61,79.22 120.61,79.06 120.84,78.83 121.55,78.83 RC37.2 ; 120.61,79.22 v2(120.64,79.22) ; v2(118.15,59.11) 118.15,61.4 118.1,61.44 ; RC3.1 139.23,72.38 138.61,71.76 v2(138.61,71.11) 138.6,71.11 138.6,69.47 138.99,69.08 138.99,67.27 v2(138.28,66.56)
  BOTTOM w0.508: RC27.1 124.68,71.7 122.72,73.65 v2(122.72,73.78) ; RC37.2 RC36.2
  vias: v2(92.49,75.64) v2(92.49,75.06) v2(93.08,75.64) v2(93.08,75.06) v2(97.87,80.69) v2(99.67,80.47) v2(99.67,79.89) v2(100.23,80.16) v2(115.73,85.91) v2(118.26,79.72)
+3.3V_ALW_PCH_U41: length 2.8
  TOP w0.457: U41.1 145.96,120.2 145.12,121.04 C387.1
  TOP w0.508: C387.1 145.11,121.23 R411.2
+3.3V_ALWP: length 27.7
  TOP w0.254: PR51.1 v2(184.82,141.66)
  IN2 w0.254: v2(184.82,141.66) 185.52,141.66 186.09,141.09 186.09,135.37 189.05,132.41 202.44,132.41 v2(203.49,133.47)
  vias: v1(206.44,134.56) v2(203.81,134.04) v2(204.13,133.47) v2(204.44,134.04) v2(204.76,133.47) v2(205.08,134.04) v2(205.4,133.47) v2(205.71,134.04) v2(206.03,133.47) v2(206.35,134.04) v2(206.67,133.47) v2(206.98,134.04)
+3.3V_AVCC: length 7.9
  TOP w0.102: L50.2 99.2,104.99 v1(99.02,104.8)
  TOP w0.203: U52.5 v2(102.56,108.8)
  TOP w0.508: v2(100.75,107.31) C444.1 100.13,106.47 C443.1 L50.2
  IN3 w0.508: v2(102.56,108.8) 102.24,108.8 v2(100.75,107.31)
+3.3V_CAM: length 2.5
  TOP w0.102: 99.07,140.31 99.1,140.31 99.2,140.21 100.11,140.21 100.79,140.88 101.17,140.88 v5(101.26,140.97)
+3.3V_CAM_Q:
  vias: v1(102.15,142.51)
+3.3V_DVCC: length 7.3
  TOP w0.102: L49.2 97.22,106.36 v1(97.48,106.1)
  TOP w0.203: v2(107.23,115.46) 107.23,115.35 106.91,115.03 106.91,114.42 106.66,114.17 U52.22
  TOP w0.508: v2(94.65,101.78) 94.65,101.78 94.27,102.16 R2590.2 ; R2591.2 v2(96.94,101.78)
  IN3 w0.508: v2(107.35,113.08) 107.23,113.21 v2(107.23,115.46)
  vias: v2(98.27,108) v2(98.27,107.37) v2(107.86,113.53)
+3.3V_GPU: length 37.6
  TOP w0.381: RV2647.1 70.14,94.02 RV35.2 ; 71.47,81.21 71.84,81.58 QC11.5 ; 71.47,81.21 71.11,81.58 QC11.2 ; 71.47,81.21 71.47,80.57 71.14,80.24 RV2433.1
  TOP w0.457: RV35.2 70.98,94.16 QC8.2 QC8.5 74.23,94.16 74.36,94.03 v2(74.67,94.03)
  TOP w0.508: v4(70.67,79.06) 71.14,79.53 RV2433.1 ; CV3053.1 v2(73.32,75.81) ; RZ41.1 v2(63.46,72.27) ; RV2404.2 RV34.2 68.57,90.8 70.18,90.8 v1(70.46,91.08) 70.8,91.42 RV2446.2 71.72,91.3 72.81,91.3 73.19,91.69 74.4,91.69 v2(74.59,91.49) ; RV2651.1 77.38,93.34 77.66,93.05 v2(77.66,93.01)
  BOTTOM w0.381: QC9.5 68.95,104.83 69.25,104.52 ; 69.25,104.52 RV49.1 RV50.1 ; 69.25,104.52 68.95,104.22 QC9.2 ; 78.59,89.4 79.29,89.4 79.67,89.78 79.67,90.44 79.31,90.8 QC6.5
  BOTTOM w0.457: v2(67.83,102.88) 68.69,102.88 68.95,103.14 QC9.2
  BOTTOM w0.508: v2(76.36,97.08) 77.01,96.44 RV94.2 ; v2(71.54,100.32) 70.66,99.44 70.27,99.44 RV48.2 ; RV2649.1 76.87,93.45 76.87,92.84 RV2653.1 77.35,92.7 v2(77.66,93.01) 77.66,93.45 78.13,93.92 78.94,93.92 79.18,93.68 RV75.2
  vias: v2(67.33,79.05) v2(67.33,78.25) v2(76.24,88.57) v2(76.24,87.94) v2(76.87,88.57) v2(76.87,87.94)
+3.3V_HDD: length 1.6
  TOP w0.254: 86.83,112.7 R124.1
  vias: v5(88.61,112.58)
+3.3V_HDD_C:
  vias: v1(88.54,119.55) v3(87.16,122.67) v3(87.16,121.97) v3(87.16,121.28)
+3.3V_LAN: length 165.9
  TOP w0.203: 189.67,158.54 C193.1
  TOP w0.254: U23.21 189.67,158.54 ; v2(184.27,155.12) U23.8 ; C194.1 184.63,161.52 184.63,160.45 184.77,160.32 U23.30 ; C192.1 179.18,159.11 179.75,158.54 U23.39 ; U23.1 180.77,155.45 v2(180.5,155.18) ; v2(187.56,155.16) 187.56,155.29 187.27,155.58 U23.14 ; v2(182.27,155.18) U23.4
  TOP w0.406: U24.5 181.38,147.25 C198.1
  TOP w0.508: v2(185.14,161.98) 184.81,161.65 C194.1 ; C188.1 186.87,131.73 v5(186.87,132.57) 186.87,132.9 186.49,133.28 R181.1 185.46,133.28 v2(185.46,132.54) ; R178.1 174.54,132.4 R176.2 175.16,133.26 v2(175.68,133.79) ; C192.1 v2(178.53,158.36) ; v2(191.3,159.62) 191.17,159.49 C193.1 ; C198.1 v2(180.58,147.31) ; R172.1 R171.1 v2(177.01,145.85)
  IN2 w0.508: v2(175.68,133.79) 176.55,132.92 185.19,132.92 185.46,132.65 v2(185.46,132.54)
  IN3 w0.508: v2(175.68,133.79) 175.11,134.36 175.11,136.52 176.12,137.53 176.12,144.96 v2(177.01,145.85)
  IN3 w1.016: 304.01,167.44 304.01,171.19 301.73,173.47 242.18,173.47 240.69,171.98 228.86,171.98 227.66,170.78 219.15,170.78 213.88,165.52 205.23,165.52 202.86,167.89 200.7,167.89 200,168.58
  BOTTOM w0.508: v2(180.58,147.31) 180.58,146.15 179.52,145.09 177.77,145.09 v2(177.01,145.85) ; C206.1 184.25,155.14 v2(184.27,155.12)
  vias: v2(198.73,169.85) v2(198.73,169.22) v2(199.36,169.22) v2(304.65,166.87) v2(305.28,166.87)
+3.3V_LAN_OUT: length 6.6
  TOP w0.102: C182.1 185.86,136.41 v5(186.74,136.41)
  TOP w0.203: U21.29 179.3,142.43 v2(179.42,142.55) ; v2(182.53,137.09) 182.38,137.24 U21.15
  TOP w0.254: v2(182.54,138.84) U21.19
  TOP w0.508: v2(184.57,134.67) R181.2 185.46,135.63 C182.1
  vias: v2(177.45,134.61) v2(178.09,134.67)
+3.3V_M: length 271.6
  TOP w0.508: v2(142.85,81.65) 147.67,81.65 148.88,82.86 153.9,82.86 155.29,81.46 156.06,81.46 157.81,79.71 v1(158.99,79.71) 159.05,79.71 160.45,78.31 160.45,76.31 161.55,75.21 v2(161.73,75.21) ; v2(116.18,79.81) 116.18,79.11 116.81,78.48 116.81,77.43 117.89,76.35 117.89,73.84
  IN1 w1.016: 32.74,17.01 33.63,17.01 35.47,15.17 39.98,15.17 42.84,12.31 45.76,12.31 46.46,13.01 70.9,13.01 71.98,14.09 82.59,14.09 83.67,15.17
  IN2 w0.508: v2(26.64,11.93) 26.64,13.05 30.39,16.79 30.39,17.2 ; v2(161.73,75.21) 161.86,75.08 161.86,67.38 158.23,63.75 158.23,50.7 157.09,49.56 157.09,18.7 151.36,12.97 130.69,12.97 128.62,15.04 123.07,15.04 118.44,10.41 115.54,10.41 112.7,13.25 110.66,13.25 109.81,14.1 103.93,14.1 102.91,13.07 98.06,13.07 95.64,15.49 85.76,15.49 v2(84.94,16.31)
  IN3 w0.508: v2(116.18,79.81) 116.18,79.43 117.02,78.59 121.94,78.59 123,79.65 129.45,79.65 130.11,78.99 130.4,78.99 131.34,78.05 137.02,78.05 139.99,81.02 141.01,81.02 141.64,81.65 v2(142.85,81.65)
  BOTTOM w0.254: UC1.Y8 117.34,62.63 v2(117.16,62.8) ; JTAA1.4 29.63,24.18 v2(29.95,23.87) ; JTAA1.2 29.43,23.68 29.88,23.23 v2(29.95,23.23)
  BOTTOM w0.508: v2(26.64,11.93) 26.63,11.92 C6.1 25.26,11.92 25.18,11.99 U2.8 ; v2(119.8,71.56) 119.81,71.57 R2.1 R1.1 ; U1.8 30.71,15.8 30.28,16.23 C5.1 30.71,17.58 v2(31.09,17.2)
  vias: v2(31.79,17.2) v2(84.37,15.87)
+3.3V_PCIE_WWAN: length 25.6
  TOP w0.508: C249.1 v2(218.03,141.15) ; v2(217.84,129.28) 218.21,129.65 C250.1 C252.1
  IN2 w0.508: v2(224.15,144.57) 218.23,144.57 v2(217.4,145.41)
  BOTTOM w0.381: R226.2 225.26,149.74 225.46,149.53 Q30.5 ; R226.2 223.34,149.74 R480.2 ; R226.2 224.7,150.11 224,150.8 224,151.51 223.4,152.11 221.61,152.11 220.95,152.77
  BOTTOM w0.508: v2(224.15,144.57) 224.15,144.76 223.57,145.34 R217.1 ; 218.38,141.5 JMINI2.24 222.32,141.5 223,142.18 R216.1
  vias: v2(213.08,148.14) v2(213.08,147.5) v2(215.68,135.25) v2(216.19,136.96) v2(216.19,136.33) v2(216.19,135.69) v2(216.83,136.96) v2(216.83,136.33) v2(219.75,155.88) v2(219.75,155.25) v2(220.38,155.88) v2(220.38,155.25) v5(214.77,134.98)
+3.3V_RUN: length 697.1
  TOP w0.203: U39.4 158.37,149.76 158.53,149.6 C2990.1
  TOP w0.254: C2988.1 159.12,155.9 158.77,155.55 U39.23 ; U83.1 298.7,167.3 298.46,167.07 297.76,167.07 297.34,166.65 297.34,166.11 ; U83.13 301.2,172.5 301.7,173.01 301.94,173.01 302.6,173.67 C2972.1 ; JLVDS1.38 94.65,121.92 v2(94.41,122.17)
  TOP w0.305: JPWR1.3 282.05,166.12 v2(282.74,165.43) ; v2(16.48,103.37) 16.48,104.39 15.98,104.89 15.15,104.89 14.83,104.58 R473.1
  TOP w0.381: C338.1 218.46,136.33 218.27,136.14 U30.5 ; v2(115.8,94.61) 115.54,94.86 R55.2 R69.2 ; U11.14 145.66,144.91 145.38,144.63 C93.1 ; Q122.5 16.74,103.37 16.74,103.37 v2(16.48,103.37) ; v2(163.36,127.12) 163.03,127.45 R123.1 162.66,127.56 163.25,128.15 R122.1 ; C97.1 151.25,147.31 U13.14 ; v2(19.79,103.37) 19.79,103.37 Q122.2
  TOP w0.432: v2(121.25,79.57) 121.25,79.98 122.59,81.33 122.59,81.99 122.23,82.35 QC1.5 ; v2(119.29,82.16) 119.48,82.35 QC1.2
  TOP w0.457: R358.1 v2(142.09,90.48) R362.1 ; RC146.1 110.59,92.02 110.67,92.1 110.67,93.97 110.82,94.12 v2(110.91,94.12) ; R475.2 23.08,94.01 23.47,93.62 QZ22.2 23.47,92.65 24.99,92.65 R460.1
  TOP w0.508: v2(140.99,81.91) 138.21,81.91 137.34,82.78 136.38,82.78 135.8,83.37 v2(135.8,83.45) 135.8,83.62 135.45,83.97 134.73,83.97 134.42,83.66 RC38.2 ; 23.47,92.65 22.95,92.13 v2(20.23,92.13) ; v2(186.66,94.73) 185.27,94.73 183.62,96.38 181.42,96.38 180.27,95.24 R304.1 ; v2(101.62,26.79) 101.5,26.66 101.5,21.43 102.21,20.72 102.21,18.86 101.67,18.32 99.08,18.32 99.07,18.33 ; v2(100.68,86.4) R64.1 R65.1 95.92,86.4 95.62,86.71 C34.1 95.62,88.37 95.35,88.64 U7.8 ; v2(303.3,174.22) 303.26,174.22 302.88,173.84 C2972.1 ; C2988.1 159.12,156.44 v2(158.91,156.65) ; R2636.1 299.94,174.94 v2(299.45,175.43) 299.05,175.02 R2634.1 ; RC146.1 RC292.1 ; CD61.1 161.21,70.43 v2(160.9,70.12) ; CD61.1 RD10.2 162.27,69.03 163.23,68.06 171.99,68.06 172.93,68.99 v2(172.93,71.54) 172.93,71.86 CD25.1 CD24.1 ; CD61.1 CD60.1 ; R35.1 R408.1 155.37,106.35 v2(155.47,106.26) ; v2(255.24,170.3) 255.24,163.31 255.82,162.74 258.74,162.74 259.69,161.79 259.69,157.34 258.8,156.46 252.32,156.46 250.99,157.79 246.8,157.79 246.29,157.28 v2(246.29,156.9) ; C97.1 R161.2 v2(150.47,146.42) ; C2990.1 157.96,149.04 157.81,149.19 v2(157.63,149.19) ; C338.1 218.46,137.46 218.92,137.91 218.92,139.12 v2(217.46,140.58) ; v2(297.5,175.46) 297.28,175.25 R2637.1 ; v2(131.62,121.77) 132.78,121.77 R360.1 ; R376.1 155.04,97.08 v2(155.2,96.92) ; R419.1 R484.1 164.18,107.37 164.18,107.37 164.69,107.88 v2(165.2,107.88) ; v2(94.33,143.95) 96.56,143.95 96.86,143.64 C440.1 98.26,143.64 98.86,143.04 Q126.3 ; v2(186.21,96.94) C268.1 186.95,96.97 JBIO1.1 ; R556.1 v2(161.71,148.45) ; C93.1 v2(144.31,143.95) ; R126.1 v2(86.65,107.94) ; R2633.1 301.71,174.94 v2(301.23,175.43) 300.82,175.02 R2635.1 ; R164.2 v2(152.82,149.79)
  TOP w1.524: 55.25,18.3 55.27,18.29 55.27,16.07 58.71,12.63 76.75,12.63 ; 45.25,18.09 42.7,18.09 39.01,21.77 27.66,21.77 26.01,23.42 22.77,23.42 20.64,21.3 17.15,21.3
  IN1 w0.381: 84.3,12.37 84.68,11.99
  IN1 w0.508: v2(50.52,34.41) 52.2,34.41 53.89,32.72 53.89,24.34 57.24,20.99 v2(57.22,20.99) ; v2(142.09,90.48) 142.09,90.38 140.61,88.91 140.01,88.91 137.27,86.18 137.27,85.16 135.8,83.68 v2(135.8,83.45) ; v2(109.74,5.36) 109.74,11.41 109.16,11.99 v2(109.16,12.27) ; v2(172.93,71.54) 172.93,72.04 173.24,72.36 178.12,72.36 178.98,71.49 181.18,71.49 181.84,72.16 181.84,73.98 182.59,74.73 v2(184.31,74.73) ; 98.16,14.65 98.16,12.65 100.54,10.27 100.54,6.22 101.13,5.63 v2(101.7,5.63)
  IN1 w1.27: 18.26,76.51 18.26,72.83 16.67,71.24 16.67,66.98
  IN1 w1.524: 98.08,15.8 92.75,15.8 88.94,11.99 84.68,11.99
  IN2 w0.508: v2(101.62,26.79) 101.32,27.09 101.32,29.46 100.43,30.35 100.43,41.67 101.51,42.75 101.51,55.45 98.04,58.92 95.73,58.92 95.16,59.49 95.16,64.28 v2(94.33,65.1) ; 156.63,106.8 162.03,106.8 162.79,107.56 163.74,107.56 164.06,107.88 v2(165.2,107.88) ; v2(119.65,77.5) 120.31,77.5 121.25,78.44 v2(121.25,79.57) 121.25,80.27 119.35,82.16 v2(119.29,82.16) ; v2(109.74,5.36) 108.23,5.36 107.14,4.27 v2(104.79,4.27) 102.77,4.27 101.7,5.34 v2(101.7,5.63) ; v2(186.66,94.73) 186.66,90.48 185.71,89.53 185.71,75.96 184.48,74.73 v2(184.31,74.73) ; v2(217.46,140.58) 217.46,140.59 216.45,141.61 216.45,145.66 v2(217.97,147.18)
  IN2 w1.016: 254.35,171.19 243.81,171.19 243.05,170.43 234.27,170.43 223.62,159.77 223.62,156.26 222.03,154.68 222.03,151.76
  IN2 w2.54: 5.63,43.81 17.63,55.81 17.63,63.94
  IN3 w0.508: v2(131.62,121.77) 131.42,121.58 131.42,115.64 130.89,115.1 130.89,111.24 131.38,110.75 v2(131.66,110.75) ; v2(186.21,96.94) 187.54,98.28 187.54,106.15 188.85,107.45 188.85,110.8 185.66,113.98 185.66,115.85 181.85,119.66 181.85,124.97 180.91,125.91 v2(180.22,125.91) ; v2(155.2,96.92) 155.2,97.9 155.75,98.45 155.75,101.59 155.07,102.27 155.07,105.86 v2(155.47,106.26) ; v2(121.25,79.57) 121.97,79.57 122.68,80.28 129.78,80.28 130.44,79.62 130.68,79.62 131.61,78.69 136.65,78.69 139.65,81.69 140.78,81.69 v2(140.99,81.91) ; v2(50.58,38.15) 51.22,37.52 51.22,35.11 v2(50.52,34.41) 52.93,34.41 53.95,33.39 62.27,33.39 v2(62.84,33.96)
  IN3 w1.016: 98.97,87.81 98.88,87.9 90.49,87.9 88.94,86.35 84.48,86.35 83.64,87.19
  BOTTOM w0.203: PU300.20 48.05,18.14 v2(47.85,18.34) 48.05,18.54 PU300.21 ; U27.42 16.06,28.71
  BOTTOM w0.254: CC41.1 108.99,13.53 108.78,13.74 108.46,13.74 108.21,13.99 UC6.14 ; v2(115.54,61.09) 115.25,61.38 UC1.T9 115.7,62.63 UC1.U8 ; RP14.2 128.95,80.95 128.75,81.14 128.12,81.14 126.59,79.62 121.3,79.62 v2(121.25,79.57) ; UC1.K16 UC1.K14 v2(114.21,59.37) ; v2(116.2,62.83) 116.41,62.63 UC1.V8 116.68,62.59 117.09,62.18 UC1.W9
  BOTTOM w0.356: v2(160.9,70.12) 160.93,70.15 JDIMM2.199 ; v2(172.93,71.54) 172.93,71.2 173.97,70.15 JDIMM1.199
  BOTTOM w0.381: RC12.2 122.15,74.36 122.15,74.86 v2(122.15,74.86) 122.15,74.86 122.15,75.42 RC291.1 ; v2(140.99,81.91) 140.69,81.91 138.9,80.12 CC9.1 138.21,79.54 UC3.5 ; 120.12,74.92 120.12,74.92 RC222.1 ; 120.12,74.92 v2(119.99,74.92) ; 120.12,74.92 120.12,74.92 RC138.1 ; 16.06,28.71 16.34,28.71 16.61,28.44 C210.1 ; UC2.5 107.84,79.88 CC8.1 ; v2(115.8,94.61) 113.83,94.61 113.45,94.99 111.77,94.99 v2(110.91,94.12) 108.72,91.94 108.72,87.06 109.17,86.61 109.17,84.74 108.81,84.38
  BOTTOM w0.406: C414.1 101.32,4.28 101.7,4.66 U93.5 v2(101.7,5.63)
  BOTTOM w0.508: v2(111.7,74.84) 111.7,74.27 RC183.1 ; RC289.1 104.86,71.44 103.03,73.27 101.95,73.27 101.53,72.85 101.53,70.98 102.1,70.41 RC283.1 RC285.1 ; R170.1 104.79,4.89 v2(104.79,4.27) 104.79,3.4 104.48,3.1 R168.1 ; R150.1 v2(246.29,156.9) ; RC170.2 121.07,76.64 120.49,77.22 120.34,77.22 120.07,77.5 v2(119.65,77.5) ; v2(109.16,12.27) 109.07,12.36 109.07,12.93 CC41.1 ; v2(115.16,74.66) 115.48,74.34 RC148.1 ; PR600.1 62.52,33.39 62.84,33.71 v2(62.84,33.96) 62.52,34.28 PR603.1 ; C210.1 16.98,29.06 v2(16.99,29.07) ; v2(282.74,165.43) 282.73,165.42 C1189.1 ; PR628.2 v2(50.52,34.41) ; CC8.1 v2(107.91,79.18) ; v2(186.21,96.94) 186.21,95.19 v2(186.66,94.73) ; L35.1 14.88,19.72 v2(14.9,19.74) ; RC259.1 101.5,26.91 v2(101.62,26.79) ; v2(50.58,38.15) PR626.1 ; v2(100.67,82.84) 100.71,82.8 100.71,80.78 100.9,80.58 100.9,75.46 v5(98.16,72.72) 95.53,70.08 RC149.1 95.53,69.39 RC147.1 95.29,68.51 94.53,67.75 94.02,67.75 93.57,67.3 93.57,65.87 v2(94.33,65.1) ; v2(150.47,146.42) 150.41,146.42 149.26,145.28 145.64,145.28 v2(144.31,143.95) ; RC222.1 RC11.2
  vias: v2(4.29,29.46) v2(4.84,35.77) v2(4.82,35.15) v2(4.93,29.46) v2(5.31,27.36) v2(5.31,26.72) v2(5.45,35.78) v2(5.43,35.18) v2(7.09,21.71) v2(16.36,65.9) v2(16.67,65.33) v2(16.99,65.9) v2(17.88,78.03) v2(18.2,77.46) v2(18.52,78.03) v2(28.61,104.07) v2(28.61,103.43) v2(29.25,104.07) v2(29.25,103.43) v2(29.88,103.43) v2(56.51,19.7) v2(63.76,107.54) v2(64.32,107.87) v2(64.31,107.26) v2(64.91,107.87) v2(64.9,107.28) v2(73.38,103.81) v2(73.38,103.18) v2(74.01,103.81) v2(74.01,103.18) v2(79.22,12.12) v2(79.86,12.12) v2(80.49,12.12) v2(80.68,87.75) v2(80.68,87.11) v2(81.32,87.75) v2(81.32,87.11) v2(93.13,108.7) v2(93.13,108.07) v2(93.76,108.7) v2(97.44,17.77) v2(98.05,17.77) v2(101.32,86.41) v2(101.95,82.73) v2(102.59,82.73) v2(105.26,101.97) v2(105.26,101.34) v2(108.49,82.73) v2(109.07,72.57) v2(109.45,73.08) v2(111.04,106.54) v2(111.04,105.91) v2(111.61,110.54) v2(111.61,109.91) v2(112.43,79.53) v2(113.21,76.15) v2(117.19,76.19) v2(155.23,152.9) v2(155.23,150.87) v2(156.97,97.71) v2(156.97,97.13) v2(159.36,118.23) v2(162.22,120.77) v2(167.23,153.09) v2(167.23,151.95) v2(167.42,152.52) v2(170.09,140.27) v2(170.37,139.7) v2(170.41,138.48) v2(179.62,125.91) v2(220.95,149.66) v2(220.95,149.03) v2(221.59,150.3) v2(221.59,149.66) v2(221.59,149.03) v2(222.22,150.3) v2(222.22,149.66) v2(222.22,149.03) v2(295.95,166.3) v2(296.65,166.3) v2(298.23,164.07) v2(299.44,164.07)
+3.3V_RUN_AIN: length 13.1
  BOTTOM w0.203: U27.27 10.76,32.1 10.58,32.28 10.58,33.01 11.02,33.46 11.02,34.14 C215.1 ; U27.9 11.16,24.67 10.39,23.89 10.39,23.16 C214.1
  BOTTOM w0.381: v2(10.45,33.58) 10.45,34.2 C215.1
  BOTTOM w0.508: C214.1 v2(9.83,21.91) 10.73,21.01 v1(11.37,21.01) C213.1 14.06,21.01 14.07,21.02 L35.2
+3.3V_RUN_AUDIO: length 22.7
  TOP w0.102: v5(254.63,169.55) 253.99,168.9 C145.1
  TOP w0.508: v2(245.46,154.68) 245.46,157.6 246.42,158.55 251.94,158.55 252.07,158.68
  BOTTOM w0.254: U17.9 256.68,156.92 256.58,157.03 256.58,157.6 257.09,158.11 ; U17.3 253.68,156.98 253.27,157.38 C120.1
  BOTTOM w0.508: v2(245.46,154.68) 245.46,153.15 L37.2 ; C120.1 253.07,158.61 C118.1 252.32,158.8 251.94,159.18 v2(251.94,159.76)
  vias: v2(257.85,159.12) v2(258.48,159.12)
+3.3V_RUN_CARD: length 39.5
  TOP w0.102: v2(33.88,52.89) v5(33.1,52.89)
  IN2 w1.016: 33.12,52.19 32.14,51.2 23.5,51.2 16.42,44.12 16.42,38.47 12.61,34.66 10.13,34.66 9.37,33.9 9.37,31.36 8.29,30.28
  vias: v2(6.84,29.85) v2(7.46,29.85) v2(33.88,53.52)
+3.3V_RUN_FFS: length 13.4
  TOP w0.102: C102.1 162.74,125.3 164.22,125.3 v1(164.24,125.31)
  IN3 w0.508: v2(161.07,124.07) 161.07,123.69 160.5,123.12 157.9,123.12 156.76,124.26 156.76,127.56 157.52,128.32 v2(159.49,128.32)
+3.3V_RUN_TPM: length 23.9
  TOP w0.381: v2(162.38,114.68) U25.5 ; U25.24 162.38,108.37 C202.1 ; C384.1 159.13,108.23 U25.19
  TOP w0.457: C202.1 161.71,108.21 v2(161.57,108.07)
  TOP w0.508: C204.1 156.72,117.33 v1(156.6,117.44) ; v2(159.73,108.14) C384.1 C203.1
  IN2 w0.457: v2(159.73,108.14) 161.5,108.14 v2(161.57,108.07)
  IN2 w0.508: v2(161.2,117.4) 162.38,116.22 v2(162.38,114.68) ; v2(159.36,117.28) 159.29,117.21 159.29,113.83 158.28,112.81 158.28,110.55 159.17,109.66 159.17,108.58 159.6,108.14 v2(159.73,108.14)
+3.3V_RUN_VDDA: length 3
  TOP w0.203: U6.H12 v4(122.04,107.68) ; U6.H5 v4(122.04,102.48) ; U6.K6 v4(123.34,103.13) ; U6.K7 v4(123.34,103.78) ; U6.C10 v4(118.14,106.38)
  TOP w0.508: C13.1 122.34,111.5 v2(122.34,111.5)
  vias: v1(125.88,111.1) v2(126.4,111.62) v2(126.4,111.04) v4(124.75,103.13)
+3.3V_RUN_VDDIO: length 4.1
  TOP w0.203: U6.C12 v4(118.14,107.68) ; U6.C4 v4(118.14,101.83) ; U6.K4 123.01,102.16 v4(122.69,101.83) U6.J4 ; U6.K3 v4(123.34,101.18) ; U6.K12 v4(123.34,107.68) ; U6.C3 v4(118.14,101.18) ; U6.K11 v4(123.34,107.03) ; U6.C11 v4(118.14,107.03)
  vias: v1(115.43,110.24) v2(116.62,110.74) v2(116.94,111.31)
+3.3V_SUS: length 152.9
  TOP w0.102: v5(80.77,25.61) 80.99,25.39 v2(81.44,25.39)
  TOP w0.254: RP15.6 131.93,109.14 v2(131.67,109.4) 131.91,109.64 RP15.5
  IN2 w0.508: v2(131.67,109.4) 131.04,109.4 128.46,106.82 128.46,100.61 126.46,98.61 124.41,98.61 122.71,96.9 114.92,96.9 113.89,95.88 111.8,95.88 111.35,96.32 99.41,96.32 97.32,94.23 90.27,94.23 86.85,90.8 86.85,89.62 86,88.77 84.82,88.77 84.37,88.32 84.37,78.86 85.67,77.55 85.67,76.16 85.35,75.84 84.39,75.84 83.9,75.34 83.9,66.07 83.48,65.65 83.48,64 84.3,63.17 84.3,56.57 86.65,54.22 86.65,49.84 85.83,49.01 85.83,43.68 84.11,41.96 84.11,34.92 83.1,33.9 81.7,33.9 80.75,32.95 80.75,26.09 v2(81.44,25.39)
  IN3 w0.508: v2(81.44,25.39) 82.69,24.15 89.22,24.15 90.52,25.45 92.62,25.45
  BOTTOM w1.016: 88.94,18.91 89.51,19.49 89.51,21.96 91.44,23.89 93.13,23.89
  vias: v2(93.06,24.95) v2(93.65,24.95)
+3.3V_TP: length 49.8
  TOP w0.102: PJP8.2 145.41,88.59 144.94,88.12 144.75,88.12 v5(144.44,87.8)
  TOP w0.305: JTP1.4 151.68,93.14
  TOP w0.508: R404.1 181,100.13 v2(180.62,99.75) 180.24,100.13 R405.1 ; C374.1 148.16,89.78 148.86,90.48 v2(150.57,90.48) 151.68,91.59 151.68,93.14
  IN2 w0.508: v2(180.62,99.75) 180.16,99.75 179.22,98.81 175.93,98.81 174.68,97.56 173.35,97.56 172.88,97.1 172.88,93.96 171.84,92.91 163.12,92.91 162.48,92.27 160.83,92.27 160.47,91.91 158.88,91.91 158.52,92.27 154.36,92.27 153.44,91.36 151.64,91.36 150.76,90.48 v2(150.57,90.48)
+3.3V_USBHUB: length 7.4
  TOP w0.254: U90.5 176.82,121.4 177.1,121.68 177.57,121.68
  TOP w0.381: R2700.2 166.08,117.96 v2(166.09,117.97)
  TOP w0.432: v2(168.44,124.58) QC4.2
  TOP w0.508: 177.57,121.68 178.71,122.83 C3024.1 ; R2701.2 v2(166.09,117.97)
  vias: v1(168.19,127.97) v2(167.04,121.85) v2(170.73,126.48) v2(170.73,125.85) v2(170.79,117.15) v2(174.79,125.53) v2(175.23,125.98) v2(176,117.85)
+3.3V_VTR:
  vias: v1(151.93,102.44)
+3.3V_VTR_ADC:
  vias: v1(138.21,103.17)
+3.3V_WLAN: length 5.2
  BOTTOM w0.381: Q30.2 228.07,149.53 228.33,149.27 R229.2 229.07,149.27 229.34,149.53 v2(229.34,150.11) ; v2(226.58,152.01) 226.61,152.01 226.48,152.14 Q22.2 224.84,152.14 R227.2
  BOTTOM w0.508: R233.2 282.04,160.53 v2(282.04,160.96)
  vias: v2(274.04,150.42) v2(274.67,150.42) v2(280.77,161.6) v2(280.77,160.96) v2(281.41,161.6) v2(281.41,160.96) v2(282.04,161.6) v2(292.77,155.57) v2(293.38,155.57) v2(298.55,149.6) v2(298.55,148.96) v3(228.57,153.6) v3(228.57,152.9) v3(229.27,153.6) v3(229.27,152.9) v3(229.97,153.6) v3(229.97,152.9) v5(219.32,143.96)
+5V_ALW: length 351.2
  TOP w0.203: PU100.12 174.77,79.85 174.54,79.62 174.54,79.13 ; U51.4 v2(209.52,138.04) ; U18.4 v2(250.61,172.11)
  TOP w0.254: U46.4 214.48,150.61 v2(214.41,150.55)
  TOP w0.305: v2(284.12,165.42) 283.05,166.5 JPWR1.1
  TOP w0.381: v2(124.31,119.48) 124.73,119.48 125.07,119.82 PU1.5 ; PR11.1 120.67,122.47 v2(121,122.8) 121,122.74 121.93,121.81 122.39,121.81 122.87,121.32 PD5.3
  TOP w0.457: C73.1 94.07,78.04 U94.3
  TOP w0.508: C73.1 v2(93.9,77.14) ; v2(191.24,124.58) 187.68,124.58 v2(184.57,127.69) ; v2(145.26,119.82) 145.26,119.94 144.89,120.31 R411.1 ; PR536.2 119.21,145.24 v2(119.09,145.24) ; U33.5 v2(92.81,98.48) ; Q16.3 v2(178.11,5.9) ; PR435.1 114.15,117.47 v2(114.02,117.34) ; R28.1 v2(193.08,38.85) ; 174.54,79.13 174.54,78.65 PR102.1 175.38,78.11 PC107.2 177,78.11 177.2,77.9 177.2,76.15 v2(177.77,75.58) ; U22.5 196.7,167.63 196.32,168.01 196.32,169.03 198.32,171.03 201.62,171.03 202.35,170.3 202.35,169.03 205.52,165.85 205.52,161.85 ; v2(155.1,79.24) 155.09,79.25 PC151.2 ; PU404.8 v2(108.43,121.47) PC429.1 PC428.1 ; 92.59,85.77 93.81,84.54 R109.1 ; U34.5 v2(87.54,110.35)
  IN1 w0.508: v2(145.26,119.82) 145.49,119.59 148.82,119.59 158.25,129.02 170.85,129.02 171.48,128.4 174.91,128.4 175.61,127.69 v2(184.57,127.69) ; v2(213.78,151.63) 212.67,151.63 211.07,150.03 211.07,141.95 210.21,141.09 210.21,138.85 209.52,138.17 v2(209.52,138.04)
  IN2 w0.508: v2(108.43,121.47) 106.72,123.18 100.43,123.18 100.05,123.56 93.45,123.56 88.3,118.42 88.3,111.12 v2(87.54,110.35) ; v2(121,122.8) 121,128.26 122.43,129.68 122.43,142.65 119.84,145.24 v2(119.09,145.24) ; v2(92.81,98.48) 85.83,91.49 85,91.49 83.69,90.19 83.69,86.62 v2(83.22,86.15) ; v2(145.26,119.82) 145.26,119.46 144.59,118.79 140.32,118.79 138.81,120.3 136.79,120.3 134.74,118.24 v2(132.85,118.24)
  IN3 w0.508: v2(36.37,34.33) 38.87,34.33 40.16,35.61 49.12,35.61 v2(49.38,35.87) 49.38,36.95 48.98,37.34 48.02,37.34 47.56,37.8 47.56,39.32 48.3,40.06 55.35,40.06 55.73,40.44 v2(55.73,41.96) ; v2(155.1,79.24) 158.19,79.24 159.16,78.26 159.16,76.12 159.68,75.6 159.68,74.65 160.02,74.31 161.81,74.31 163.23,75.73 171.63,75.73 172.45,74.9 176.35,74.9 177.03,75.58 v2(177.77,75.58) 178.73,74.63 178.73,72.76 179.3,72.19 180.15,72.19 v2(180.75,72.79) ; v2(124.31,119.48) 124.31,120.83 122.34,122.8 v2(121,122.8) ; v2(93.9,77.14) 93.54,77.14 92.74,76.34 90.94,76.34 88.21,73.62 v2(88.21,73.22) 87.7,73.22 87.22,73.7 v2(80.63,73.7)
  BOTTOM w0.127: v2(93.9,77.14) 93.87,77.14 v5(93.22,76.49) ; v2(79.86,74.35) 79.86,74.82 v5(80.09,75.05)
  BOTTOM w0.203: v2(155.1,79.24) 155.02,79.32 PU150.18 ; v2(85.11,22.38) 85.11,21.94 86.46,20.59 U45.4 ; U19.4 v2(83.22,86.15)
  BOTTOM w0.508: v2(132.85,118.24) 132.85,118.26 130.71,116.12 126.52,116.12 124.31,118.33 v2(124.31,119.48) ; C1188.1 v2(284.12,165.42) ; v2(121,122.8) 109.57,122.8 108.43,121.66 v2(108.43,121.47) 108.43,120.32 109.07,119.69 110.72,119.69 111.42,118.99 111.42,118.04 112.11,117.34 v2(114.02,117.34) ; v2(155.1,79.24) 155.22,79.12 PR150.1 ; PR327.1 48.36,24.44 48.04,24.76 40.22,24.76 39.39,25.58 v5(38.87,25.58) v2(37.69,25.58) ; v2(55.73,41.96) PR617.2 ; PR711.2 v2(36.37,34.33)
  vias: v2(24.61,67.43) v2(24.61,66.79) v2(25.25,67.43) v2(25.25,66.79) v2(30.11,47.11) v2(30.11,46.52) v2(79.22,74.35) v2(79.41,73.77) v2(80.01,73.72) v2(80.49,74.35) v2(153.02,5.4) v2(153.02,4.77) v2(153.66,5.4) v2(153.66,4.77) v2(154.28,5.39) v2(154.28,4.75) v2(183.3,4.63) v2(183.93,4.63) v2(188.95,20.12) v2(189.1,6.42) v2(189.1,5.78) v2(189.1,5.15) v2(189.27,19.55) v2(189.58,20.12) v2(189.74,6.42) v2(189.74,5.78) v2(189.74,5.15) v2(213.78,152.26) v2(214.41,152.26) v2(214.41,151.63) v2(220.7,169.16) v2(220.7,168.52) v2(220.7,167.89) v2(221.35,169.15) v2(221.35,168.52) v2(221.35,167.88) v2(221.97,169.79) v2(221.97,169.15) v2(221.97,168.52) v2(221.97,167.88) v2(222.6,169.79) v2(222.6,169.16) v2(222.6,168.52) v2(222.6,167.89) v2(247.75,172.15) v2(248.36,172.15) v2(248.98,172.14) v2(249.59,172.14) v3(312.01,166.11) v3(312.08,167.5) v3(312.08,166.81) v3(312.65,167.12) v3(312.58,166.42)
