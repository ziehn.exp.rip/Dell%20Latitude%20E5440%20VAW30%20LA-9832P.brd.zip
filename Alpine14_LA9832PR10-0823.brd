# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.05V_RUN on TOP (solid shape): 122.08,57.92 122.08,57.62 121.84,57.38 121.43,57.26 121.48,56.83 121.51,56.72 121.41,56.65 120.83,56.65 120.56,56.93 120.49,56.93 120.47,56.94 120.29,56.98 120.12,56.93 119.53,56.93 119.4,56.8 119.37,56.79 119.33,56.8 119,56.89 118.7,56.55 118.6,56.58 118.44,56.74 118.35,56.81 118.24,56.84 118.2,56.85 118.2,57.78 118.22,57.8 118.93,57.8 119.19,57.55 120.43,57.55 121.01,58.12 121.88,58.12
+1.05V_RUN on TOP (solid shape): outline of 209 points within 86.84,54.79 95.72,71.81
+1.05V_RUN on TOP (solid shape): outline of 353 points within 110.53,52.32 118.27,60.65
+1.5V_RUN on BOTTOM (solid shape): 260.01,172.52 260.01,172.08 259.43,172.08 259.43,170.68 260.01,170.68 260.01,170.36 259.88,170.23 258.04,170.23 257.69,170.58 257.69,172.36 257.97,172.65 259.88,172.65
+1.5V_RUN on IN1 (solid shape): outline of 412 points within 159.3,130.93 166.03,139.56
+1.5V_RUN on IN1 (solid shape): outline of 460 points within 159.02,103.24 164.63,112.83
+1.5V_RUN on IN2 (solid shape): 97.76,25.96 97.76,24.5 97.7,24.44 96.56,24.44 96.43,24.57 96.43,25.9 96.62,26.09 97.64,26.09
+1.5V_RUN on IN2 (solid shape): 259.18,173.28 259.18,172.08 258.99,171.89 258.04,171.89 257.34,172.58 257.34,173.54 257.4,173.6 258.86,173.6
+1.5V_RUN on IN2 (solid shape): 163.42,104.45 163.42,102.61 163.2,102.39 163.14,102.39 163.04,102.29 161.14,102.29 160.95,102.48 160.95,103.31 160.98,103.32 161.25,103.66 160.98,104.01 160.95,104.02 160.95,104.21 160.98,104.22 161.14,104.37 161.18,104.59 161.18,104.62 161.39,104.83 163.04,104.83
+1.5V_RUN on IN2 (solid shape): outline of 100 points within 167.11,102.4 169.47,105.88
+1.5V_RUN on IN2 (solid shape): outline of 106 points within 87.41,66.03 89.89,72.95
+1.5V_RUN on IN2 (solid shape): outline of 176 points within 154.91,121.21 162.91,133.98
+1.5V_RUN on IN2 (solid shape): outline of 315 points within 141.96,90.35 156.69,98.54
+1.05V_RUN on IN2 (solid shape): outline of 620 points within 90.14,68.13 105.51,88.83
+1.5V_RUN on IN3 (solid shape): outline of 688 points within 155.29,110.54 162.22,122.61
+1.05V_RUN on VCC: 87.35,54.85 87.35,64.38 88.84,64.38 89.05,64.38 119.75,64.38 120.24,63.89 120.24,62.45 118.97,61.18 118.97,58.43 119.37,58.03 121.79,58.03 122.04,57.78 120.88,56.61 120.88,54.85
+1.5V_RUNP on BOTTOM (solid shape): 272.01,172.97 272.01,171.5 271.69,171.19 266.86,171.19 265.85,170.17 260.26,170.17 260.2,170.23 260.2,172.39 260.26,172.46 265.53,172.46 266.23,173.16 271.82,173.16
+1.5V_THERMAL on IN2 (solid shape): outline of 354 points within 106.97,56.89 112.43,59.11
+1.05V_VCCST on TOP (solid shape): outline of 983 points within 118.46,51.62 138.27,55.36
+1.05V_VMM_VDD on TOP (solid shape): 109.89,102.04 109.89,101.53 110.15,101.27 111.29,101.27 111.67,100.89 113.26,100.89 113.26,99.62 113.13,99.5 110.59,99.5 110.02,100.07 108.81,100.07 108.69,100.19 108.69,102.04 108.81,102.16 109.77,102.16
+1.05V_VMM_VDD on TOP (solid shape): 127.8,105.59 127.8,104.19 127.23,104.19 126.91,104.51 126.91,104.89 126.72,105.08 126.28,105.08 125.32,104.13 124.69,104.13 124.56,104.26 124.56,104.51 124.69,104.64 124.88,104.64 126.08,105.85 127.55,105.85
+1.05V_VMM_VDD on BOTTOM (solid shape): outline of 2236 points within 111.35,98.23 125.96,111.69
+1.05V_VMM_VDDTX on TOP (solid shape): 113.89,99.11 113.89,97.84 110.97,97.84 110.72,97.59 110.02,97.59 110.02,99.05 110.27,99.31 113.7,99.31
+1.05V_VMM_VDDTX on TOP (solid shape): 119.86,111.83 119.29,111.26 119.29,110.23 119.16,110.1 118.72,110.1 118.59,110.23 118.59,111.37 119.16,111.94 119.16,112.39 119.23,112.45 119.86,112.45
+1.05V_VMM_VDDTX on IN2 (solid shape): outline of 2273 points within 111.1,98.04 124.56,112.07
+1.8V_RUN_CARD on BOTTOM (solid shape): 9.55,31.06 9.55,30.7 9.47,30.62 8.74,30.62 8.69,30.67 8.69,31.11 8.36,31.44 8.18,31.44 8.18,31.92 8.69,31.92
+1.35V_MEM on TOP (solid shape): outline of 16253 points within 120.75,29.58 191.12,66.41
+1.35V_MEM on BOTTOM (solid shape): 188,57.59 188,56.95 187.43,56.95 187.43,54.92 188,54.92 188,54.41 187.49,53.9 185.97,53.9 185.84,54.03 185.84,58.03 186.03,58.22 187.36,58.22
+1.35V_MEM on BOTTOM (solid shape): 190.28,36.82 190.98,36.82 191.13,36.67 191.13,33.49 190.97,33.33 187.81,33.33 187.55,33.58 187.55,35.95 188.42,36.82 190.28,36.82
+1.35V_MEN_P on TOP (solid shape): 180.95,83.81 180.95,82.73 180.69,82.48 179.49,82.48 179.36,82.6 179.36,83.87 179.49,84 180.76,84
+1.35V_MEN_P on TOP (solid shape): 193.2,65.14 193.2,58.08 193.06,57.94 191.94,57.14 191.09,56.06 188.44,56.06 188.19,56.32 188.19,61.4 187.17,62.41 187.17,65.4 187.3,65.52 192.82,65.52
+1.35V_MEN_P on BOTTOM (solid shape): 193.46,64.89 193.46,58.54 192.57,57.65 192.02,57.65 190.21,55.83 190.21,51.49 190.93,50.77 190.93,47.38 190.65,47.1 188.33,47.1 187.42,48.01 187.42,53.46 188.19,54.22 188.19,57.71 187.42,58.48 187.42,65.14 187.68,65.4 192.95,65.4
+1.35V_MEN_P on IN3 (solid shape): 192.32,62.09 192.12,61.9 191.49,61.9 191.3,62.09 191.3,64.32 192.32,64.32
+1.35V_MEN_P on IN3 (solid shape): 182.1,84.34 182.1,83.85 181.31,83.06 180.02,83.06 179.74,83.34 179.74,83.75 179.93,83.94 180.4,83.94 181.27,84.81 181.63,84.81
+3.3V_ALW on TOP (solid shape): 148.63,125.91 148.63,123.32 148.32,123.01 147.12,123.01 146.72,123.4 146.72,125.72 146.97,125.97 148.56,125.97
+3.3V_ALW on TOP (solid shape): 210.67,140.07 210.67,138.8 210.6,138.74 208.83,138.74 208.63,138.93 208.63,140.45 208.83,140.64 210.1,140.64
+3.3V_ALW on TOP (solid shape): 210.67,137.28 210.67,136.33 209.59,135.25 208.7,135.25 208.44,135.5 208.44,136.14 208.63,136.33 208.63,137.21 208.76,137.34 210.6,137.34
+3.3V_ALW on TOP (solid shape): 131.83,108.89 131.87,108.89 131.99,108.77 132.63,108.77 132.69,108.7 132.69,104.83 133.39,104.13 133.39,103.56 132.31,103.56 132.12,103.75 132.12,104.39 131.42,105.08 131.42,108.77 131.55,108.89 131.82,108.89
+3.3V_ALW on TOP (solid shape): 198.22,133.4 198.47,133.4 198.73,133.15 198.73,132.26 198.16,132.26 198.16,130.23 198.73,130.23 198.73,129.4 198.47,129.15 194.41,129.15 193.9,129.66 193.9,134.1 194.35,134.55 197.08,134.55
+3.3V_ALW on TOP (solid shape): 259.12,170.36 259.12,166.93 258.86,166.68 256.77,166.68 256.39,167.06 256.39,170.04 255.62,170.81 251.37,170.81 251.31,170.87 251.31,172.2 252.13,173.03 256.45,173.03
+3.3V_ALW on TOP (solid shape): 91,76.72 91,76.09 90.72,75.81 90.02,75.81 89.83,75.62 89.83,73.27 89.76,73.21 89.24,73.21 89.06,73.39 88.24,74.21 88.24,76.76 88.34,76.86 90.86,76.86
+3.3V_ALW on TOP (solid shape): 215.75,149.85 215.75,147.88 215.62,147.76 213.71,147.76 213.52,147.95 213.52,148.39 213.02,148.9 213.02,149.72 213.21,149.91 215.68,149.91
+3.3V_ALW on TOP (solid shape): 160.06,88.76 160.57,88.76 160.57,89.34 161.07,89.34 161.33,89.08 161.33,86.61 161.26,86.54 160.31,86.54 160.18,86.67 160.18,88.07 159.61,88.64 159.61,89.22 159.73,89.34 160.06,89.34
+3.3V_ALW on TOP (solid shape): 140.05,114.86 140.05,114.4 140.29,114.16 141.07,114.16 141.13,114.1 141.13,113.59 141.07,113.53 139.61,113.53 139.25,113.89 137.16,113.89 137.06,113.99 137.06,114.89 137.21,115.05 137.96,115.05 138.06,115.15 139.77,115.15
+3.3V_ALW on TOP (solid shape): 148.56,120.45 148.56,119.63 148.75,119.43 150.6,119.43 150.79,119.24 150.79,117.97 150.66,117.85 148.75,117.85 148.74,117.86 148.74,118.39 148.73,118.4 148.27,118.4 148.25,118.39 148.25,117.88 148.21,117.84 147.79,117.84 147.39,118.23 147.39,120.43 147.48,120.51 148.5,120.51
+3.3V_ALW on TOP (solid shape): 91.67,109.59 91.67,108.7 94.02,106.35 94.02,105.4 93.76,105.15 92.94,105.15 92.05,106.04 91.41,106.04 90.14,107.31 90.14,109.4 89.51,110.04 88.87,110.04 88.75,110.16 88.75,110.54 88.87,110.67 89.64,110.67 89.83,110.86 90.4,110.86
+3.3V_ALW on TOP (solid shape): 201.59,167.95 201.59,153.73 204.32,151 204.32,149.85 204.19,149.72 202.98,149.72 202.86,149.85 202.86,150.68 200.32,153.22 200.32,167.12 200.13,167.31 199.36,167.31 199.24,167.44 199.24,167.82 199.36,167.95 199.94,167.95 200.06,168.08 201.46,168.08
+3.3V_ALW on TOP (solid shape): 97.89,98.8 97.89,98.54 98.21,98.23 99.29,98.23 99.6,97.91 99.54,97.74 99.61,97.56 99.61,97.27 99.92,96.96 100.88,96.96 101.07,96.77 101.07,96.26 100.94,96.13 99.41,96.13 99.22,96.32 99.22,96.77 98.91,97.08 97.89,97.08 97.64,96.83 97.64,96.13 97.51,96 96.75,96 96.49,96.26 96.49,97.4 96.18,97.72 95.22,97.72 94.78,98.16 94.08,98.16 94.02,98.23 94.02,98.73 94.08,98.8 95.16,98.8 95.35,98.99 97.7,98.99
+3.3V_ALW on BOTTOM (solid shape): 85.78,20.46 85.78,19.57 85.72,19.52 85.04,19.52 84.84,19.73 84.84,20.77 84.99,20.92 85.32,20.92
+3.3V_ALW on BOTTOM (solid shape): 259.43,168.46 259.43,166.11 259.12,165.79 256.64,165.79 256.32,166.11 256.32,168.01 256.07,168.27 256.07,168.77 259.12,168.77
+3.3V_ALW on BOTTOM (solid shape): 88.8,21.27 88.8,20.11 88.21,19.52 87.22,19.52 87.15,19.6 87.15,20.49 87.3,20.64 87.55,20.64 87.91,21 87.91,21.28 88.02,21.39 88.68,21.39
+3.3V_ALW on IN2 (solid shape): 215.75,149.09 217.02,149.09 217.08,149.03 217.08,148.07 217.02,148.01 213.91,148.01 213.08,148.84 213.08,149.66 213.21,149.79 215.05,149.79
+3.3V_ALW on IN2 (solid shape): 85.76,68.38 85.76,66.98 86.02,66.73 86.02,65.97 85.38,65.97 84.75,66.6 84.75,68.38 84.87,68.51 85.64,68.51
+3.3V_ALW on IN2 (solid shape): 257.72,167.76 259.82,167.76 260.07,167.5 260.07,166.93 256.83,166.93 256.7,167.06 256.7,167.38 256.26,167.82 256.26,168.33 256.32,168.39 257.09,168.39
+3.3V_ALW on IN2 (solid shape): outline of 113 points within 84.75,20.31 88.81,24.38
+3.3V_ALW on IN2 (solid shape): outline of 246 points within 82.27,26.15 91.03,30.66
+3.3V_ALW on VCC: 86.57,64.89 83.92,67.53 83.92,74.39 83.01,75.3 74.14,75.3 74.14,88.02 74.14,89.16 74.14,89.17 74.14,89.38 74.14,89.38 74.14,101.36 78.63,105.85 91.96,105.85 95.22,109.11 95.22,145.3 100.79,150.87 215.01,150.87 217.02,148.86 217.02,142.97 207.64,133.6 201.14,133.6 200.13,132.58 189.35,132.58 180.06,123.29 180.06,71.11 178,71.11 177.79,71.11 177.41,70.73 156.84,70.73 154.81,68.7 148.81,68.7 147.93,67.81 142.87,67.81 142.87,73.65 145.39,73.65 146.28,74.54 146.28,88.76 140.05,94.99 87.35,94.99 86.33,93.97 80.75,93.97 78.08,91.3 78.08,80.15 78.99,79.24 88.69,79.24 88.69,72.19 87.35,70.85 87.35,64.89 ; 1 cut-out
+3.3V_ALW2 on IN3 (solid shape): 142.53,156.46 142.53,156.2 142.72,156.01 143.1,156.01 143.29,156.2 143.29,156.48 143.42,156.61 144.45,156.61 144.93,156.13 144.93,153.2 143.99,152.26 143.99,151.93 143.86,151.8 143.59,151.8 143.23,151.44 142.79,151.44 142.79,151.74 141.39,153.14 141.39,156.46 141.58,156.65 142.34,156.65
+3.3V_ALW_5048 on TOP (solid shape): 160.55,92.45 160.55,90.36 160.82,90.1 160.82,89.53 159.76,89.53 159.4,89.89 159.4,91.85 158.84,92.41 158.84,92.74 159.05,92.95 160.06,92.95
+3.3V_ALW_5048 on IN2 (solid shape): outline of 103 points within 158.66,92.47 164.69,96.38
+3.3V_ALW_5075 on TOP (solid shape): 150.34,117.4 150.34,116.26 150.15,116.07 149.2,116.07 149.07,116.2 149.07,116.45 148.82,116.7 148.18,116.7 147.99,116.89 147.99,117.66 150.09,117.66
+3.3V_ALW_5075 on IN1 (solid shape): 150.41,116.39 150.41,112.39 150.21,112.2 150.21,108.89 150.09,108.77 149.39,108.77 149.2,108.96 149.2,109.85 149.45,110.1 149.45,112.26 149.33,112.39 149.33,115.82 149.07,116.07 149.07,116.45 149.2,116.58 150.21,116.58
+3.3V_ALW_5075 on IN2 (solid shape): outline of 128 points within 137.58,105.66 153.2,111.5
+3.3V_ALW_PCH on TOP (solid shape): 116.5,85.65 116.5,84.83 116.43,84.76 115.29,84.76 115.23,84.83 115.23,85.97 115.42,86.16 115.99,86.16
+3.3V_ALW_PCH on TOP (solid shape): 93.37,75.91 93.37,74.96 93.13,74.72 93.13,74.6 93.1,74.53 93.03,74.5 92.79,74.35 92.81,74.06 92.81,73.71 92.65,73.55 92.61,73.55 92.61,73.51 92.3,73.21 91.16,73.21 91.1,73.27 91.1,75.74 91.32,75.97 93.31,75.97
+3.3V_ALW_PCH on BOTTOM (solid shape): 128.55,72.58 128.55,71.57 128.47,71.49 127.38,71.49 127.3,71.57 127.3,72.08 127.38,72.15 127.43,72.15 128.02,72.74 128.4,72.74
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 83 points within 114.4,78.79 119.99,86.16
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 166 points within 91.32,71.29 100.51,81.49
+3.3V_ALW_PCH on IN1 (solid shape): outline of 1844 points within 117.89,56.17 128.75,74.1
+3.3V_ALW_PCH on VCC: 100.54,73.4 96.85,77.08 93.3,77.08 92.81,77.57 92.81,82.31 93.93,83.43 130.55,83.43 131.04,82.94 131.04,74.01 130.42,73.4
+3.3V_ALWP on TOP (solid shape): 207.24,134.36 207.24,133.21 206.41,132.39 206.41,129.47 206.09,129.15 199.17,129.15 198.92,129.4 198.92,133.15 199.17,133.4 202.79,133.4 204.13,134.74 206.86,134.74
+3.3V_ALWP on BOTTOM (solid shape): 208.38,137.85 208.38,132.39 208.06,132.07 203.62,132.07 203.24,132.45 203.24,133.79 204.44,134.99 204.44,137.28 205.4,138.23 208,138.23
+3.3V_CAM on TOP (solid shape): 99.35,141.48 99.35,141.13 98.81,141.13 98.81,140.64 99.35,140.64 99.35,140.39 99.26,140.3 95.27,140.3 95.22,140.35 95.22,140.58 95.35,140.71 96.94,140.71 97.19,140.96 97.83,140.96 98.36,141.49 99.34,141.49
+3.3V_CAM_Q on TOP (solid shape): 102.32,144.09 102.32,142.09 102.02,141.79 101.5,141.79 100.8,141.09 100.74,141.09 100.04,140.39 99.52,140.39 99.5,140.4 99.5,140.82 99,140.82 98.98,140.83 98.98,140.97 99.49,140.97 99.5,140.99 99.5,141.41 99.57,141.47 99.9,141.47 100.44,142.02 100.44,144.35 100.66,144.57 101.84,144.57
+3.3V_DVCC on TOP (solid shape): 98.78,108.77 98.78,107.31 98.34,106.86 96.87,106.86 96.68,107.05 96.68,108.77 96.87,108.96 98.59,108.96
+3.3V_DVCC on TOP (solid shape): 110.4,114.55 110.4,113.72 109.38,113.72 109.19,113.91 108.76,113.91 107.52,112.67 107.19,112.67 106.98,112.46 105.66,112.46 105.61,112.51 105.61,112.61 105.66,112.67 106.65,112.67 106.81,112.82 106.81,112.97 108.51,114.67 110.27,114.67
+3.3V_DVCC on IN2 (solid shape): outline of 532 points within 94.4,101.02 110.59,114.1
+3.3V_GPU on TOP (solid shape): 67.98,79.49 67.92,79.49 67.79,79.37 67.79,78.73 67.98,78.54 68.3,78.54 68.3,78.03 68.24,77.97 67.16,77.97 67.03,78.1 67.03,80.06 67.35,80.38 67.98,80.38
+3.3V_GPU on BOTTOM (solid shape): 78.71,89.21 78.59,89.21 78.27,88.89 78.27,86.86 78.21,86.8 77.51,86.8 76.94,87.36 75.98,87.36 75.6,87.74 75.6,89.08 75.92,89.4 78.27,89.4 78.46,89.59 78.71,89.59
+3.3V_GPU on BOTTOM (solid shape): 67.6,78.99 67.6,78.89 67.48,78.65 67.6,78.41 67.6,78.16 67.03,77.59 66.84,77.59 66.71,77.72 66.71,77.96 66.75,78.37 66.36,78.48 66.35,78.48 66.27,78.48 66.2,78.41 66.01,78.41 65.89,78.54 65.89,79.05 66.08,79.24 67.35,79.24
+3.3V_GPU on IN1 (solid shape): outline of 1851 points within 63.31,71.94 80.64,103.37
+3.3V_HDD on TOP (solid shape): 87.54,114.1 88.05,114.1 88.05,114.67 89.7,114.67 89.89,114.48 89.89,111.18 89.7,110.99 88.11,110.99 87.98,111.12 87.98,111.94 87.67,112.26 86.52,112.26 86.52,113.15 87.1,113.72 87.1,114.61 87.16,114.67 87.54,114.67
+3.3V_HDD_C on TOP (solid shape): 88.87,122.55 88.87,115.05 88.68,114.86 87.03,114.86 86.71,115.18 86.71,122.67 86.97,122.93 88.49,122.93
+3.3V_HDD_C on BOTTOM (solid shape): 87.48,123.05 87.48,120.83 87.16,120.51 84.62,120.51 84.05,121.09 84.05,122.8 84.3,123.05 86.33,123.05 86.59,123.31 87.22,123.31
+3.3V_LAN on TOP (solid shape): 306.49,166.55 304.46,166.55 304.39,166.62 304.39,167 304.52,167.12 306.49,167.12
+3.3V_LAN on TOP (solid shape): 200.32,170.23 200.32,168.52 200.06,168.27 198.67,168.27 198.35,168.58 198.35,170.17 198.67,170.49 200.06,170.49
+3.3V_LAN on BOTTOM (solid shape): 305.73,167.06 307.35,167.06 307.42,167 307.42,166.82 307.36,166.77 305.75,166.77 305.47,166.49 304.46,166.49 304.33,166.62 304.33,167 304.46,167.12 305.66,167.12
+3.3V_LAN on IN2 (solid shape): outline of 1397 points within 176.69,145.15 199.74,170.11
+3.3V_LAN on IN3 (solid shape): 200.38,169.22 200.38,168.33 200.13,168.08 199.3,168.08 198.44,168.93 198.44,169.95 198.6,170.11 199.49,170.11
+3.3V_LAN on IN3 (solid shape): 304.52,167.38 304.71,167.19 305.66,167.19 305.79,167.06 305.79,166.49 305.66,166.36 303.82,166.36 303.5,166.68 303.5,167.82 304.52,167.82
+3.3V_LAN_OUT on TOP (solid shape): 178.22,136.13 178.22,134.93 178.34,134.8 178.34,134.65 178.05,134.36 177.26,134.36 177.2,134.42 177.2,134.74 177.59,135.13 177.59,136.15 177.64,136.2 178.15,136.2
+3.3V_LAN_OUT on IN2 (solid shape): 180.04,142.49 182.35,142.49 182.73,142.1 182.73,140.01 182.71,139.91 182.73,139.81 182.73,139.43 182.71,139.33 182.73,139.23 182.73,135.94 183.11,135.56 184.63,135.56 184.89,135.31 184.89,134.56 184.74,134.42 183.29,134.42 182.99,134.59 182.69,134.42 182.49,134.42 182.25,134.55 181.99,134.46 181.95,134.43 181.14,135.25 178.92,135.25 178.6,134.93 178.6,134.42 178.41,134.23 177.27,134.23 177.08,134.42 177.08,135.83 177.61,136.36 180.8,136.36 181.46,137.02 181.46,140.94 181.18,141.22 179.49,141.22 179.17,141.53 179.17,142.65 179.3,142.78 179.74,142.78
+3.3V_M on TOP (solid shape): outline of 605 points within 116.62,61.35 120.01,74.22
+3.3V_M on BOTTOM (solid shape): 85.78,18.18 85.78,16.58 84.89,15.69 84.89,14.93 84.66,14.7 83.87,14.7 83.84,14.72 83.84,16.67 84.34,17.4 84.67,18.22 85.74,18.22
+3.3V_M on IN1 (solid shape): 32.99,16.56 32.93,16.5 31.03,16.5 30.83,16.69 30.83,17.33 31.03,17.52 32.99,17.52
+3.3V_M on IN1 (solid shape): 85.19,16.44 85.19,15.99 83.67,14.47 83.03,14.47 82.97,14.53 82.97,15.17 84.43,16.63 85,16.63
+3.3V_M on IN2 (solid shape): 31.09,23.8 31.09,18.98 32.04,18.03 32.04,16.95 31.72,16.63 29.88,16.63 29.88,21.77 29.44,22.22 29.44,23.99 29.63,24.18 30.71,24.18
+3.3V_PCIE_WWAN on TOP (solid shape): 213.33,148.39 213.33,147.37 213.14,147.18 211.87,147.18 211.87,148.58 213.14,148.58
+3.3V_PCIE_WWAN on TOP (solid shape): 221.4,155.63 221.02,155.63 220.45,155.06 219.56,155.06 219.43,155.19 219.43,156.01 219.62,156.2 221.4,156.2
+3.3V_PCIE_WWAN on TOP (solid shape): 213.27,137.15 213.97,137.15 213.97,136.67 213.98,136.66 213.98,136.64 214.42,136.4 214.36,136.89 214.32,136.91 214.32,137.15 215.49,137.15 215.68,137.34 217.02,137.34 217.27,137.09 217.27,134.93 216.89,134.55 212.25,134.55 211.94,134.87 211.94,137.28 212,137.34 213.08,137.34
+3.3V_PCIE_WWAN on BOTTOM (solid shape): outline of 864 points within 200.51,128.9 226.8,160.84
+3.3V_RUN on TOP (solid shape): 80.68,13.14 80.68,11.99 80.49,11.8 77,11.8 76.55,12.25 76.55,13.39 80.43,13.39
+3.3V_RUN on TOP (solid shape): 158.11,99.98 158.11,97.06 157.98,96.93 156.79,96.93 156.76,96.96 156.76,99.89 156.97,100.11 157.99,100.11
+3.3V_RUN on TOP (solid shape): 160.76,118.86 160.76,117.91 160.5,117.91 160.5,118.48 159.99,118.48 159.99,117.91 159.23,117.91 159.1,118.04 159.1,118.92 159.23,119.05 160.57,119.05
+3.3V_RUN on TOP (solid shape): 160.95,121.09 161.45,121.09 161.45,121.66 162.28,121.66 162.47,121.47 162.47,120.64 162.34,120.51 160.88,120.51 160.69,120.7 160.69,121.66 160.95,121.66
+3.3V_RUN on TOP (solid shape): 99.61,18.54 99.61,17.15 99.56,17.09 97.3,17.09 97.11,17.29 97.11,18.09 96.94,18.26 96.94,19.36 97,19.42 98.74,19.42
+3.3V_RUN on TOP (solid shape): 300.2,163.76 300.39,163.57 301.15,163.57 301.41,163.82 301.41,164.96 301.85,164.96 301.92,164.9 301.92,163.38 301.66,163.12 298.11,163.12 297.79,163.44 297.79,164.96 300.2,164.96
+3.3V_RUN on TOP (solid shape): 113.26,107.43 112.88,107.43 112.37,106.93 112.37,102.54 111.86,102.54 111.86,102.8 110.72,103.94 110.72,107.12 111.04,107.43 112.37,107.43 112.81,107.88 112.81,107.94 113.26,107.94
+3.3V_RUN on TOP (solid shape): 181.52,126.42 181.52,125.47 181.33,125.28 178.6,125.28 178.47,125.4 178.47,125.66 179.04,125.66 179.04,126.17 178.47,126.17 178.47,126.48 178.54,126.55 181.39,126.55
+3.3V_RUN on TOP (solid shape): 294.61,166.68 294.8,166.49 297.47,166.49 297.53,166.42 297.53,165.35 294.74,165.35 294.61,165.22 294.61,164.46 294.48,164.33 293.66,164.33 293.6,164.39 293.6,166.17 294.11,166.68 294.11,167.19 294.61,167.19
+3.3V_RUN on TOP (solid shape): 155.71,152.77 156.37,152.77 156.44,152.71 156.44,152.65 156.37,152.58 155.49,152.58 155.42,152.65 154.85,152.65 154.72,152.52 154.72,151.38 154.85,151.25 155.42,151.25 155.74,151.57 156.37,151.57 156.44,151.5 156.44,151.31 155.68,150.55 154.22,150.55 154.15,150.61 154.15,153.13 154.21,153.19 155.29,153.19
+3.3V_RUN on TOP (solid shape): 142.4,89.59 141.71,89.59 141.32,89.21 141.32,88.07 141.58,87.81 144.1,87.81 144.11,87.77 144.44,87.47 144.77,87.77 144.77,87.81 145.13,87.81 145.64,88.32 146.28,88.32 146.28,87.75 146.79,87.75 146.79,88.32 147.05,88.32 147.05,87.03 146.74,86.72 141.08,86.72 140.34,87.46 140.34,89.24 141.77,90.67 141.77,91.37 142.4,91.37
+3.3V_RUN on TOP (solid shape): 223.75,150.36 223.75,148.01 222.41,146.68 217.27,146.68 217.02,146.93 217.02,149.85 217.08,149.91 218.41,149.91 218.53,149.8 218.53,149.76 218.57,149.76 218.6,149.72 218.73,149.72 218.73,149.38 218.88,149.23 218.88,149.21 219.36,149.01 219.16,149.48 219.14,149.48 219.09,149.53 219.09,149.72 220.19,149.72 221.14,150.68 223.43,150.68
+3.3V_RUN on TOP (solid shape): 130.78,114.99 130.78,111.62 131.23,111.18 131.67,111.18 131.86,110.99 131.86,110.58 130.39,109.11 130.39,107.59 130.06,107.25 128.73,107.25 128.64,107.34 128.64,109.36 128.18,109.82 128.18,110.42 129.51,111.75 129.51,112.96 129.32,113.15 128.12,113.15 128.12,114.04 127.93,114.23 123.86,114.23 123.54,113.91 123.54,112.83 123.04,112.83 123.04,113.85 122.66,114.23 116.94,114.23 115.73,113.02 114.02,113.02 113.26,112.26 113.26,110.1 112.88,109.72 111.48,109.72 111.35,109.85 111.35,110.8 112.24,111.69 112.24,112.96 113.19,113.91 115.16,113.91 116.81,115.56 130.21,115.56
+3.3V_RUN on TOP (solid shape): 168.31,153.15 168.31,148.33 170.98,145.66 175.49,145.66 175.49,145.15 175.42,145.09 174.54,145.09 174.34,144.9 174.34,144.2 174.22,144.07 173.9,144.07 173.77,144.2 173.77,144.77 173.46,145.09 171.91,145.09 171.13,144.31 170.59,144.77 171.04,144.23 170.73,143.91 170.73,138.29 170.6,138.17 169.14,138.17 168.95,138.36 168.95,143.12 165.77,146.3 165.77,153.09 166.22,153.53 167.93,153.53
+3.3V_RUN on TOP (solid shape): outline of 118 points within 92.75,86.16 105.7,108.96
+3.3V_RUN on TOP (solid shape): outline of 289 points within 44.68,16.95 58.08,21.2
+3.3V_RUN on TOP (solid shape): outline of 827 points within 100.43,58.86 117.75,85.4
+3.3V_RUN on TOP (solid shape): outline of 921 points within 3.97,19.42 18.9,36.88
+3.3V_RUN on BOTTOM (solid shape): 95.49,66.51 95.49,64.75 95.36,64.62 94.16,64.62 93.9,64.87 93.9,66.49 93.98,66.56 95.44,66.56
+3.3V_RUN on BOTTOM (solid shape): 81.57,88.13 81.57,86.99 81.44,86.86 79.6,86.86 79.54,86.92 79.54,87.81 80.05,88.32 81.38,88.32
+3.3V_RUN on BOTTOM (solid shape): 74.82,103.92 74.82,102.53 75.61,101.75 77.09,101.75 77.38,101.46 77.38,100.23 77.24,100.09 76.16,100.09 75.72,100.53 73.57,100.53 73.25,100.85 73.25,102.82 73.14,102.92 73.14,103.99 73.25,104.1 74.65,104.1
+3.3V_RUN on BOTTOM (solid shape): 57.46,21.16 57.46,20.92 57.41,20.88 57.41,19.96 56.97,19.52 56.97,19.52 56.55,19.1 55.6,19.1 55.54,19.17 55.54,19.74 55.73,19.93 55.73,20.88 55.92,21.07 55.93,21.07 56.02,21.16 56.93,21.16 57.01,21.24 57.37,21.24
+3.3V_RUN on BOTTOM (solid shape): 109.77,73.26 109.77,72.83 109.07,72.12 109.07,71.62 109,71.56 107.51,71.56 107.13,71.17 105.07,71.17 105.07,71.68 106.62,71.68 107.26,72.32 107.64,72.7 107.86,72.7 108.56,73.4 109.64,73.4
+3.3V_RUN on BOTTOM (solid shape): 6.26,27.42 6.26,26.72 6.39,26.6 7.34,26.6 7.66,26.28 8.55,26.28 8.67,26.41 9.5,26.41 9.56,26.34 9.56,26.22 9.12,25.77 6.7,25.77 6.45,25.52 5.75,25.52 5.75,25.96 5.05,26.66 5.05,27.42 5.18,27.55 6.13,27.55
+3.3V_RUN on BOTTOM (solid shape): 8.74,30.42 9.5,30.42 9.55,30.37 9.55,30.27 9.5,30.22 8.58,30.22 8.49,30.31 5.59,30.31 5.37,30.09 5.37,29.58 4.99,29.2 4.16,29.2 3.97,29.39 3.97,30.73 4.16,30.92 5.31,30.92 5.56,31.17 7.99,31.17
+3.3V_RUN on BOTTOM (solid shape): 10.45,25.84 10.45,24.88 10.07,24.5 9.12,24.5 8.42,23.8 8.42,23.3 8.36,23.23 7.91,23.23 7.47,22.79 7.47,21.58 7.34,21.45 6.83,21.45 6.7,21.58 6.7,22.98 8.61,24.88 10.07,24.88 10.26,25.07 10.26,25.84 10.32,25.9 10.39,25.9
+3.3V_RUN on BOTTOM (solid shape): 102.6,86.41 102.6,84.89 102.85,84.64 108.43,84.64 108.62,84.83 109,84.83 109,82.8 108.69,82.48 104.43,82.48 103.8,83.11 103.29,83.11 102.53,82.35 102.53,81.14 102.02,81.14 102.02,82.03 101.45,82.6 101.45,83.18 100.7,83.92 100.7,85.96 100.33,86.33 100.33,86.57 100.49,86.73 102.28,86.73
+3.3V_RUN on BOTTOM (solid shape): 112.5,80.51 112.37,80.38 112.37,79.81 112.5,79.68 113.19,79.68 113.45,79.94 115.48,79.94 117.12,78.3 117.12,77.03 118.27,75.87 118.27,75.24 118.21,75.18 117.07,75.18 117,75.24 117,75.94 116.41,76.53 116.41,78.25 115.61,79.05 114.65,79.05 114.4,78.79 113.45,78.79 113.26,78.6 113.26,77.08 114.53,75.81 114.53,75.24 114.46,75.18 112.75,75.18 112.62,75.3 112.62,78.41 111.86,79.18 111.86,81.02 111.92,81.08 112.5,81.08
+3.3V_RUN on BOTTOM (solid shape): 65.19,107.96 65.19,105.08 63.73,103.62 60.49,103.62 58.01,101.15 29.06,101.15 28.29,101.91 28.29,104.13 28.49,104.32 29.44,104.32 30.07,103.69 30.39,103.69 30.9,103.18 34.2,103.18 35.91,104.89 51.54,104.89 58.15,105.72 64.36,108.13 65.02,108.13
+3.3V_RUN on BOTTOM (solid shape): 157.93,97.58 157.93,96.56 157.59,96.22 157.41,96.22 157.34,96.26 157.32,96.34 156.97,96.78 156.62,96.34 156.6,96.26 156.52,96.22 155.97,96.22 155.62,96.56 155.11,96.56 154.98,96.7 154.98,97.27 155.1,97.4 155.72,97.4 156.13,97.81 157.71,97.81
+3.3V_RUN on IN1 (solid shape): 17.31,65.24 17.12,65.05 16.23,65.05 16.04,65.24 16.04,67.02 17.31,67.02
+3.3V_RUN on IN1 (solid shape): 18.9,78.1 18.9,76.32 17.63,76.32 17.63,78.1 17.82,78.29 18.71,78.29
+3.3V_RUN on IN1 (solid shape): 84.75,12.75 85,12.75 85,11.29 84.94,11.23 78.97,11.23 78.78,11.42 78.78,12.44 79.09,12.75 83.86,12.75 84.11,13.01 84.49,13.01
+3.3V_RUN on IN1 (solid shape): 98.97,17.52 98.97,14.65 98.14,13.81 97.13,13.81 96.78,14.16 96.78,16.78 97.18,17.18 97.18,17.89 97.26,17.96 98.53,17.96
+3.3V_RUN on IN1 (solid shape): outline of 293 points within 72.05,86.86 82.52,104.19
+3.3V_RUN on IN1 (solid shape): outline of 737 points within 113.2,58.82 117.46,74.98
+3.3V_RUN on IN2 (solid shape): 222.86,151.95 222.86,149.03 222.6,148.77 220.76,148.77 220.57,148.96 220.57,149.72 221.53,150.68 221.53,152.33 222.48,152.33
+3.3V_RUN on IN2 (solid shape): outline of 88 points within 3.98,34.85 7.09,45.08
+3.3V_RUN on IN2 (solid shape): outline of 187 points within 104.62,100.38 112.94,110.99
+3.3V_RUN on IN2 (solid shape): outline of 532 points within 154.57,106.04 180.5,140.98
+3.3V_RUN on IN2 (solid shape): outline of 871 points within 149.49,145.86 167.99,157.09
+3.3V_RUN on IN2 (solid shape): outline of 1174 points within 254.04,163.19 306.62,175.7
+3.3V_RUN on IN2 (solid shape): outline of 1219 points within 13.56,63.55 65.32,108.15
+3.3V_RUN on IN3 (solid shape): 84.17,87.37 84.17,86.67 84.11,86.61 83.48,86.61 83.29,86.8 80.49,86.8 80.36,86.92 80.36,87.88 80.49,88 83.54,88
+3.3V_RUN on IN3 (solid shape): 101.89,87.34 101.89,86.29 101.64,86.03 100.62,86.03 99.61,87.05 97.81,87.05 97.69,87.18 97.69,88.31 97.73,88.35 100.88,88.35
+3.3V_RUN on IN3 (solid shape): 65.17,107.96 65.17,105.39 64.43,104.64 63.03,104.64 62.08,103.69 60.74,103.69 58.77,101.72 29.18,101.72 28.29,102.61 28.29,104.13 28.49,104.32 29.44,104.32 30.07,103.69 30.39,103.69 30.9,103.18 34.2,103.18 35.91,104.89 51.54,104.89 58.15,105.72 64.36,108.13 65.01,108.13
+3.3V_RUN on IN3 (solid shape): 120.04,77.64 121.21,77.64 122.4,76.45 122.4,74.67 122.21,74.48 121.43,74.48 121.34,74.53 121.35,74.64 121.07,75.21 120.79,74.64 120.8,74.53 120.71,74.48 113.03,74.48 112.89,74.62 112.89,76.2 113,76.32 113.26,76.32 113.39,76.19 115.29,76.19 115.35,76.19 115.61,76.45 117.37,76.45 118.2,75.62 119.67,75.62 119.93,75.87 119.93,76.95 119.67,77.21 119.54,77.21 119.42,77.33 119.42,77.59 119.54,77.72 119.96,77.72
+3.3V_RUN on VCC: 62.97,101.72 62.97,107.84 74.99,116.88 81.56,130.42 87.45,130.42 88.36,131.33 88.36,136.03 89.13,136.79 89.13,152.29 95.2,158.36 221.86,158.36 222.54,157.68 222.54,149 220.85,147.31 217.52,147.31 217.52,149.07 215.22,151.38 100.58,151.38 94.72,145.51 94.72,109.32 91.75,106.35 78.42,106.35 73.78,101.72 ; 1 cut-out
+3.3V_RUN_AIN on IN1 (solid shape): outline of 479 points within 5.95,21.64 10.77,33.81
+3.3V_RUN_AUDIO on TOP (solid shape): outline of 181 points within 251.31,158.3 259.12,169.54
+3.3V_RUN_AUDIO on BOTTOM (solid shape): 258.74,159.19 258.74,158.23 258.61,158.11 257.28,158.11 257.02,157.85 256.77,157.85 256.77,158.87 256.83,158.93 257.34,158.93 257.72,159.31 258.61,159.31
+3.3V_RUN_AUDIO on IN2 (solid shape): outline of 139 points within 249.85,158.55 258.8,161.85
+3.3V_RUN_CARD on BOTTOM (solid shape): 8.56,30.04 9.52,30.04 9.58,29.99 9.58,29.84 9.52,29.79 8.56,29.79 8.38,29.61 7.64,29.61 7.44,29.4 5.79,29.4 5.71,29.48 5.71,30.09 5.79,30.17 8.43,30.17
+3.3V_RUN_CARD on BOTTOM (solid shape): 34.14,53.84 34.52,53.46 35.34,53.46 35.53,53.27 35.53,50.47 35.28,50.22 34.77,50.22 34.39,49.84 30.6,49.84 30.37,50.07 30.37,50.67 30.5,50.79 33.88,50.79 34.14,51.05 34.14,52.19 33.5,52.82 33.5,53.71 33.63,53.84 34.07,53.84
+3.3V_RUN_CARD on IN2 (solid shape): 34.14,53.65 34.14,52.51 33.31,51.68 32.55,51.68 32.49,51.74 32.49,52.25 33.06,52.82 33.06,53.59 33.31,53.84 33.95,53.84
+3.3V_RUN_CARD on IN2 (solid shape): 8.86,30.85 8.86,30.09 8.29,29.52 6.64,29.52 6.51,29.65 6.51,30.22 6.77,30.47 7.72,30.47 8.17,30.92 8.8,30.92
+3.3V_RUN_FFS on TOP (solid shape): 159.87,128.45 159.87,127.18 159.8,127.12 159.17,127.12 159.1,127.18 159.1,128.45 159.23,128.58 159.74,128.58
+3.3V_RUN_FFS on TOP (solid shape): 162.91,124.96 162.34,124.96 161.64,124.26 161.64,121.85 160.37,121.85 158.91,123.31 158.91,124.83 159.04,124.96 159.36,124.96 159.42,124.9 159.42,123.5 159.74,123.18 160.06,123.18 160.76,123.88 160.76,125.09 160.88,125.21 161.77,125.21 162.03,125.47 162.91,125.47
+3.3V_RUN_TPM on TOP (solid shape): 163,118.32 163,117.94 162.97,117.91 161.58,117.91 161.39,117.72 161.39,117.15 161.15,116.91 159.61,116.91 159.31,116.6 159.31,115.15 159.21,115.05 159.03,115.05 158.93,115.15 158.93,116.78 158.77,116.93 157.48,116.93 157.3,117.11 157.3,117.59 157.4,117.69 159.01,117.69 159.04,117.72 160.82,117.72 160.95,117.85 160.95,118.36 161.07,118.48 162.84,118.48
+3.3V_RUN_VDDA on TOP (solid shape): 129.13,111.75 128.94,111.56 127.42,111.56 126.72,110.86 125.89,110.86 125.58,111.18 125.58,112.39 126.66,112.39 126.85,112.58 129.13,112.58
+3.3V_RUN_VDDA on TOP (solid shape): 126.85,103.18 127.74,103.18 127.8,103.12 127.8,102.48 127.74,102.42 125.96,102.42 125.51,102.86 124.69,102.86 124.56,102.99 124.56,103.24 124.69,103.37 126.66,103.37
+3.3V_RUN_VDDA on IN3 (solid shape): outline of 1389 points within 117.27,102.04 126.66,112.32
+3.3V_RUN_VDDIO on TOP (solid shape): 114.85,111.94 115.04,111.75 116.43,111.75 116.62,111.94 116.62,112.45 118.91,112.45 118.91,111.94 118.78,111.94 118.4,111.56 118.4,110.23 118.21,110.04 114.85,110.04 114.4,110.48 113.45,110.48 113.45,112.13 114.15,112.83 114.85,112.83
+3.3V_RUN_VDDIO on IN3 (solid shape): outline of 617 points within 113.12,99.76 126.53,111.67
+3.3V_SUS on TOP (solid shape): 93.88,25.85 93.88,24.74 93.7,24.56 93.7,23.25 93.6,23.15 92.47,23.15 92.42,23.2 92.42,24.28 92.53,24.39 92.65,24.39 92.82,24.56 92.82,25.12 92.83,25.12 92.83,25.91 92.94,26.03 93.7,26.03
+3.3V_SUS on BOTTOM (solid shape): 93.89,25.07 93.89,23.93 93.38,23.42 92.56,23.42 92.56,24.38 92.75,24.57 92.75,25.07 92.94,25.26 93.7,25.26
+3.3V_SUS on BOTTOM (solid shape): 89.38,19.36 89.38,18.66 88.94,18.22 88.81,18.22 88.43,17.83 88.43,17.14 87.92,16.63 87.92,14.85 87.79,14.72 87.02,14.72 86.92,14.82 86.92,17.19 87.15,17.42 87.15,18.16 87.2,18.22 87.73,18.22 87.86,18.34 87.86,19.04 88.11,19.3 88.56,19.3 88.75,19.49 89.25,19.49
+3.3V_SUS on IN3 (solid shape): 93.89,25.52 93.89,24.76 93.76,24.63 92.81,24.63 92.68,24.76 92.68,25.01 92.49,25.2 92.49,25.71 93.7,25.71
+3.3V_TP on TOP (solid shape): 147.42,89.53 147.04,89.15 147.04,88.51 146.02,88.51 146.02,88.95 146.6,89.53 146.6,90.03 147.42,90.03
+3.3V_USBHUB on TOP (solid shape): 168.69,121.53 169.96,121.53 170.03,121.47 170.03,121.34 169.96,121.28 166.98,121.28 166.79,121.47 166.79,121.97 166.92,122.1 168.12,122.1
+3.3V_USBHUB on TOP (solid shape): 176.06,126.36 178.28,126.36 178.28,125.34 178.98,124.64 178.98,123.94 178.47,123.94 177.46,124.96 174.92,124.96 174.54,124.58 174.54,123.82 174.41,123.69 174.28,123.69 174.22,123.75 174.22,125.34 174.09,125.47 174.09,126.55 174.22,126.67 175.74,126.67
+3.3V_USBHUB on TOP (solid shape): 170.94,119.09 170.94,117.95 171.04,117.85 171.04,117.02 170.73,116.7 169.9,116.7 169.9,117.28 170.4,117.28 170.61,117.49 170.61,117.85 170.69,117.92 170.69,119.09 170.74,119.14 170.89,119.14
+3.3V_USBHUB on TOP (solid shape): 174.73,118.86 177.33,118.86 177.33,118.04 177.2,117.91 176.5,117.91 176.19,117.59 175.55,117.59 175.36,117.4 175.36,116.83 175.3,116.77 174.73,116.77 174.73,117.34 174.22,117.85 174.22,119.05 174.28,119.12 174.47,119.12
+3.3V_USBHUB on TOP (solid shape): 170.28,126.74 171.68,126.74 171.68,125.59 171.93,125.34 171.93,123.75 171.87,123.69 171.74,123.69 171.68,123.75 171.68,124.9 170.98,125.59 169.9,125.59 168.38,127.12 166.53,127.12 166.53,127.69 166.41,127.82 165.07,127.82 164.88,127.63 164.88,125.15 165.26,124.77 165.96,124.77 165.96,124.39 165.2,124.39 164.76,123.94 164.76,121.34 164.18,121.34 164.12,121.4 164.12,125.06 164.52,125.31 164.12,125.57 164.12,128.2 164.38,128.45 168.57,128.45
+3.3V_USBHUB on IN2 (solid shape): outline of 479 points within 165.52,116.83 176.25,126.8
+3.3V_VTR on TOP (solid shape): 153.83,100.45 153.33,100.45 153.33,101.08 152.18,102.23 151.23,102.23 151.1,102.35 150.34,102.35 150.21,102.48 150.21,102.61 150.34,102.73 150.91,102.73 150.97,102.8 152.25,102.8 152.44,102.99 153.83,102.99
+3.3V_VTR_ADC on TOP (solid shape): 138.76,103.34 139.14,103.34 139.27,103.22 140,103.22 140.05,103.17 140.05,102.99 139.99,102.92 138.34,102.92 137.64,102.23 137.64,100.51 137.51,100.38 136.69,100.38 136.69,102.73 136.82,102.86 137.26,102.86 137.83,103.43 138.67,103.43
+3.3V_WLAN on TOP (solid shape): outline of 307 points within 211.94,138.74 230.35,154.23
+3.3V_WLAN on TOP (solid shape): outline of 626 points within 273.6,148.39 298.8,162.23
+3.3V_WLAN on BOTTOM (solid shape): 298.74,149.85 298.74,148.2 298.49,147.95 297.73,147.95 297.56,148.11 297.56,149.85 297.75,150.04 298.55,150.04
+3.3V_WLAN on BOTTOM (solid shape): 293.75,157.95 293.75,155.46 293.6,155.31 292.58,155.31 292.39,155.5 292.39,157.98 292.58,158.17 293.53,158.17
+3.3V_WLAN on BOTTOM (solid shape): 274.93,150.49 274.93,146.42 274.74,146.23 273.02,146.23 272.96,146.3 272.96,150.36 273.28,150.68 274.74,150.68
+3.3V_WLAN on IN2 (solid shape): outline of 1149 points within 227.94,152.2 282.36,168.08
+5V_ALW on TOP (solid shape): 249.91,172.27 249.91,170.87 249.85,170.81 247.75,170.81 247.43,171.12 247.43,172.27 247.62,172.46 249.72,172.46
+5V_ALW on TOP (solid shape): 88.85,72.93 88.85,72.84 89.06,72.62 89.77,72.62 89.82,72.57 89.82,72.44 89.76,72.38 88.54,72.38 88.02,72.9 88.02,73.36 88.12,73.46 88.32,73.46
+5V_ALW on TOP (solid shape): 24.61,70.28 24.61,69.59 25.12,69.08 25.12,67.94 25.5,67.56 25.5,66.41 25.25,66.16 23.6,66.16 23.21,66.54 23.21,69.71 23.81,70.3 24.58,70.3
+5V_ALW on TOP (solid shape): 313.54,167.5 313.54,166.36 313.03,166.36 312.52,165.85 311.5,165.85 311.31,166.04 311.31,167.63 311.5,167.82 313.22,167.82
+5V_ALW on TOP (solid shape): 185.63,5.37 185.63,4.59 185.55,4.5 184.23,4.5 184.02,4.3 184.02,3.66 183.25,3.66 183.04,3.86 183.04,4.69 183.23,4.88 183.43,4.88 184.05,5.5 185.5,5.5
+5V_ALW on TOP (solid shape): 31.28,47.43 31.28,42.47 37.59,36.16 37.61,36.14 37.64,36.1 37.68,36.06 37.7,36.05 38.01,35.74 38.01,25.39 37.88,25.26 37.31,25.26 36.93,25.65 36.93,32.86 35.88,33.91 35.88,35.42 36.01,35.42 36.01,35.37 36.02,35.32 36.04,35.27 36.06,35.22 36.09,35.17 36.13,35.14 36.17,35.1 36.22,35.08 36.26,35.06 36.32,35.04 36.37,35.04 36.42,35.04 36.48,35.06 36.52,35.08 36.57,35.1 36.61,35.14 36.65,35.17 36.68,35.22 36.7,35.27 36.72,35.32 36.73,35.37 36.73,35.42 36.72,35.48 36.7,35.53 36.68,35.58 36.65,35.62 36.61,35.66 36.57,35.69 36.52,35.72 36.48,35.74 36.42,35.75 36.37,35.75 36.32,35.75 36.26,35.74 36.22,35.72 36.17,35.69 36.13,35.66 36.09,35.62 36.06,35.58 36.04,35.53 36.02,35.48 36.01,35.42 35.88,35.42 35.88,36.22 29.88,42.22 29.88,47.36 30,47.48 31.23,47.48
+5V_ALW on TOP (solid shape): outline of 83 points within 204.18,151.31 223.05,170.04
+5V_ALW on TOP (solid shape): outline of 347 points within 78.27,73.27 92.81,89.36
+5V_ALW on BOTTOM (solid shape): 25.7,69.32 25.7,66.81 25.46,66.57 24.46,66.57 24.23,66.79 24.23,67.45 24.66,67.87 24.66,69.31 24.74,69.4 25.63,69.4
+5V_ALW on BOTTOM (solid shape): 313.09,167.69 313.09,165.98 312.9,165.79 309.98,165.79 309.85,165.92 309.85,167.63 310.04,167.82 312.97,167.82
+5V_ALW on BOTTOM (solid shape): 190.16,25.2 190.16,22.09 190.54,21.71 190.54,21.39 190.06,21.39 190.06,21.58 189.17,21.58 189.17,20.44 190.06,20.44 190.06,20.63 190.54,20.63 190.54,19.49 190.41,19.36 187.95,19.36 187.47,19.84 187.47,22.65 188.48,22.65 188.48,22.43 188.48,22.4 188.49,22.34 188.51,22.28 188.53,22.23 188.56,22.18 188.6,22.14 188.64,22.1 188.69,22.07 188.75,22.04 188.8,22.03 188.86,22.02 188.92,22.02 188.98,22.03 189.03,22.04 189.08,22.07 189.13,22.1 189.18,22.14 189.22,22.18 189.25,22.23 189.27,22.28 189.29,22.34 189.3,22.4 189.3,22.43 189.3,22.65 189.3,22.68 189.29,22.74 189.27,22.8 189.25,22.85 189.22,22.9 189.18,22.94 189.13,22.98 189.08,23.01 189.03,23.04 188.98,23.05 188.92,23.06 188.86,23.06 188.8,23.05 188.75,23.04 188.69,23.01 188.64,22.98 188.6,22.94 188.56,22.9 188.53,22.85 188.51,22.8 188.49,22.74 188.48,22.68 188.48,22.65 187.47,22.65 187.47,23.16 188.47,24.16 189.13,24.16 189.52,24.55 189.52,25.2 189.65,25.33 190.03,25.33
+5V_ALW on BOTTOM (solid shape): outline of 463 points within 152.73,2.28 190.47,8.2
+5V_ALW on IN1 (solid shape): outline of 378 points within 152.46,2.3 190.03,6.75
+5V_ALW on IN2 (solid shape): 214.67,152.39 214.67,150.49 214.48,150.3 213.59,150.3 213.4,150.49 213.4,152.26 213.65,152.52 214.54,152.52
+5V_ALW on IN3 (solid shape): outline of 459 points within 152.73,2.3 190.47,8.2
+5V_ALW on VCC: outline of 136 points within 22.71,2.02 315.03,176.18
+5V_ALWP on TOP (solid shape): 205.35,153.66 205.35,153.65 206.13,153.65 206.13,153.66 206.63,153.66 206.63,153.65 207.33,153.65 207.33,153.66 207.83,153.66 207.83,153.65 209.23,153.65 209.41,153.48 209.41,150.74 209.03,150.36 204.76,150.36 204.57,150.55 204.57,151.12 204.06,151.63 204.06,153.41 204.32,153.66 205.28,153.66
+5V_ALWP on BOTTOM (solid shape): 209.21,152.75 209.21,142.29 208.76,141.85 205.46,141.85 205.4,141.91 205.4,147.83 204.31,148.91 204.31,152.92 204.48,153.08 208.87,153.08
+5V_HDD on TOP (solid shape): 84.62,117.53 84.62,116.83 84.17,116.39 84.17,115.88 84.05,115.75 82.4,115.75 82.27,115.88 82.27,116.58 83.92,118.23
+5V_HDD on TOP (solid shape): 86.14,129.72 86.14,128.26 84.62,128.26 84.62,128.71 83.92,129.4 83.29,129.4 83.1,129.59 83.1,131.18 83.29,131.37 84.49,131.37
+5V_HDD on BOTTOM (solid shape): 86.33,131.56 86.33,128.71 86.08,128.45 82.9,128.45 82.71,128.64 82.02,128.64 82.02,130.29 82.08,130.36 82.65,130.36 82.97,130.67 82.97,131.56 83.29,131.88 86.02,131.88
+5V_MOD on TOP (solid shape): 196.36,40.69 196.36,39.53 196.06,39.22 194.47,39.22 193.76,39.93 193.76,40.8 194.05,41.08 195.98,41.08
+5V_MOD on TOP (solid shape): 191.87,28.34 191.87,25.91 191.63,25.68 190.42,25.68 190.21,25.89 190.21,28.52 190.47,28.77 191.43,28.77
+5V_MOD on BOTTOM (solid shape): 191.81,26.66 191.81,24.82 191.49,24.5 190.66,24.5 190.47,24.69 190.47,25.33 189.9,25.9 189.9,26.85 190.09,27.04 191.43,27.04
+5V_MOD on BOTTOM (solid shape): 194.93,41.33 198.22,41.33 198.41,41.14 198.41,39.74 198.28,39.62 196.06,39.62 194.51,38.07 191.26,38.07 191.05,38.28 191.05,38.88 192.72,38.88 192.72,38.83 192.73,38.77 192.74,38.72 192.77,38.67 192.8,38.63 192.83,38.59 192.87,38.56 192.92,38.53 192.97,38.51 193.02,38.5 193.08,38.5 193.13,38.5 193.18,38.51 193.23,38.53 193.28,38.56 193.32,38.59 193.35,38.63 193.38,38.67 193.41,38.72 193.42,38.77 193.43,38.83 193.43,38.88 193.42,38.93 193.41,38.98 193.38,39.03 193.35,39.08 193.32,39.11 193.28,39.15 193.23,39.17 193.18,39.19 193.13,39.21 193.08,39.21 193.02,39.21 192.97,39.19 192.92,39.17 192.87,39.15 192.83,39.11 192.8,39.08 192.77,39.03 192.74,38.98 192.73,38.93 192.72,38.88 191.05,38.88 191.05,39.49 191.62,39.49 191.62,40 191.05,40 191.05,40.92 191.7,41.58 194.68,41.58
+5V_RUN on TOP (solid shape): 146.72,114.35 146.72,113.53 146.66,113.47 145.01,113.47 144.94,113.53 144.94,114.35 145.33,114.74 146.34,114.74
+5V_RUN on TOP (solid shape): 15.79,95.56 15.79,93.84 14.32,93.84 14.07,94.1 14.07,95.5 14.45,95.88 15.47,95.88
+5V_RUN on TOP (solid shape): 24.59,104.18 24.59,102.37 24.45,102.24 22.94,102.24 22.81,102.37 22.81,104.25 22.84,104.28 24.48,104.28
+5V_RUN on TOP (solid shape): 95.69,25.82 95.69,23.18 95.63,23.12 94.49,23.12 94.43,23.19 94.43,24.28 94.74,24.6 94.74,25.05 94.4,25.39 94.4,26.02 95.49,26.02
+5V_RUN on TOP (solid shape): 82.97,114.99 83.48,114.99 83.48,115.56 83.98,115.56 84.17,115.37 84.17,113.66 83.98,113.47 82.59,113.47 82.4,113.66 82.4,113.91 82.27,114.04 82.27,115.37 82.46,115.56 82.97,115.56
+5V_RUN on TOP (solid shape): 225.21,154.74 225.21,152.07 224.89,151.76 222.6,151.76 222.35,151.5 219.09,151.5 219.09,151.59 219.2,151.71 219.22,151.7 219.42,152.18 218.95,151.98 218.95,151.96 218.73,151.74 218.73,151.5 218.54,151.5 218.35,151.31 217.08,151.31 217.02,151.38 217.02,154.49 217.33,154.8 220.83,154.8 221.14,155.12 224.83,155.12
+5V_RUN on BOTTOM (solid shape): 307.38,167.82 307.38,167.38 307.28,167.28 304.77,167.28 304.65,167.4 304.65,167.89 304.71,167.95 307.25,167.95
+5V_RUN on BOTTOM (solid shape): 190.91,40.99 190.91,38.07 190.74,37.9 187.49,37.9 187.23,38.15 187.23,40.76 187.61,41.14 190.75,41.14
+5V_RUN on IN1 (solid shape): 14.96,94.29 14.77,94.1 14.13,94.1 13.94,94.29 13.94,96.57 14.96,96.57
+5V_RUN on IN1 (solid shape): 25.53,104.21 25.53,103.37 25.44,103.28 23.21,103.28 23.16,103.34 23.16,104.24 23.21,104.3 25.44,104.3
+5V_RUN on IN1 (solid shape): outline of 1557 points within 67.22,107.81 96.49,157.92
+5V_RUN on IN3 (solid shape): 190.26,42.24 190.26,38.17 189.66,37.58 188.04,37.58 187.27,38.35 187.27,42.41 187.46,42.6 189.91,42.6
+5V_RUN on IN3 (solid shape): 185.98,82.58 185.98,80.86 185.43,80.31 184.6,80.31 183.37,81.53 183.37,81.67 182.38,82.65 182.38,84.2 182.52,84.34 184.22,84.34
+5V_RUN on IN3 (solid shape): outline of 393 points within 182.81,57.71 189.78,74.12
+5V_RUN on VCC: 180.57,83.18 180.57,123.08 189.56,132.07 200.38,132.07 201.4,133.09 207.85,133.09 217.52,142.76 217.52,146.8 221.06,146.8 223.05,148.79 223.05,157.89 222.07,158.87 94.99,158.87 88.62,152.5 88.62,137 87.86,136.24 87.86,131.54 87.24,130.93 81.67,130.93 82.14,134.07 82.3,137.24 82.3,142.24 82.03,146.37 81.23,150.43 81.22,150.49 81.22,150.55 81.22,158.02 81.05,158.93 80.56,159.72 75.39,165.36 75.3,165.51 75.27,165.68 75.27,173.8 75.41,174.14 75.75,174.28 111.8,174.28 112,174.24 112.17,174.11 112.77,173.39 113.63,172.72 114.7,172.48 130.83,172.48 131.43,172.56 132,172.77 133.54,173.58 133.65,173.62 133.77,173.63 138.28,173.63 138.28,164.73 138.76,164.25 140.81,164.25 142.52,162.55 190.83,162.55 192.76,164.48 192.76,173.63 198.63,173.63 198.75,173.62 198.86,173.58 200.4,172.77 200.97,172.56 201.57,172.48 219.2,172.48 219.44,172.49 219.68,172.53 219.68,167.91 220.82,166.76 220.97,166.61 233.8,166.61 235.18,165.24 235.18,153.77 210.81,129.4 194.41,129.4 188.19,123.18 188.19,85.31 186.05,83.18
+5V_RUN_AUDIO on TOP (solid shape): 249.91,169.47 249.91,167.82 249.59,167.5 249.59,167.06 247.12,164.58 244.89,164.58 243.5,163.19 243.5,157.6 242.73,156.84 240.26,156.84 240.26,160.84 241.21,161.79 241.21,164.9 245.85,169.54 249.85,169.54
+5V_TSP on TOP (solid shape): 72.24,105.69 72.24,105.11 72.74,105.11 72.74,105.66 72.76,105.68 73.33,105.68 73.54,105.46 74.33,105.46 74.4,105.4 74.4,104.83 74.27,104.7 71.98,104.7 71.98,105.68 71.99,105.69 72.23,105.69
+5V_TSP on BOTTOM (solid shape): 78.42,106.35 78.42,105.39 78.39,105.36 78.11,105.36 78.11,105.92 77.62,105.92 77.62,105.36 76.1,105.36 75.96,105.5 75.96,106.37 76.07,106.48 78.29,106.48
+5V_TSP_Q on TOP (solid shape): 73,108.56 72.99,105.84 72.57,105.84 72.57,105.83 72.57,105.27 72.57,105.27 72.4,105.27 72.4,105.66 72.4,105.83 71.98,105.83 71.98,105.83 71.98,108.54 72.15,108.7 72.85,108.7
+5V_TSP_Q on BOTTOM (solid shape): 78.39,105.18 78.39,102.49 78.13,102.23 77.5,102.23 77.12,102.61 77.12,105.08 77.24,105.2 78.36,105.2
+5V_USB_CHG_PWR on TOP (solid shape): 20.36,81.21 20.36,78.67 20.17,78.48 16.99,78.48 16.8,78.67 14.9,78.67 14.58,78.99 14.58,80.19 15.4,81.02 18.71,81.02 19.09,81.4 20.17,81.4
+5V_USB_CHG_PWR on BOTTOM (solid shape): 26.52,73.66 26.52,72.06 26.14,71.68 26.14,70.77 25.97,70.6 24.68,70.6 24.42,70.86 24.42,71.87 24.67,72.12 24.67,73.69 24.77,73.79 26.39,73.79
+5V_USB_CHG_PWR on BOTTOM (solid shape): 21.63,81.14 21.63,78.79 21.31,78.48 16.48,78.48 16.1,78.86 15.09,78.86 14.71,79.24 14.71,80.32 15.59,81.21 16.23,81.21 16.61,81.59 21.18,81.59
+5V_USB_CHG_PWR on IN1 (solid shape): 23.02,80.64 23.02,73.33 23.47,72.89 25.25,72.89 25.82,72.32 25.82,70.82 25.44,70.44 22.81,70.44 22.78,70.41 21.88,70.41 20.1,72.19 20.1,77.27 18.64,78.73 15.09,78.73 14.71,79.11 14.71,79.62 16.67,81.59 22.07,81.59
+P1.05V_PEX_VDD on BOTTOM (solid shape): 81.7,84.89 82.71,84.89 82.97,84.64 82.97,81.53 82.78,81.33 81.76,81.33 81.76,81.91 80.36,81.91 80.36,81.33 79.73,81.33 79.48,81.59 79.48,83.51 81.56,83.51 81.56,83.45 81.57,83.4 81.58,83.35 81.61,83.3 81.64,83.26 81.67,83.22 81.71,83.19 81.76,83.16 81.81,83.14 81.86,83.13 81.91,83.12 81.97,83.13 82.02,83.14 82.07,83.16 82.12,83.19 82.16,83.22 82.19,83.26 82.22,83.3 82.25,83.35 82.26,83.4 82.27,83.45 82.27,83.51 82.26,83.56 82.25,83.61 82.22,83.66 82.19,83.7 82.16,83.74 82.12,83.78 82.07,83.8 82.02,83.82 81.97,83.83 81.91,83.84 81.86,83.83 81.81,83.82 81.76,83.8 81.71,83.78 81.67,83.74 81.64,83.7 81.61,83.66 81.58,83.61 81.57,83.56 81.56,83.51 79.48,83.51 79.48,85.4 79.54,85.46 81.13,85.46
+V1.05S_APLLOPI on TOP (solid shape): 96.3,53.91 96.3,53.2 94.63,51.53 92.14,51.53 91.86,51.81 91.86,53.97 92.05,54.16 96.05,54.16
+V1.05SP_B+ on BOTTOM (solid shape): 157.05,80.41 161.59,80.41 162.14,79.87 162.14,78.64 161.58,78.64 161.58,77.25 162.12,77.25 162.14,77.23 162.14,76.94 158.45,76.94 158.24,77.14 156.76,77.14 156.18,77.72 156.18,79.49 155.99,79.68 154.91,79.68 154.85,79.62 153.58,79.62 153.52,79.68 153.52,80.64 153.77,80.89 156.58,80.89
+VCC_CORE on TOP (solid shape): outline of 4851 points within 77.38,27.8 118.72,52.95
+VCC_CORE on BOTTOM (solid shape): outline of 246 points within 72.87,29.26 100.79,48.12
+VCC_CORE on BOTTOM (solid shape): outline of 1966 points within 108.39,31.56 121.42,54.5
+VCC_CORE on VCC: 87.96,26.53 87.96,26.53 80.34,26.53 77.44,29.43 77.44,40.4 81.38,44.34 81.38,53.1 82.63,54.35 86.99,54.35 86.99,54.35 120.88,54.35 120.88,43.28 118.21,40.61 118.21,26.53
+VCC_PWR_SRC on BOTTOM (solid shape): 63.73,27.42 63.73,26.15 63.74,26.14 63.74,25.98 64.35,25.36 64.79,25.36 64.81,25.39 65.83,25.39 65.83,22.58 65.99,22.42 65.99,18.41 66.62,17.77 67.79,17.77 69,16.56 69,13.64 68.55,13.2 64.36,13.2 63.85,13.71 63.85,14.72 63.09,15.48 59.28,15.48 59.09,15.68 59.09,19.87 59.28,20.06 63.85,20.06 64.11,20.31 64.11,22.34 63.85,22.6 58.9,22.6 58.65,22.85 58.65,25.39 59.15,25.9 59.15,27.42 59.35,27.61 63.54,27.61
+VDDA_PVDD on TOP (solid shape): outline of 500 points within 240.26,149.47 251.62,155.96
+VDDA_PVDD on BOTTOM (solid shape): 251.51,151.07 252.25,151.07 252.32,150.99 252.32,150.89 252.25,150.82 251.41,150.82 250.72,150.13 250.09,150.13 249.76,150.46 249.35,150.46 249.35,151.02 249.4,151.07 250.14,151.07 250.24,151.17 251.41,151.17
+VDDA_PVDD on BOTTOM (solid shape): 250.48,154.8 250.48,154.49 250.82,154.14 251.38,154.14 251.43,154.09 252.27,154.09 252.32,154.04 252.32,153.89 252.27,153.84 251.48,153.84 251.24,153.6 250.3,153.6 249.73,154.17 249.53,154.17 249.34,154.36 249.34,155.44 249.47,155.57 249.72,155.57
+VDDRP on BOTTOM (solid shape): 46.96,50.6 46.96,44.06 46.26,43.36 36.55,43.36 35.79,44.12 35.79,50.6 36.3,51.11 46.46,51.11
+VDDRP_B+ on BOTTOM (solid shape): 46.2,36.06 46.2,27.3 46.01,27.11 45.44,27.11 45.44,27.68 44.04,27.68 44.04,27.11 43.47,27.11 43.22,27.36 43.22,31.8 42.96,32.06 42.96,36.25 43.09,36.38 45.88,36.38
GND on TOP (solid shape): 211.05,147.17 209.66,147.17 209.46,147.37 209.46,148.38 209.67,148.59 211.05,148.59
GND on TOP (solid shape): 216.83,147.82 216.7,147.69 216.06,147.69 215.94,147.82 215.94,151.82 216.83,151.82
GND on TOP (solid shape): 113.83,96.45 113.7,96.32 111.29,96.32 111.1,96.51 111.1,97.34 111.23,97.46 113.83,97.46
GND on TOP (solid shape): 64.68,74.73 64.68,72.89 64.55,72.76 63.73,72.76 63.6,72.89 63.6,74.79 63.73,74.92 64.49,74.92
GND on TOP (solid shape): 98.98,54.24 98.98,53.09 98.44,52.55 96.67,52.55 96.44,52.78 96.44,54.11 96.65,54.32 98.9,54.32
GND on TOP (solid shape): 115.16,150.55 115.16,149.47 115.04,149.34 114.4,149.34 114.34,149.41 114.34,150.55 114.46,150.68 115.04,150.68
GND on TOP (solid shape): 179.45,87.49 179.45,86.17 179.32,86.05 176.12,86.05 176.1,86.06 176.1,87.51 176.19,87.6 179.35,87.6
GND on TOP (solid shape): 195.93,65.84 195.93,62.16 195.74,61.97 194.09,61.97 193.59,62.48 193.59,65.78 193.84,66.03 195.74,66.03
GND on TOP (solid shape): 300.27,152.07 300.27,150.99 300.14,150.87 299.57,150.87 299.38,151.06 299.38,152.01 299.57,152.2 300.14,152.2
GND on TOP (solid shape): 305.87,159.27 305.87,158.2 305.62,157.96 303.91,157.96 303.58,158.29 303.58,159.3 303.79,159.51 305.62,159.51
GND on TOP (solid shape): 89,155.76 89,154.8 88.75,154.55 87.73,154.55 87.07,155.21 87.07,155.76 87.13,155.82 88.94,155.82
GND on TOP (solid shape): 94.91,27.3 94.91,26.47 94.84,26.41 91.73,26.41 91.73,26.79 92.49,27.55 94.65,27.55
GND on TOP (solid shape): 127.67,92.5 127.67,89.71 127.08,89.13 124.46,89.13 124.46,92.38 124.74,92.66 127.5,92.66
GND on TOP (solid shape): 42.56,85.72 42.56,81.93 42.29,81.67 40.84,81.67 40.8,81.71 40.8,85.98 40.82,86 42.28,86
GND on TOP (solid shape): 66.01,79.7 66.01,78.35 65.7,78.03 65.51,78.03 65.38,78.16 65.38,79.69 65.43,79.74 65.98,79.74
GND on TOP (solid shape): 94.33,49.9 94.33,48.44 94.14,48.25 91.54,48.25 91.41,48.38 91.41,49.84 91.67,50.09 94.14,50.09
