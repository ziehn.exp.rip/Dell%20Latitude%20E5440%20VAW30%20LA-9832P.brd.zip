# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEVICE_DET#: length 125.2
  TOP w0.102: RP17.2 141.13,96.86 v2(140.04,97.95) 140.37,98.29 140.5,98.29 141.14,98.94 U38.B1 ; v2(186.54,87.88) v1(185.93,87.88)
  IN2 w0.102: v2(169.52,87.47) 169.34,87.65 166.9,87.65 166.58,87.97 163.6,87.97 163.38,87.75 v2(162.91,87.75) ; v2(193.66,36.54) 193.32,36.54 191.53,38.33 191.03,38.83 191.03,40.37 188.91,42.49 188.91,50.58 182.68,56.81 182.68,71.85 186.22,75.39 186.22,77.08 186.54,77.4 v2(186.54,87.88)
  BOTTOM w0.102: v2(186.54,87.88) 185.73,88.68 170.28,88.68 169.52,87.92 v2(169.52,87.47) ; v2(140.04,97.95) 139.55,97.46 139.55,96.9 140.25,96.2 140.25,93.11 141.5,91.85 147.29,91.85 147.79,91.35 149.8,91.35 150.27,90.89 150.74,90.89 152.73,88.89 155.26,88.89 156.03,89.66 158.87,89.66 160.39,91.17 161.63,91.17 161.84,90.97 161.84,89.65 162.91,88.57 v2(162.91,87.75) ; JSATA2.8 196.2,38.99 193.75,36.54 v2(193.66,36.54)
DGPU_CORE_EN: length 139
  TOP w0.102: v1(108.95,86.8) 108.76,86.99 RC305.2 107.48,86.59 v2(107.48,85.78)
  IN2 w0.076: 112.82,66.67 113.2,66.67 113.52,66.35 113.52,65.44 114.17,64.79 v2(114.28,64.79)
  IN2 w0.102: 112.82,66.67 112.76,66.73 111.88,66.73 111.42,67.18 110.04,67.18 106.79,70.43 101.92,70.43 100.67,71.67 100.67,78.85 102.02,80.19 103.16,80.19 107.31,84.34 107.5,84.34 108.2,85.05 108.2,85.33 107.75,85.78 v2(107.48,85.78) ; v2(61.19,39.87) 61.19,40 61.57,40.38 62.71,40.38 64.95,38.14 78.26,38.14 80.97,40.86 80.97,58.5 79.29,60.19 79.29,65.46 79.98,66.16 79.98,72.19 81.25,73.46 81.25,78.6 80.64,79.21 78.88,79.21 77.65,80.45 v2(77.65,81.14)
  IN3 w0.102: v2(77.65,81.14) 78.35,81.84 81.32,81.84 83.14,83.67 89.88,83.67 90.64,84.43 93.62,84.43 94.38,85.19 97.52,85.19 98.29,85.96 99.24,85.96 99.94,85.26 99.94,85.26 100.15,85.06 102.06,85.06 102.72,85.72 105.64,85.72 105.7,85.78 v2(107.48,85.78)
  BOTTOM w0.076: UC1.R5 114.57,64.79 v2(114.28,64.79)
  BOTTOM w0.254: v2(61.19,39.87) 61.19,38.4 PR627.2
DGPU_HOLD_RST#: length 61.1
  TOP w0.102: v2(117.13,73.59) 116.56,74.16 116.56,76.7 116.34,76.92 116.34,77.83 116.14,78.03 114.85,78.03 v2(112.81,80.06) ; v2(78.21,75.05) v1(77.66,74.5) 75.87,74.5 75.22,75.14 75.22,76.29 75.05,76.46 UV14.1
  IN1 w0.097: v2(117.19,70.23) 117.1,70.32 117.1,73.56 v2(117.13,73.59)
  IN3 w0.102: v2(112.81,80.06) 111.1,80.06 110.62,79.58 108.14,79.58 103.55,79.58 102.41,78.44 97.73,78.44 97.14,79.03 93.13,79.03 92.34,78.24 84.31,78.24 82.21,76.13 79.29,76.13 v2(78.21,75.05)
  BOTTOM w0.076: 116.87,69.84 116.76,69.73 116.76,67.84 117.21,67.39 117.21,67.09 117.38,66.92 117.56,66.92 117.8,66.69 117.8,66.17 UC1.Y3
  BOTTOM w0.102: v2(117.19,70.23) 116.87,69.9 116.87,69.84 ; RP11.7 117.14,73.59 v2(117.13,73.59)
DGPU_PEX_RST#: length 35.8
  TOP w0.102: UV14.4 75.84,75.16 75.48,75.53 75.48,76.4 v2(74.58,77.3) 74.27,77.61 RV29.1 73.34,78.08 RV2427.2 v1(73.33,79.05)
  IN3 w0.102: v2(79.22,97.61) 80.17,96.66 80.17,91.63 79.18,90.64 75.96,90.64 75.55,90.23 75.55,88.58 74.12,87.15 74.12,77.76 v2(74.58,77.3)
  BOTTOM w0.102: RV76.1 80.07,93.62 79.22,94.48 v2(79.22,97.61)
DGPU_PEX_RST_R#: length 7.5
  TOP w0.102: v1(72.21,76.86) 72.06,76.86 v2(71.47,77.45) 71.77,77.45 RV2427.1
  BOTTOM w0.102: v2(71.47,77.45) 71.47,78.04 71.26,78.25 68.39,78.25 68.17,78.03 68.17,77.35 UV1.AC7
DGPU_PWR_EN: length 142.3
  IN1 w0.097: v2(83.11,90.67) 83.11,90.2 82.46,89.55 82.46,85.72 81.08,84.33 81.08,72.39 v2(80.81,72.13)
  IN3 w0.102: v2(80.81,72.13) 81.57,72.13 82.45,73 86.98,73 87.43,72.56 88.54,72.56 89.12,73.14 89.12,73.59 89.9,74.38 92.68,74.38 93.72,73.33 100.9,73.33 102.51,71.72 103.37,71.72 103.96,71.13 109.2,71.13 110.62,72.55 112.79,72.55 112.92,72.42 112.92,72.4 v2(113.13,72.19) ; v2(25.56,100.83) 26.39,101.65 28.36,101.65 28.93,101.08 59.41,101.08 60.49,102.16 61.7,102.16 63.54,104 69.32,104 69.63,104.32 74.29,104.32 74.61,104 74.61,103.41 75.09,102.92 77.76,102.92 81.25,99.43 81.25,92.52 v2(83.11,90.67)
  BOTTOM w0.076: UC1.L3 113.38,66.25 113.38,66.94 113.3,67.02 113.3,68.09 112.79,68.6 112.79,69.84
  BOTTOM w0.102: v2(83.11,90.67) 83.11,90.3 82.64,89.83 v1(82.4,89.83) 82.4,87.38 R155.1 ; RC306.2 115.09,75.29 114.73,74.93 114.73,74.08 115.02,73.79 115.02,72.69 114.78,72.44 113.39,72.44 v2(113.13,72.19) 112.79,71.84 112.79,69.84 ; QV2806.2 v2(25.56,100.83)
DGPU_PWROK: length 236.1
  TOP w0.102: U37.A56 175.03,97.34 R354.2 175.09,97.7 175.3,97.91 176.97,97.91 177.08,97.81 v1(177.08,97.57) v2(177.08,96.83)
  IN2 w0.102: v2(118.36,76.93) 118.72,77.28 118.72,78.87 118.95,79.09 118.95,80 118.44,80.51 118.15,80.51 117.83,80.83 117.83,81.7 119.04,82.9 119.04,83.82 119.73,84.51 120.45,84.51 122.85,82.11 126.19,82.11 126.78,82.71 126.78,85.14 127.27,85.63 127.9,85.63 128.57,84.95 131.81,84.95 133.86,82.9 136.07,82.9 137.11,83.94 143.82,83.94 144.25,83.51 147.77,83.51 148.93,84.67 148.93,85.87 152.09,89.03 154.82,89.03 155.51,89.72 156.44,89.72 156.6,89.55 162.08,89.55 162.51,89.12 167.04,89.12 167.27,88.89 173.61,88.89 176.53,91.81 176.53,95.44 177.08,95.99 v2(177.08,96.83)
  IN2 w0.254: v2(79.68,72.89) 79.6,72.81 79.6,66.59 78.84,65.83 76.73,65.83 75.54,64.63 72.87,64.63 70.59,62.35 50.47,62.35 48.42,60.3 48.42,54.47 47.98,54.03 47.98,50.47 48.23,50.22 48.23,40.57 49.95,38.85 v2(49.95,38.52) 49.95,37.33 41.44,28.82 35.34,28.82 v2(34.9,29.26)
  IN3 w0.102: v2(118.36,76.93) 117.83,76.93 117.72,77.04 115.06,77.04 114.72,76.7 113.89,76.7 113.64,76.95 112.62,76.95 112.23,76.56 112.23,74.54 111.77,74.08 109.43,74.08 107.63,72.28 104.43,72.28 102.06,74.64 100.88,74.64 96.95,78.57 93.32,78.57 92.53,77.78 84.6,77.78 82.33,75.52 79.66,75.52 78.82,74.67 78.82,73.74 79.66,72.89 v2(79.68,72.89)
  BOTTOM w0.076: 115.11,69.84 115.11,69.52 114.69,69.1 114.69,67.45 114.8,67.34 114.8,67.02 114.96,66.85 114.96,66.07 114.92,66.03 114.92,65.85 114.54,65.47 UC1.P4
  BOTTOM w0.102: v2(118.36,76.93) 118.32,76.93 118.59,76.65 118.59,75.29 118.22,74.92 117.77,74.92 117.64,74.79 RP11.6 117.64,73.37 117.36,73.09 117.36,72.63 116.86,72.13 116.46,72.13 115.11,70.78 115.11,69.84
  BOTTOM w0.254: v2(49.95,38.52) 49.95,38.66 50.33,39.04 PR633.2 ; v2(34.9,29.26) PR709.1
DH_1.35V: length 10.2
  BOTTOM w1.016: 177.84,82.16 178.22,82.54 187.81,82.54 187.87,82.48
  vias: v1(177.09,81.04) v3(177.64,81.27) v3(177.64,80.64)
DIS_BAT_PROCHOT#: length 90.8
  TOP w0.102: U37.B51 171.48,92.64 172.31,91.81 175.58,91.81 176.71,90.68 179.56,90.68 179.88,91 183.36,91 v2(183.82,90.54)
  TOP w0.254: v2(148.37,121.97) 147.69,122.66 144.63,122.66 v1(144.16,123.13) 143.42,123.87 PR514.1
  IN3 w0.102: v2(183.82,90.54) 184.94,91.66 184.94,92.49 185.23,92.79 185.6,92.79 186.14,93.33 186.14,95.04 188.25,97.15 188.25,104 189.28,105.03 189.28,110.98 187.42,112.83 v2(187.42,115)
  BOTTOM w0.102: v2(148.37,121.97) 149.52,120.83 154.65,120.83 155.38,121.56 156.66,121.56 157.58,120.64 158.41,120.64 160.5,118.55 160.5,117.34 161,116.84 165.95,116.84 167.04,115.75 177.67,115.75 177.84,115.59 186.84,115.59 v2(187.42,115)
DISP_ON: length 44.7
  TOP w0.102: D80.1 101.26,99.47 99.96,99.47 R2581.1 99.73,100.51 100.18,100.96 v1(100.46,100.96) v2(101.32,100.96) ; v2(97.19,134.92) JLVDS1.12
  IN3 w0.102: v2(101.32,100.96) 101.32,102.86 101.07,103.12 101.07,104.26 103.92,107.12 103.92,113.6 98.21,119.31 98.21,122.67 96.18,124.71 96.18,133.91 v2(97.19,134.92)
DK_AC_OFF: length 2.8
  TOP w0.254: PU701.25 v1(122.03,142.9) 122.03,143.44 121.89,143.58 PD511.2
DK_AC_OFF_EN: length 2.7
  TOP w0.254: PU701.22 123.53,143.05 124.11,143.63 PR546.1
DK_CSS_GC: length 26.8
  TOP w0.254: PQ403.3 112.81,134.04 112.56,134.29 112.56,135.69 112.81,135.94 PQ403.1 113.76,135.94 113.96,136.14 113.96,136.96 114.32,137.33 PR418.2 PR417.2 v1(114.32,139.7) 114.32,139.99 v2(114.53,140.2) ; PU701.11 126.7,137.17 127.24,136.63 v2(127.24,135.55)
  BOTTOM w0.254: v2(114.53,140.2) 114.53,138.36 115.67,137.21 120.62,137.21 122.08,135.75 127.04,135.75 v2(127.24,135.55)
DK_PWRBAR: length 2.3
  TOP w0.254: PU701.33 119.47,138.17 118.34,139.31 PR531.1
DL_1.35V:
  vias: v1(177.15,79.11) v3(176.07,79.44) v3(176.07,78.81)
DMIC0: length 211.6
  TOP w0.102: CE11.1 R2595.2 101.71,139.32 101.45,139.06 v2(101.07,139.06)
  IN1 w0.097: v2(224.19,168.96) 223.75,168.96 223.43,169.28 223.43,169.73 222.58,170.58 215.4,170.58 211.65,166.84 205.44,166.84 201.66,170.62 187.24,170.62 187.04,170.81 186.66,170.81 186.65,170.82 186.38,170.82 186.12,171.08 186.12,172.68 185.81,173 148.47,173 147.71,172.24 147.71,170.39 148.47,169.63 149.1,169.63 149.8,168.93 149.8,162.08 149.04,161.31 147.45,161.31 144.44,158.3 141.07,158.3 140.37,157.6 134.34,157.6 127.16,150.42 127.16,148.71 124.56,146.1 122.4,146.1 120.75,144.45 120.75,141.98 118.11,139.34 115.89,139.34 115.13,138.58 115.13,135.6 114.56,135.02 113.26,133.72 111.04,133.72 110.08,132.77 103.99,132.77 101.07,135.69 v2(101.07,139.06)
  BOTTOM w0.102: U17.4 254.18,157.11 253.78,157.51 253.78,159.76 252.96,160.58 v1(251.08,160.58) 245.78,160.58 240.44,155.24 230.94,155.24 227.09,159.09 227.09,165.12 224,168.2 224,168.77 v2(224.19,168.96)
DMIC0_R: length 6.7
  TOP w0.102: JLVDS1.2 97.2,139.92 v1(97.99,139.13) 98.88,138.24 D77.2 100.15,139.11 R2595.1
DMIC1: length 36.8
  TOP w0.102: v2(250.97,154.51) v5(252.28,155.82) 259.05,155.82 263.12,159.88 275.06,159.88 276.77,161.6 276.77,163.31 280.05,166.59 JPWR1.7
  BOTTOM w0.102: U17.46 251.03,154.46 v2(250.97,154.51)
DMIC_CLK0: length 190.8
  TOP w0.102: v2(105.45,134.74) 104.23,135.96 CE10.1 R2596.2
  IN1 w0.097: v2(223.94,169.54) 222.67,170.81 215.3,170.81 211.56,167.06 205.53,167.06 201.72,170.87 187.3,170.87 187.11,171.06 186.66,171.06 186.65,171.04 186.47,171.04 186.35,171.17 186.35,172.77 185.9,173.22 148.37,173.22 147.48,172.33 147.48,170.3 148.37,169.41 149.01,169.41 149.58,168.84 149.58,162.17 148.94,161.54 147.36,161.54 144.34,158.52 140.98,158.52 140.28,157.82 134.25,157.82 126.94,150.52 126.94,148.8 124.47,146.33 122.31,146.33 120.53,144.55 120.53,142.07 118.02,139.56 115.8,139.56 114.91,138.67 114.91,135.69 114.46,135.25 105.96,135.25 v2(105.45,134.74)
  BOTTOM w0.102: LE3.2 245.33,158.53 C139.1 243.18,157.6 240.59,155.01 230.84,155.01 226.86,158.99 226.86,165.02 223.77,168.11 223.77,169.37 v2(223.94,169.54)
DMIC_CLK0_R: length 10.4
  TOP w0.102: R2596.1 103.81,138.1 101.57,138.1 100.81,137.34 100.81,136.97 D77.3 99.87,136.31 99.05,137.13 98.81,137.13 v1(98.27,137.67) 98.02,137.92 98.02,138.16 97.26,138.92 JLVDS1.4
DMIC_CLK1: length 38.9
  TOP w0.102: v2(260.64,158.61) 261.34,158.61 262.99,160.27 274.93,160.27 276.39,161.73 276.39,163.44 279.55,166.6 JPWR1.8
  IN3 w0.102: v2(260.64,158.61) 260.45,158.42 251.81,158.42 v2(250.48,159.76)
  BOTTOM w0.102: v5(259.71,159.63) 260.64,158.7 v2(260.64,158.61) ; LE4.2 249.52,158.8 C130.1 250.43,159.06 250.43,159.7 v2(250.48,159.76)
DMIC_CLK_L: length 8.4
  BOTTOM w0.102: U17.2 253.18,156.74 v1(252.52,157.4) 252.08,157.84 247.85,157.84 247.47,158.22 LE4.1 LE3.1
DOCK_AC_OFF: length 54.6
  TOP w0.254: PD509.1 119.76,146.54 120.22,146.99 v2(120.94,146.99) 121.2,146.73 PD511.1 122.34,146.28 PR537.1
  IN2 w0.102: v2(120.94,146.99) 121.55,146.38 125.41,146.38 125.73,146.07 139.06,146.07 140.63,147.63 140.63,152.53 140.99,152.9 143.55,152.9 146.18,155.53 146.18,163.58 147.1,164.51 147.1,169.12 v2(147.5,169.52)
  BOTTOM w0.102: v2(120.94,146.99) v1(120.94,147.59) ; JDOCK1.2 147.45,169.58 v2(147.5,169.52)
DOCK_AC_OFF_EC: length 107.2
  TOP w0.102: v2(174.25,100.37) 173.78,100.84 173.14,100.84 ; 173.14,100.84 173.41,101.11 173.57,101.11 v1(174.18,101.72) ; 173.14,100.84 U37.A63
  TOP w0.254: PR547.1 124.24,145.91 v2(123.93,145.6) 123.93,145.1 PR546.2
  IN3 w0.102: v2(174.25,100.37) 174.69,100.8 174.69,105.9 173.96,106.62 173.96,108.75 174.37,109.16 174.37,115.16 173.07,116.46 173.07,128.32 173.9,129.15 173.9,134.36 173.2,135.06 173.2,142.93 v2(172.19,143.95)
  BOTTOM w0.102: v2(172.19,143.95) 167.55,143.95 166.43,142.83 160.47,142.83 157.39,139.75 157.39,139.44 156.69,138.74 153.78,138.74 153.63,138.88 143.19,138.88 142.79,139.28 138.12,139.28 136.78,137.94 132.65,137.94 131.98,138.61 128.37,138.61 127.86,139.12 126.47,139.12 123.93,141.66 v2(123.93,145.6)
DOCK_DCIN_IS+: length 87
  TOP w0.102: v2(182.68,169.95) 182.68,170.2 v1(182.93,170.45)
  TOP w0.508: PQ403.6 117.1,135.94 117.61,136.45 v2(117.61,136.44)
  IN1 w0.381: v2(182.68,169.95) 182.27,169.55
  IN1 w0.508: 182.27,169.55 181.88,169.16 175.04,169.16 174.15,168.27 174.15,167.82 172.88,166.55 171.17,166.55 170.47,167.25 161.45,167.25 160.87,166.68 155.54,166.68 149.44,160.58 147.54,160.58 144.62,157.66 141.38,157.66 140.68,156.96 135.47,156.96 127.99,149.48 127.99,147.7 124.23,143.95 122.39,143.95 121.45,143 121.45,141.79 117.61,137.94 v2(117.61,136.44)
  BOTTOM w0.254: JDOCK1.134 182.45,171.02 182.78,170.69 182.78,170.05 v2(182.68,169.95)
DOCK_DCIN_IS-: length 89.7
  TOP w0.508: 117.77,135.31 118.26,135.8 v2(118.26,136.44) ; 117.77,135.31 116.5,134.04 PQ403.4 ; 117.77,135.31 v1(117.77,135.32)
  IN1 w0.381: 183.26,169.44 v2(183.26,169.95)
  IN1 w0.508: 183.26,169.44 182.54,168.71 182.54,168.53 180.88,166.87 179.04,166.87 177.46,168.46 175.24,168.46 174.79,168 174.79,167.56 173.15,165.92 170.91,165.92 170.21,166.62 161.71,166.62 161.14,166.04 155.8,166.04 149.71,159.95 147.8,159.95 144.88,157.03 141.64,157.03 140.94,156.33 135.74,156.33 128.62,149.22 128.62,147.44 124.5,143.31 122.66,143.31 122.08,142.74 122.08,141.52 118.26,137.69 v2(118.26,136.44)
  BOTTOM w0.254: JDOCK1.136 182.95,171.03 183.17,170.81 183.17,170.05 v2(183.26,169.95)
DOCK_DET#: length 164.8
  TOP w0.102: v2(167.1,94.35) 167.09,94.35 166.65,93.92 166.65,93.56 166.48,93.4 U37.B41 ; D19.2 191.26,171.17 191.26,172.25 190.52,172.99 187.06,172.99 186.07,172 R272.1 182.25,171.43 182.78,170.9 183.16,170.9 v2(184.09,169.97)
  TOP w0.254: PR564.2 PR560.2 137.55,126.13 v1(137.55,126.84) 137.55,127.16 v2(137.21,127.5) ; PQ512.2 142.52,140.53 142.93,140.12 v2(142.93,139.79) ; v2(146.87,128.36) 146.41,128.83 PU506.2
  IN2 w0.254: v2(137.21,127.5) 138.91,127.5 139.29,127.12 145.63,127.12 v2(146.87,128.36)
  IN3 w0.102: v2(167.1,94.35) 167.02,94.44 167.02,103.09 167.23,103.31 167.23,105.2 167.82,105.78 167.82,107.16 168.13,107.48 168.13,116.15 169.58,117.59 169.58,129.41 171.64,131.47 171.64,134.83 172.72,135.92 172.72,141.06 170.84,142.94 v2(170.84,144.52) 170.84,147.42 171.55,148.14 171.55,157.41 178.28,164.14 178.28,165.73 178.03,165.98 178.03,167 178.28,167.25 178.28,168.52 178.87,169.1 183.6,169.1 184.09,169.6 v2(184.09,169.97)
  IN3 w0.254: v2(142.93,139.79) 143.39,139.32 143.39,137.9 140.25,134.75 140.25,133.02 138.98,131.75 138.98,129.85 137.21,128.08 v2(137.21,127.5)
  BOTTOM w0.102: v2(142.93,139.79) 142.99,139.79 143.67,139.11 153.73,139.11 153.85,138.99 156.56,138.99 157.14,139.56 157.14,139.82 160.37,143.06 166.28,143.06 167.74,144.52 v2(170.84,144.52)
DOCK_DET_R#: length 14.8
  TOP w0.102: v2(185.58,172.49) 185.58,173.03 v1(185.77,173.22) 190.61,173.22 D19.1 192.12,171.71 D87.2
  BOTTOM w0.102: JDOCK1.142 184.45,172.97 184.5,173.03 184.82,173.03 184.95,172.9 JDOCK1.144 184.95,171.19 185.08,171.06 185.33,171.06 185.58,171.31 v2(185.58,172.49)
DOCK_HP_DET: length 135.1
  TOP w0.102: v2(169.07,104.39) 168.88,104.39 v1(168.6,104.1) 168.23,103.74 U37.A7
  IN2 w0.102: v2(264.95,160.77) 262.8,160.77 261.15,162.42 255.37,162.42 254.16,163.63 246.54,163.63 245.91,163 239.16,163 237.35,161.18 237.35,160.17 236.65,159.47 236.65,157.42 231.69,152.46 231.69,151.88 225.17,145.36 225.17,143.15 221.97,139.95 217.02,139.95 215.43,138.36 215.43,136.8 212.78,134.14 212.78,132.2 210.1,129.52 190.65,129.52 182.02,120.88 182.02,118.96 182.4,118.58 182.4,115.88 175.36,108.84 175.36,107.69 174.3,106.63 172.86,106.63 171.42,105.19 170.07,105.19 169.26,104.39 v2(169.07,104.39)
  BOTTOM w0.102: v2(264.95,160.77) R158.2 264.96,159.75 Q21.2
DOCK_LOM_ACTLED_YEL#: length 31.2
  TOP w0.102: v2(191.24,165.09) 192.21,164.11 v1(192.21,163.14) 192.21,159.42 190.33,157.54 U23.19
  BOTTOM w0.102: JDOCK1.100 173.95,171.02 173.86,170.92 173.86,170.16 174.92,169.09 180.24,169.09 180.26,169.07 181.52,169.07 181.54,169.09 181.62,169.09 183.9,166.81 184.41,166.81 186.13,165.09 v2(191.24,165.09)
DOCK_LOM_SPD10LED_GRN#: length 43
  TOP w0.102: U23.40 179.36,158.04 178.47,157.15 v2(178.47,156.84)
  IN1 w0.097: v2(178.47,156.84) 178.05,157.26 174.05,157.26 169.2,162.1 169.2,162.49 168.62,163.07 164.64,163.07 164.25,162.68 158.35,162.68 157.9,163.13 154.6,163.13 154.22,162.75 154.16,162.75 150.66,159.25 v2(148.06,159.25)
  BOTTOM w0.102: v2(148.06,159.25) 147.74,159.57 v1(147.74,160.37) 147.74,160.84 148.37,161.47 148.37,162.17 147.95,162.59 JDOCK1.3
DOCK_LOM_SPD100LED_ORG#: length 68.3
  TOP w0.102: U23.20 190.51,158.04 191.81,159.34 v1(191.81,161.29) 191.81,163.82 188.82,166.81 188.82,169.03 187.04,170.81 185.97,170.81 184.76,169.6 v2(184.55,169.6)
  IN1 w0.097: v2(156.63,165.41) 158.98,163.06 163.99,163.06 165.77,164.84 170.41,164.84 170.79,165.22 173.52,165.22 173.96,164.77 180.76,164.77 182.41,166.42 184.44,166.42 185.58,167.57 185.58,168.56 v2(184.55,169.6)
  BOTTOM w0.102: v2(156.63,165.41) 156.63,167.89 155.09,169.43 148.36,169.43 147.95,169.84 JDOCK1.4
DOCK_LOM_TRD0+: length 17.8
  TOP w0.089: v2(174.9,170.26) 175,170.16 175,169.36 174.66,169.03 174.66,164.47 175.24,163.89 176.42,162.72 v1(177.2,161.93) 177.66,161.47 181.2,161.47 181.82,160.85 181.82,160.27 181.77,160.22 U23.36
  BOTTOM w0.089: JDOCK1.104 174.95,171.04 175,170.99 175,170.35 v2(174.9,170.26)
DOCK_LOM_TRD0-: length 17.8
  TOP w0.089: U23.35 182.27,160.22 182.22,160.27 182.22,161.02 181.37,161.87 177.82,161.87 177.48,162.21 175.06,164.63 175.06,168.86 175.39,169.2 175.39,170.16 v2(175.49,170.26)
  BOTTOM w0.089: JDOCK1.106 175.45,171.05 175.39,170.99 175.39,170.35 v2(175.49,170.26)
DOCK_LOM_TRD1+: length 18.2
  TOP w0.089: v2(176.41,170.27) 176.46,170.22 176.46,164.83 178.18,163.11 v1(178.88,163.11) 182.63,163.11 183.04,162.69 183.04,161.42 183.82,160.65 183.82,160.27 183.77,160.22 U23.32
  BOTTOM w0.089: v2(176.41,170.27) 176.45,170.32 JDOCK1.110
DOCK_LOM_TRD1-: length 18.3
  TOP w0.089: U23.31 184.27,160.22 184.22,160.27 184.22,160.81 183.44,161.59 183.44,162.86 182.79,163.5 178.35,163.5 176.85,165 176.85,170.14 v2(176.99,170.27)
  BOTTOM w0.089: v2(176.99,170.27) 176.84,170.42 176.84,170.94 176.95,171.05 JDOCK1.112
DOCK_LOM_TRD2+: length 18.1
  TOP w0.089: v2(179.22,169.96) 179.3,169.88 179.3,169.53 178.28,168.51 178.28,167.46 179.07,166.67 180.07,166.67 181.13,165.61 181.13,164.93 181.67,164.38 183.64,164.38 185.69,162.34 186.32,161.7 186.32,160.27 186.27,160.22 U23.27
  BOTTOM w0.089: JDOCK1.122 179.45,171.12 179.46,171.11 179.46,170.5 179.41,170.45 179.41,170.15 v2(179.22,169.96)
DOCK_LOM_TRD2-: length 18.1
  TOP w0.089: v2(179.8,169.96) 179.69,169.85 179.69,169.36 178.68,168.35 178.68,167.62 179.23,167.06 180.24,167.06 181.52,165.78 181.52,165.09 181.84,164.77 v1(182.66,164.77) 183.81,164.77 186.72,161.86 186.72,160.27 186.77,160.22 U23.26
  BOTTOM w0.089: v2(179.8,169.96) 179.8,170.28 179.86,170.34 179.86,170.95 179.95,171.05 JDOCK1.124
DOCK_LOM_TRD3+: length 16
  TOP w0.089: U23.23 188.27,160.22 188.32,160.27 188.32,161.42 185.9,163.84 185.9,164.22 184.45,165.67 182.45,167.67 182.27,167.67 181.81,168.13 180.69,169.25 180.69,169.72 v2(180.6,169.81)
  BOTTOM w0.089: v2(180.6,169.81) 180.69,169.91 180.69,170.56 180.76,170.62 180.76,170.97 180.95,171.16 180.95,171.38 JDOCK1.128
DOCK_LOM_TRD3-: length 16
  TOP w0.089: v2(181.18,169.81) 181.09,169.72 181.09,169.41 v1(182.08,168.41) 182.43,168.06 182.61,168.06 184.73,165.95 186.3,164.38 186.3,164 188.72,161.58 188.72,160.27 188.77,160.22 U23.22
  BOTTOM w0.089: JDOCK1.130 181.45,171.1 181.15,170.81 181.15,170.46 181.09,170.39 181.09,169.91 v2(181.18,169.81)
DOCK_MIC_DET: length 144.1
  TOP w0.102: U37.B8 167.98,101.82 168.26,101.55 168.26,101.23 v2(168.72,100.77)
  IN2 w0.102: v2(168.72,100.77) 168.35,101.14 168.35,101.57 169.27,102.49 171.23,102.49 176.12,107.39 176.12,108.77 183.26,115.9 183.26,121.37 190.96,129.06 210.37,129.06 213.23,131.92 213.23,133.95 214.12,134.84 215.92,134.84 217.91,136.83 219.7,136.83 225.72,142.85 225.72,145.26 232.14,151.69 232.14,152.27 237.11,157.23 237.11,159.28 237.81,159.98 237.81,160.99 239.3,162.49 246.12,162.49 246.76,163.12 253.78,163.12 254.99,161.92 260.95,161.92 263.05,159.82 266.61,159.82 v2(267.5,158.93)
  BOTTOM w0.102: Q21.5 264.96,155.9 R159.2 265.22,155.63 266.13,155.63 267.77,157.27 v1(267.77,157.94) 267.77,158.66 v2(267.5,158.93)
DOCK_POR_RST#: length 125
  TOP w0.102: v2(152.18,127.82) 152.63,127.37 152.63,127.09 153.52,126.2 153.52,122.8 152.06,121.34 152.06,117.89 155.51,114.44 155.51,112.29 155.12,111.9 155.12,108.85 155.54,108.43 155.54,107.13 156.04,106.63 156.04,105.59 ; U38.A21 151.04,102.06 151.28,101.82 152.27,101.82 153.14,100.96 153.14,100.26 C357.1 154.05,99.34 155.39,99.34 155.61,99.56 155.61,102.78 156.13,103.31 156.13,105.5 156.04,105.59 ; 156.04,105.59 154.28,105.59 153.82,105.13 RP18.5 ; v2(192.25,166.81) 192.71,166.81 v1(193.86,167.96) 193.88,167.97 D87.3 191.66,169.78 190.89,170.55 187.65,170.55 187.13,171.06 185.84,171.06 185.43,170.65 184.92,170.65 v2(184.82,170.74)
  IN2 w0.102: v2(152.18,127.82) 151.87,128.13 151.87,130.61 153.9,132.64 153.9,142.17 154.79,143.06 154.79,143.31 158.11,146.64 167.89,146.64 171.17,149.91 171.17,154.04 173.01,155.88 175.49,155.88 177.58,157.98 177.58,159.25 178.47,160.14 179.3,160.14 182.16,163 190.66,163 192.25,164.58 v2(192.25,166.81)
  BOTTOM w0.102: JDOCK1.140 183.95,171.29 184.5,170.74 v2(184.82,170.74)
DOCK_PSID: length 93.6
  TOP w0.102: v2(125.7,123.63) 126.01,123.63 v1(126.97,122.66)
  TOP w0.254: PU1.1 125.72,123.64 v2(125.7,123.63)
  IN2 w0.102: v2(125.7,123.63) 125.2,124.13 125.2,124.77 124.79,125.18 124.79,128.81 125.7,129.72 134.85,129.72 136.33,131.21 142.49,131.21 143.1,130.6 150.84,130.6 153.64,133.4 153.64,142.29 154.53,143.18 154.53,143.44 157.96,146.87 167.74,146.87 170.85,149.98 170.85,155.69 172.38,157.22 172.38,160.01 173.96,161.6 175.42,161.6 178.11,164.28 181.7,164.28 182.73,165.32 v2(182.87,165.32)
  BOTTOM w0.102: v2(182.87,165.32) 182.95,165.24 JDOCK1.135
DOCK_PWR_BTN#: length 115.1
  TOP w0.102: v2(139.23,98.54) 138.99,98.3 R330.2 138.99,95.65 C342.1 ; v1(185.97,149.03) v2(186.98,149.03)
  IN2 w0.102: v2(139.23,98.54) 138.34,99.43 138.34,99.88 136.9,101.31 136.9,108.93 137.86,109.88 138,109.88 140.87,112.75 146.7,112.75 147.27,112.18 150.65,112.18 151.64,113.17 151.64,114.66 152.67,115.69 153.58,115.69 156.76,118.86 157.35,118.86 158.25,119.76 159.47,119.76 162.41,122.7 162.41,125.78 162.03,126.17 162.03,128.13 162.98,129.09 164.57,129.09 165.66,130.18 165.66,140.21 168.03,142.59 171.72,142.59 173.65,144.52 183.93,144.52 184.44,145.03 184.44,147.63 185.84,149.03 v2(186.98,149.03)
  IN3 w0.102: v2(186.98,149.03) 186.98,153.53 186.28,154.23 186.28,161.66 184.95,163 184.95,164.42 183.44,165.93 v2(183.44,165.97)
  BOTTOM w0.102: v2(183.44,165.97) 183.95,165.46 JDOCK1.139
DOCK_PWR_SW#: length 6.8
  TOP w0.102: R328.2 C344.1 138.07,95.65 R330.1 138.07,97.29 v1(138.46,97.67) 138.76,97.97 138.76,100.11 139.22,100.56 U38.A63
DOCK_SMB_ALERT#: length 200.8
  TOP w0.102: R292.2 173.82,94.54 v2(173.74,94.63) 173.53,94.84 U37.A51 ; v1(128.61,121.37) 128.23,121.75 128.23,122.3 128.6,122.67 v2(128.88,122.67)
  TOP w0.254: v2(128.88,122.67) 128.88,122.99 129.21,123.32 PQ1.3 ; PD512.2 140.93,171.27 141.22,171.57 v2(141.22,172.69)
  IN2 w0.254: v2(182.86,165.96) 181.28,167.53 181.28,168.41 180.37,169.32 171.39,169.32 170.52,168.44 161.42,168.44 158.08,171.78 148.18,171.78 146.97,172.99 141.53,172.99 v2(141.22,172.69)
  IN3 w0.102: v2(186.82,114.99) 186.82,117.09 188,118.27 188,121.34 180.38,128.96 180.38,131.06 181.33,132.01 181.33,132.83 181.81,133.31 181.81,138.96 182.41,139.56 182.41,142.61 184.06,144.26 184.06,148.52 182.09,150.49 182.09,152.52 180.06,154.55 180.06,155.44 180.5,155.88 180.5,159.44 179.58,160.36 179.58,162.01 180.31,162.74 180.31,164.77 181.5,165.96 v2(182.86,165.96) ; v2(173.74,94.63) 174.77,95.67 174.77,99.74 174.98,99.95 174.98,106.01 174.19,106.8 174.19,108.63 174.65,109.08 174.65,110.91 v2(175.61,111.88)
  BOTTOM w0.102: v2(128.88,122.67) 128.95,122.74 129.25,122.74 130.15,121.83 130.6,121.83 131.07,121.37 131.79,121.37 131.86,121.44 137.08,121.44 137.36,121.16 146.25,121.16 147.28,120.13 158.15,120.13 159.99,118.29 159.99,117.09 160.69,116.39 165.52,116.39 167.93,113.97 167.93,112.76 169.16,111.54 175.27,111.54 v2(175.61,111.88) 178.73,114.99 v2(186.82,114.99) ; JDOCK1.133 182.45,165.55 v2(182.86,165.96)
DOCK_SMB_CLK: length 125.9
  TOP w0.102: v2(134.2,105.47) 134.14,105.53 RP7.2 ; v2(143.1,100.89) 142.72,100.51 142.72,99.56 142.64,99.48 U38.B4
  IN1 w0.097: v2(187.62,130.53) 187.44,130.71 187.27,130.71 187.17,130.61 187.17,128.83 184.69,126.36 176.76,126.36 174.35,123.95 166.48,123.95 164.82,122.29 159.04,122.29 158.15,123.18 154.68,123.18 152.37,120.87 152.37,119.12 150.56,117.3 144.97,117.3 142.66,114.99 142.66,111.5 142.47,111.31 142.47,109.28 141.89,108.71 141.89,107.05 142.88,106.07 142.88,101.11 v2(143.1,100.89)
  IN3 w0.102: v2(143.1,100.89) 143.1,98.99 142.66,98.54 140.63,98.54 139.99,99.18 138.53,99.18 135.74,101.97 135.74,105.53 135.34,105.93 134.67,105.93 v2(134.2,105.47) ; v2(187.62,130.53) 187.44,130.71 186.68,130.71 186.05,131.34 186.05,133.06 185.27,133.84 185.27,144.39 184.82,144.83 184.82,156.26 184.06,157.03 184.06,160.84 182.79,162.11 182.54,162.11 v2(182.35,161.92)
  BOTTOM w0.102: v2(182.35,161.92) 182.19,162.07 181.36,162.07 180.95,162.48 JDOCK1.127
DOCK_SMB_DAT: length 125.8
  TOP w0.102: v2(134.83,105.46) 134.4,105.03 RP7.1 ; v2(142.28,97.65) 142.28,97.73 142.38,97.83 142.38,97.85 142.39,97.86 U38.A3
  IN1 w0.097: v2(187.62,131.12) 187.44,130.94 187.18,130.94 186.95,130.7 186.95,128.93 184.6,126.58 176.66,126.58 174.26,124.17 166.38,124.17 164.73,122.52 159.13,122.52 158.25,123.4 154.59,123.4 152.15,120.96 152.15,119.21 150.46,117.52 144.87,117.52 142.43,115.08 142.43,111.59 142.24,111.4 142.24,109.37 141.67,108.8 141.67,106.96 142.66,105.97 142.66,98.12 142.28,97.75 v2(142.28,97.65)
  IN3 w0.102: v2(134.83,105.46) 135.01,105.64 135.31,105.64 135.51,105.44 135.51,101.88 138.44,98.95 139.9,98.95 140.53,98.31 142,98.31 142.28,98.04 v2(142.28,97.65) ; v2(182.35,162.5) 182.51,162.34 182.89,162.34 184.29,160.93 184.29,157.12 185.05,156.36 185.05,144.93 185.5,144.48 185.5,133.94 186.28,133.15 186.28,131.44 186.78,130.94 187.44,130.94 v2(187.62,131.12)
  BOTTOM w0.102: v2(182.35,162.5) 182.14,162.3 181.46,162.3 181.18,162.58 181.18,162.92 181.45,163.19 JDOCK1.129
DOCK_USBP1+: length 139.2
  TOP w0.102: R415.1 165.92,167.28 L53.4 165.92,166.72 166.24,166.4 166.24,166.18 165.55,165.5 165.55,163.23 166.06,162.72 166.06,162.47 v3(167.44,161.1) 168.55,159.98 168.55,158.41 v2(168.37,158.22)
  IN1 w0.097: v2(126.89,61.91) 126.89,62.08 127.22,62.41 128,62.41 128.77,63.19 128.77,66.85 129.93,68 129.93,69.3 130.66,70.04 131.58,70.04 134.3,72.75 134.3,73.49 135.28,74.47 135.28,76.75 135.95,77.42 135.95,80.37 140.84,85.26 140.84,86.05 144.62,89.82 149.17,89.82 151.3,91.95 152.32,91.95 153.01,92.64 153.01,96.53 154.6,98.13 154.6,116.65 156.71,118.76 158.16,118.76 159.55,120.15 162.47,120.15 162.63,120.31 166.29,120.31 167.99,118.61 v2(168.12,118.61)
  IN3 w0.102: v2(168.37,158.22) 168.57,158.02 168.57,149.11 169.45,148.22 169.45,130.56 167.72,128.82 167.72,120.49 167.3,120.07 167.3,118.93 167.58,118.65 168.08,118.65 v2(168.12,118.61)
  BOTTOM w0.076: v2(126.89,61.91) 126.56,61.59 UC1.AT10
DOCK_USBP1-: length 139.3
  TOP w0.102: v2(168.95,158.22) 168.77,158.41 168.77,160.07 167.79,161.06 167.79,161.08 167.42,161.45 167.39,161.45 166.28,162.56 166.28,162.81 165.77,163.32 165.77,165.41 166.45,166.09 166.45,166.4 166.77,166.72 L53.1 166.77,167.28 R407.1
  IN1 w0.097: v2(167.99,119.2) 167.71,119.2 166.38,120.52 162.54,120.52 162.38,120.36 159.46,120.36 158.07,118.97 156.63,118.97 154.39,116.74 154.39,98.21 152.8,96.62 152.8,92.72 152.23,92.16 151.21,92.16 149.09,90.03 144.53,90.03 140.63,86.14 140.63,85.35 135.74,80.45 135.74,77.51 135.07,76.84 135.07,74.56 134.09,73.57 134.09,72.84 131.5,70.25 130.58,70.25 129.72,69.39 129.72,68.09 128.56,66.93 128.56,63.28 127.91,62.62 127.13,62.62 126.76,62.26 126.63,62.26 126.32,61.95 v2(126.24,61.95)
  IN3 w0.102: v2(168.95,158.22) 168.78,158.05 168.78,149.2 169.67,148.31 169.67,130.47 167.93,128.73 167.93,120.4 167.51,119.98 167.51,119.02 167.67,118.86 167.8,118.86 167.99,119.06 v2(167.99,119.2)
  BOTTOM w0.076: v2(126.24,61.95) 125.91,61.63 UC1.AR10
DOCK_USBP1_D+: length 4.2
  TOP w0.102: v2(165.91,170.23) 166.09,170.05 166.09,169.74 166.24,169.59 166.24,169.18 165.92,168.86 L53.3 165.92,168.36 R415.2
  BOTTOM w0.102: v2(165.91,170.23) 166.09,170.42 166.09,171.06 165.95,171.2 JDOCK1.72
DOCK_USBP1_D-: length 4.2
  TOP w0.102: R407.2 166.77,168.36 L53.2 166.77,168.86 166.45,169.18 166.45,169.68 166.31,169.83 166.31,170.05 v2(166.49,170.23)
  BOTTOM w0.102: v2(166.49,170.23) 166.31,170.42 166.31,171.06 166.45,171.2 JDOCK1.74
DOCK_USBP2+: length 142.2
  TOP w0.102: R269.1 163.95,167.28 L43.4 163.95,166.72 164.26,166.41 164.26,164.27 164.25,164.25 164.25,163.71 164.26,163.69 164.26,162.61 167.42,159.45 167.42,157.86 v2(167.24,157.67)
  IN1 w0.097: v2(166.09,118.62) 166.23,118.75 166.23,118.94 165.54,119.62 163.3,119.62 161.91,118.23 161.18,118.23 157.52,114.57 157.52,112.97 157.3,112.75 157.3,109.44 158.06,108.69 158.06,106.11 158.46,105.7 158.46,103.02 158.04,102.6 158.04,101.21 157.61,100.78 157.61,95.99 156.27,94.64 156.27,92.95 150.13,86.82 144.56,86.82 143.06,85.31 143.06,84.54 138.46,79.95 138.46,73.39 136.69,71.62 136.69,70.79 135.48,69.59 134.83,69.59 134.34,69.1 134.34,68.02 132.78,66.46 132.04,66.46 131.7,66.11 131.7,63.6 129.34,61.24 129.34,59.66 127.63,57.95 124.34,57.95 124.17,58.12 124.17,58.49 v2(123.96,58.7)
  IN3 w0.102: v2(166.09,118.62) 166.09,118.63 166.23,118.77 166.23,121.59 166.23,121.6 166.23,125.58 166.7,126.05 166.7,129.11 168.74,131.15 168.74,146.83 167.87,147.7 167.87,155.9 167.44,156.33 167.44,157.47 v2(167.24,157.67)
  BOTTOM w0.076: UC1.AL15 123.64,59.02 v2(123.96,58.7)
DOCK_USBP2-: length 142.3
  TOP w0.102: R270.1 164.8,167.28 L43.1 164.8,166.72 164.48,166.39 v3(164.48,163.97) 164.48,162.7 167.64,159.54 167.64,157.85 v2(167.82,157.67)
  IN1 w0.097: v2(124.61,58.7) 124.38,58.47 124.38,58.21 124.43,58.16 127.54,58.16 129.13,59.74 129.13,61.33 131.49,63.69 131.49,66.2 131.95,66.67 132.69,66.67 134.13,68.11 134.13,69.19 134.74,69.8 135.4,69.8 136.48,70.88 136.48,71.71 138.25,73.48 138.25,80.03 142.85,84.63 142.85,85.4 144.48,87.03 150.04,87.03 156.05,93.04 156.05,94.73 157.4,96.08 157.4,100.86 157.83,101.3 157.83,102.69 158.25,103.11 158.25,105.61 157.85,106.02 157.85,108.6 157.09,109.35 157.09,112.84 157.31,113.06 157.31,114.66 161.1,118.44 161.82,118.44 163.21,119.83 165.63,119.83 166.45,119.02 166.45,118.85 v2(166.68,118.62)
  IN3 w0.102: v2(167.82,157.67) 167.65,157.5 167.65,156.42 168.08,155.99 168.08,147.79 168.96,146.91 168.96,131.06 166.92,129.02 166.92,125.97 166.44,125.49 166.44,121.69 166.45,121.68 166.45,119.3 166.45,118.85 v2(166.68,118.62)
  BOTTOM w0.076: UC1.AM15 124.29,59.02 v2(124.61,58.7)
DOCK_USBP2_D+: length 4.2
  TOP w0.102: R269.2 163.95,168.36 L43.3 163.95,168.9 164.26,169.21 164.26,169.54 164.6,169.88 164.6,170.04 v2(164.41,170.23)
  BOTTOM w0.102: JDOCK1.66 164.45,171.2 164.59,171.06 164.59,170.42 v2(164.41,170.23)
DOCK_USBP2_D-: length 4.2
  TOP w0.102: v2(164.99,170.23) 164.82,170.06 164.82,169.79 164.48,169.45 164.48,169.22 164.8,168.9 L43.2 164.8,168.36 R270.2
  BOTTOM w0.102: v2(164.99,170.23) 164.81,170.42 164.81,171.06 164.95,171.2 JDOCK1.68
DOCKED: length 89.3
  TOP w0.102: U37.A38 166.23,91.48 v2(166.33,91.39) ; v2(186.92,155.18) 186.77,155.33 U23.13
  IN3 w0.102: v2(166.33,91.39) 166.33,91.89 167.65,93.21 168.19,93.21 168.41,93.44 168.41,99.29 167.25,100.46 167.25,101.79 168.15,102.69 168.15,105.06 168.05,105.16 168.05,107.07 168.36,107.38 168.36,115.93 171.42,118.99 171.42,127.82 171.11,128.13 171.11,129.83 172.06,130.79 172.06,134.74 172.95,135.63 172.95,142.55 171.68,143.82 171.68,147.69 172,148.01 172,155.63 v2(172.44,156.07)
  BOTTOM w0.102: v2(172.44,156.07) 174.09,157.73 v1(179.91,157.73) 182.98,157.73 183.55,158.3 185.46,158.3 186.92,156.84 v2(186.92,155.18)
DPB_CA_DET: length 93.4
  TOP w0.102: U11.1 v2(145.66,141.34) ; v2(148.4,170.35) 148.29,170.23 v1(147.89,170.23) 147.5,170.23 147.35,170.38 R120.2 ; Q133.2 146.96,148.6 146.74,148.37 v2(146.74,147.82) ; v2(147.61,141.28) U11.4 ; v2(126.4,110.42) 125.75,109.77 125.75,109.45 124.96,108.66 U6.M14
  IN2 w0.102: v2(145.07,123.18) 144.5,122.61 140.31,122.61 139.55,123.37 137.27,123.37 136.87,122.96 136.87,120.99 134.56,118.68 132.67,118.68 126.91,112.91 126.91,110.93 v2(126.4,110.42)
  IN3 w0.102: v2(145.07,123.18) 145.07,123.56 145.83,124.32 145.83,134.8 147.61,136.58 v2(147.61,141.28) ; v2(145.66,141.34) 145.66,144.79 146.71,145.84 146.71,147.79 v2(146.74,147.82) 148.37,147.82 148.7,148.14 148.7,151.62 145.77,154.55 145.77,163.25 149.64,167.12 149.64,168.53 148.4,169.77 v2(148.4,170.35)
  BOTTOM w0.102: JDOCK1.6 148.45,170.84 148.4,170.79 v2(148.4,170.35) ; v2(145.66,141.34) 145.72,141.28 v2(147.61,141.28)
DPB_CA_DET#: length 10.6
  TOP w0.102: U11.13 146.31,144.23 v2(146.09,144.01) ; v1(150.23,149.33) 150.47,149.09 R161.1 150.07,147.95 Q133.1 148.26,146.88 U11.10 148.26,144.28 v2(148.18,144.2)
  BOTTOM w0.102: v2(148.18,144.2) 146.28,144.2 v2(146.09,144.01)
DPB_DOCK_AUX: length 45
  TOP w0.089: U11.11 147.61,143.96 147.51,143.86 147.42,143.86 147.32,143.76 147.32,143.59 147.42,143.49 147.59,143.49 147.69,143.39 147.69,143.23 147.59,143.13 147.2,143.13 147.1,143.03 147.1,142.82 147.21,142.71 v2(147.39,142.71) 147.39,142.38 146.96,141.95 U11.3
  IN3 w0.089: v2(155.41,170.66) 155.54,170.53 155.54,167.92 152.48,164.87 148.32,164.87 146.37,162.92 146.37,154.8 149.3,151.87 149.3,147.89 147.85,146.44 147.85,145.42 147.39,144.96 147.39,143.58 147.69,143.29 147.69,143.01 v2(147.39,142.71)
  BOTTOM w0.089: v2(155.41,170.66) 155.5,170.75 155.5,170.99 155.45,171.05 JDOCK1.34
DPB_DOCK_AUX#: length 45.1
  TOP w0.089: U11.6 148.91,140.83 148.02,141.73 v2(148.02,142.71) 148.92,142.71 149.56,143.35 U11.8
  IN3 w0.089: v2(148.02,142.71) 148.02,143.43 147.72,143.72 147.72,144.82 148.18,145.28 148.18,146.31 149.63,147.75 149.63,152.01 146.7,154.94 146.7,162.79 148.46,164.54 152.62,164.54 155.87,167.79 155.87,170.53 v2(155.99,170.66)
  BOTTOM w0.089: v2(155.99,170.66) 155.9,170.75 155.9,170.99 155.95,171.05 JDOCK1.36
DPB_DOCK_HPD: length 94
  TOP w0.102: C311.1 R271.1 157.15,170.75 v2(157.01,170.62) 157.12,170.62 157.7,170.04 v1(158.46,170.04) ; U6.K14 123.02,108.82 123.86,109.67 123.86,110.16 124.4,110.7 v2(124.4,111.18)
  IN2 w0.102: v2(124.4,111.18) 125.77,112.55 126.22,112.55 132.58,118.9 134.46,118.9 136.64,121.08 136.64,123.06 137.23,123.65 145.3,123.65 v2(145.64,123.31)
  IN3 w0.102: v2(145.64,123.31) 145.64,123.75 146.15,124.26 146.15,134.61 151.04,139.5 151.04,151.95 147.31,155.68 147.31,162.54 148.71,163.94 153.28,163.94 157.45,168.1 157.45,170.25 157.09,170.62 v2(157.01,170.62)
  BOTTOM w0.102: JDOCK1.40 156.95,170.68 v2(157.01,170.62)
DPB_DOCK_LANE_N0: length 11.7
  TOP w0.089: v2(149.99,170.27) 149.9,170.18 149.9,167.06 149.52,166.68 v1(149.52,164.09) 149.52,160.79 R261.1
  BOTTOM w0.089: v2(149.99,170.27) 149.9,170.37 149.9,170.99 149.95,171.05 JDOCK1.12
DPB_DOCK_LANE_N1: length 11.8
  TOP w0.089: v2(151.49,170.27) 151.38,170.16 151.38,169.77 151.1,169.49 151.1,167.06 151.33,166.83 v1(151.33,164.85) 151.33,160.88 R256.1
  BOTTOM w0.089: JDOCK1.18 151.45,171.1 151.4,171.05 151.4,170.37 v2(151.49,170.27)
DPB_DOCK_LANE_N2: length 12.7
  TOP w0.089: v2(153.06,170.34) 153.04,170.32 153.04,169.98 154.18,168.83 154.18,165.19 v1(153.78,164.78) 152.95,163.95 152.95,161.94 153.26,161.62 153.26,160.85 R264.1
  BOTTOM w0.089: JDOCK1.24 152.95,171.06 152.96,171.05 152.96,170.43 v2(153.06,170.34)
DPB_DOCK_LANE_N3: length 12.6
  TOP w0.089: v2(154.56,170.21) 154.44,170.1 154.44,169.98 155.17,169.25 v1(155.17,166.2) 155.17,164.2 154.34,163.37 154.34,162.41 155.17,161.58 155.17,160.84 R267.1
  BOTTOM w0.089: JDOCK1.30 154.45,171.1 154.39,171.04 154.39,170.37 v2(154.56,170.21)
DPB_DOCK_LANE_P0: length 11.8
  TOP w0.089: v2(149.41,170.27) 149.5,170.18 149.5,167.22 149.12,166.84 149.12,160.9 R260.1
  BOTTOM w0.089: JDOCK1.10 149.45,171.05 149.5,170.99 149.5,170.37 v2(149.41,170.27)
DPB_DOCK_LANE_P1: length 11.8
  TOP w0.089: R254.1 150.94,160.81 150.94,166.67 150.71,166.9 150.71,169.65 150.99,169.93 150.99,170.2 v2(150.91,170.27)
  BOTTOM w0.089: JDOCK1.16 150.95,171.05 151,170.99 151,170.37 v2(150.91,170.27)
DPB_DOCK_LANE_P2: length 12.8
  TOP w0.089: v2(152.47,170.34) 152.64,170.17 152.64,169.81 153.79,168.67 153.79,165.35 152.55,164.11 152.55,161.78 152.87,161.46 152.87,160.84 R262.1
  BOTTOM w0.089: v2(152.47,170.34) 152.57,170.43 152.57,170.93 152.45,171.05 JDOCK1.22
DPB_DOCK_LANE_P3: length 12.6
  TOP w0.089: v2(153.97,170.21) 154.05,170.13 154.05,169.81 154.78,169.09 154.78,164.36 153.95,163.53 153.95,162.25 154.78,161.42 154.78,160.84 R258.1
  BOTTOM w0.089: JDOCK1.28 153.95,171.05 154,171 154,170.24 v2(153.97,170.21)
DPB_HPD: length 71.5
  TOP w0.102: U6.J1 123.54,99.03 v1(123.54,98.11) 123.54,97.54 123.86,97.22 123.86,95.23 123.41,94.77 123.41,91.32 v2(124.1,90.62)
  IN2 w0.102: v2(102.84,65.71) 100.59,65.71 99.36,66.94 99.36,68.66 97.45,70.58 97.45,82.4 99.62,84.57 101.38,84.57 103.16,86.35 105.14,86.35 108.34,89.55 117.39,89.55 118.18,90.34 123.09,90.34 123.37,90.62 v2(124.1,90.62)
  BOTTOM w0.076: UC1.C8 107.73,62.98 107.16,63.55 107.07,63.55 106.79,63.83 106.01,63.83 105.78,64.06 105.36,64.48 104.55,65.29 103.26,65.29 v2(102.84,65.71)
  BOTTOM w0.102: v2(102.84,65.71) 102.78,65.65 99.5,65.65 99.01,66.15 RC156.2
DPB_LANE_N0: length 67.3
  TOP w0.089: U6.E14 119.42,109.01 119.42,109.44 v2(119.81,109.83) ; C296.1 149.38,157.32 149.38,155.22 148.96,154.8 v1(148.96,152.33) 148.96,150.53 148.61,150.19 148.37,150.19 v2(148.18,150)
  IN1 w0.089: v2(119.81,109.83) 119.73,109.91 118.78,109.91 118.4,110.29 118.4,113.95 118.91,114.46 118.91,123.95 124.71,129.76 124.71,130.27 125.12,130.67 125.55,130.67 126.19,131.31 126.19,131.38 127.08,132.27 127.08,133.04 129.13,135.09 129.13,135.61 130.48,136.96 131.23,136.96 137.39,143.12 140.56,143.12 140.82,143.37 141.86,143.37 144.25,145.76 144.25,146.04 145.39,147.18 145.52,147.18 147.74,149.41 147.74,150.11 147.83,150.19 147.98,150.19 v2(148.18,150)
DPB_LANE_N0_C: length 1.1
  TOP w0.089: R261.2 C296.2
DPB_LANE_N1: length 68.1
  TOP w0.089: v2(150.4,151.36) 150.3,151.25 150.14,151.25 150.01,151.37 v1(150.01,153.85) 150.01,154.45 151.23,155.67 151.23,157.78 151.3,157.85 151.48,157.85 151.61,157.73 C303.1 ; v2(119.86,110.45) 119.87,110.46 120.28,110.46 120.42,110.32 U6.F14
  IN1 w0.089: v2(150.4,151.36) 150.4,151.33 150.18,151.1 149.86,151.1 149.5,150.75 149.5,149.29 147.02,146.8 146.47,146.8 144.39,144.72 144.05,144.72 142.07,142.74 141.45,142.74 141.2,142.49 137.62,142.49 130.86,135.73 130.61,135.73 129.01,134.12 129.01,132.89 126.42,130.31 126.12,130.31 119.5,123.69 119.5,113.32 119.02,112.84 119.02,111.07 119.39,110.7 119.61,110.7 v2(119.86,110.45)
DPB_LANE_N1_C: length 1.1
  TOP w0.089: R256.2 C303.2
DPB_LANE_N2: length 68.6
  TOP w0.089: v2(152.69,152.3) 152.5,152.11 151.95,152.11 151.8,152.25 151.8,154.27 153.09,155.55 v1(153.09,156.25) 153.09,157.66 153.19,157.76 153.39,157.76 C307.1 ; v2(121.34,109.83) 120.96,109.45 120.96,108.81 121.07,108.7 U6.G14
  IN1 w0.089: v2(121.34,109.83) 121.49,109.68 122.08,109.68 122.21,109.81 122.21,110.35 122.66,110.8 122.74,110.88 122.74,112.3 122.53,112.5 122.53,124.09 125.59,127.14 125.9,127.14 131.44,132.69 131.44,133.67 134.24,136.47 135.66,136.47 139.78,140.58 142.71,140.58 144.15,142.01 144.74,142.01 147.63,144.9 147.87,144.9 150.68,147.71 150.9,147.71 151.93,148.74 151.93,151.82 152.25,152.14 152.53,152.14 v2(152.69,152.3)
DPB_LANE_N2_C: length 1.1
  TOP w0.089: R264.2 C307.2
DPB_LANE_N3: length 68.1
  TOP w0.089: v2(152.65,153.24) 152.84,153.43 153.2,153.43 v1(154.73,154.95) 154.99,155.22 154.99,157.74 155.09,157.84 155.22,157.84 C309.1 ; v2(121.26,110.45) 121.27,110.46 121.54,110.46 121.72,110.29 U6.H14
  IN1 w0.089: v2(152.65,153.24) 152.49,153.39 152.26,153.39 151.33,152.47 151.33,149.04 150.69,148.4 150.49,148.4 147.61,145.52 146.97,145.52 144.12,142.68 143.96,142.68 142.5,141.22 138.15,141.22 130.85,133.91 130.85,132.94 125.77,127.85 125.45,127.85 121.94,124.34 121.94,110.98 121.66,110.7 121.51,110.7 v2(121.26,110.45)
DPB_LANE_N3_C: length 1.1
  TOP w0.089: R267.2 C309.2
DPB_LANE_P0: length 67.6
  TOP w0.089: U6.E13 119.77,108.13 120.09,108.45 120.09,108.79 119.81,109.07 v2(119.81,109.2) ; v2(148.18,150.58) 148.44,150.58 148.56,150.7 148.56,154.96 148.98,155.38 148.98,157.48 C294.1
  IN1 w0.089: v2(119.81,109.2) 119.43,109.58 118.65,109.58 118.07,110.15 118.07,114.09 118.58,114.59 118.58,124.09 124.38,129.9 124.38,130.4 124.98,131 125.41,131 125.86,131.45 125.86,131.52 126.75,132.4 126.75,133.17 128.8,135.23 128.8,135.75 130.34,137.29 131.09,137.29 137.25,143.45 140.43,143.45 140.68,143.7 141.72,143.7 143.92,145.9 143.92,146.17 145.26,147.51 145.38,147.51 147.41,149.54 147.41,150.24 147.69,150.52 148.12,150.52 v2(148.18,150.58)
DPB_LANE_P0_C: length 1.1
  TOP w0.089: R260.2 C294.2
DPB_LANE_P1: length 68.2
  TOP w0.089: C298.1 150.84,157.53 150.84,155.83 149.62,154.61 149.62,151.21 149.97,150.85 150.32,150.85 v2(150.4,150.77) ; U6.F13 120.42,108.13 120.74,108.45 120.74,110.54 120.24,111.03 v2(119.86,111.03)
  IN1 w0.089: v2(150.4,150.77) 149.99,150.77 149.83,150.61 149.83,149.15 147.15,146.47 146.61,146.47 144.53,144.39 144.19,144.39 142.21,142.41 141.59,142.41 141.33,142.15 137.76,142.15 131,135.4 130.75,135.4 129.34,133.99 129.34,132.76 126.56,129.98 126.26,129.98 119.83,123.55 119.83,113.18 119.35,112.7 119.35,111.2 119.52,111.03 v2(119.86,111.03)
DPB_LANE_P1_C: length 1.1
  TOP w0.089: R254.2 C298.2
DPB_LANE_P2: length 68.7
  TOP w0.089: C305.1 152.69,157.57 152.69,155.72 151.41,154.43 151.41,152.09 151.78,151.71 v1(151.95,151.71) v2(152.69,151.71) ; U6.G13 121.07,108.13 121.39,108.45 121.39,109.16 v2(121.34,109.2)
  IN1 w0.089: v2(121.34,109.2) 121.49,109.35 122.22,109.35 122.54,109.68 122.54,110.22 122.8,110.47 123.07,110.74 123.07,112.44 122.86,112.64 122.86,123.95 125.72,126.81 126.04,126.81 131.77,132.55 131.77,133.53 134.38,136.14 135.8,136.14 139.92,140.25 142.85,140.25 144.28,141.68 144.88,141.68 147.76,144.57 148,144.57 150.81,147.38 151.03,147.38 152.26,148.61 152.26,151.68 152.38,151.81 152.59,151.81 v2(152.69,151.71)
DPB_LANE_P2_C: length 1.1
  TOP w0.089: R262.2 C305.2
DPB_LANE_P3: length 68.1
  TOP w0.089: C308.1 154.6,157.57 154.6,155.38 153.04,153.82 v2(152.65,153.82) ; U6.H13 122.07,108.36 122.07,108.96 122.11,109 122.11,110.45 121.71,110.86 121.43,110.86 v2(121.26,111.03)
  IN1 w0.089: v2(152.65,153.82) 152.56,153.72 152.12,153.72 151,152.6 151,149.18 150.56,148.73 150.36,148.73 147.47,145.85 146.83,145.85 143.99,143.01 143.82,143.01 142.36,141.55 138.01,141.55 130.52,134.05 130.52,133.07 125.63,128.18 125.31,128.18 121.61,124.48 121.61,111.12 121.52,111.03 v2(121.26,111.03)
DPB_LANE_P3_C: length 1.1
  TOP w0.089: R258.2 C308.2
DPC_CA_DET: length 97.3
  TOP w0.102: v2(153.2,141.35) U13.4 ; v2(148.63,162.55) 148.36,162.82 R121.2 ; v2(151.83,141.38) 151.76,141.38 151.25,140.86 U13.1 151.25,138.91 v1(150.7,138.36) ; v2(116.69,109.15) 117.17,108.67 U6.A14 ; v2(154.53,148.45) 154.26,148.72 Q135.2
  IN2 w0.102: v2(146.15,123.63) 145.9,123.88 137.14,123.88 128.06,114.8 124.24,114.8 122.15,112.7 119.42,112.7 116.69,109.97 v2(116.69,109.15)
  IN3 w0.102: v2(153.2,141.35) 153.2,141.59 154.44,142.83 154.44,148.36 v2(154.53,148.45) ; v2(146.15,123.63) 146.47,123.94 146.47,134.29 151.83,139.66 v2(151.83,141.38) 151.83,142.58 151.4,143.02 151.4,152.73 149.43,154.7 149.43,156.99 148.63,157.79 v2(148.63,162.55)
  BOTTOM w0.102: JDOCK1.5 148.45,162.73 v2(148.63,162.55) ; v2(151.83,141.38) 151.83,141.32 151.87,141.35 v2(153.2,141.35)
DPC_CA_DET#: length 11
  TOP w0.102: U13.13 151.9,144.68 v2(152.08,144.49) ; v2(153.77,144.52) 153.85,144.59 U13.10 153.85,146.64 155.28,148.07 Q135.1 156.17,148.64 v1(156.17,149.05) 156.17,149.43 155.82,149.79 R164.1
  BOTTOM w0.102: v2(153.77,144.52) 153.69,144.59 152.19,144.59 v2(152.08,144.49)
DPC_DOCK_AUX: length 29.1
  TOP w0.089: U13.11 153.2,143.12 v2(152.88,142.8) 152.88,142.36 152.55,142.02 U13.3
  IN3 w0.089: v2(155.41,162.34) 155.52,162.23 155.52,161.73 152.55,158.76 152.55,154.79 153.22,154.13 153.22,145.86 152.89,145.54 152.89,142.93 152.88,142.92 v2(152.88,142.8)
  BOTTOM w0.089: v2(155.41,162.34) 155.56,162.49 155.56,162.81 155.45,162.92 JDOCK1.33
DPC_DOCK_AUX#: length 30
  TOP w0.089: U13.6 154.5,141.12 153.52,142.1 v2(153.52,142.79) 153.7,142.79 155.15,144.24 U13.8
  IN3 w0.089: v2(155.99,162.34) 155.85,162.19 155.85,161.59 152.88,158.62 152.88,154.93 153.55,154.26 153.55,145.73 153.22,145.4 153.22,143.1 153.52,142.8 v2(153.52,142.79)
  BOTTOM w0.089: v2(155.99,162.34) 155.95,162.38 JDOCK1.35
DPC_DOCK_HPD: length 95.7
  TOP w0.102: v2(114.08,103.75) 114.08,103.69 114.53,103.24 115.67,103.24 115.78,103.35 116.78,103.35 116.88,103.46 U6.A6
  IN2 w0.102: v2(114.08,103.75) 114.15,103.81 114.15,109.21 116.81,111.88 118.21,111.88 119.29,112.96 122.02,112.96 124.12,115.05 127.99,115.05 137.04,124.11 144.09,124.11 145.13,125.15 v2(150.02,125.15)
  IN3 w0.102: v2(150.02,125.15) 150.65,125.77 150.65,128.81 152.35,130.51 152.35,131.71 152.86,132.22 152.86,139.1 154.79,141.03 154.79,141.73 155.43,142.37 155.43,149.97 154.76,150.64 154.76,157.02 156.29,158.55 v2(157.01,158.55)
  BOTTOM w0.102: v2(157.01,158.55) C310.1 R268.1 156.91,159.67 157.38,160.28 v1(157.38,160.76) 157.38,161.96 156.95,162.39 JDOCK1.39
DPC_DOCK_LANE_N0: length 3.7
  BOTTOM w0.089: R252.2 149.48,160.82 149.48,161.99 149.9,162.41 149.9,162.86 149.95,162.92 JDOCK1.11
DPC_DOCK_LANE_N1: length 3.5
  BOTTOM w0.089: R255.2 151.4,160.81 151.4,162.86 151.45,162.92 JDOCK1.17
DPC_DOCK_LANE_N2: length 3.7
  BOTTOM w0.089: JDOCK1.23 152.95,162.92 152.9,162.86 152.9,162.53 153.26,162.17 153.26,160.86 R263.2
DPC_DOCK_LANE_N3: length 3.9
  BOTTOM w0.089: R266.2 155.2,160.82 155.2,161.43 154.69,161.93 154.4,162.23 154.4,162.86 154.45,162.92 JDOCK1.29
DPC_DOCK_LANE_P0: length 3.7
  BOTTOM w0.089: R259.2 149.09,160.87 v1(149.09,161.7) 149.09,162.16 149.5,162.57 149.5,162.86 149.45,162.92 JDOCK1.9
DPC_DOCK_LANE_P1: length 3.5
  BOTTOM w0.089: JDOCK1.15 150.95,162.92 151,162.86 v1(151,161.73) 151,160.88 R253.2
DPC_DOCK_LANE_P2: length 3.7
  BOTTOM w0.089: JDOCK1.21 152.45,162.92 152.5,162.86 152.5,162.36 152.86,162 v1(152.86,161.65) 152.86,160.83 R257.2
DPC_DOCK_LANE_P3: length 3.9
  BOTTOM w0.089: JDOCK1.27 153.95,162.92 154,162.86 154,162.06 v1(154.41,161.66) 154.81,161.26 154.81,160.87 R265.2
DPC_LANE_N0: length 84
  TOP w0.089: v2(115.99,103.73) 115.92,103.79 115.92,104.04 115.99,104.11 U6.A7
  IN1 w0.089: v2(115.99,103.73) 116.11,103.73 116.29,103.55 116.29,103.32 115.11,102.14 114.95,101.97 113.38,101.97 111.86,103.5 111.86,107.62 112.42,108.17 112.42,109.21 113.29,110.09 113.29,117.22 113.88,117.82 113.88,126.17 116.64,128.92 116.64,129.48 118.53,131.37 119.6,131.37 126.64,138.41 126.64,140 127.82,141.18 127.82,143.8 131.55,147.53 131.55,147.99 136.96,153.4 145.51,153.4 148.19,156.08 148.36,156.08 148.58,155.85 v2(148.58,155.83)
  BOTTOM w0.089: C295.2 149.39,157.33 149.39,156.46 148.95,156.02 148.77,156.02 v2(148.58,155.83)
DPC_LANE_N0_C: length 1.1
  BOTTOM w0.089: R252.1 C295.1
DPC_LANE_N1: length 83.3
  TOP w0.089: U6.A8 117.11,104.81 116.76,104.81 116.64,104.69 115.37,104.69 114.93,104.25 114.93,103.94 v2(114.74,103.75)
  IN1 w0.089: v2(114.74,103.75) 114.99,103.5 114.99,103.38 114.91,103.31 113.51,103.31 112.79,104.03 112.79,107.23 113.34,107.79 113.34,108.83 114.22,109.7 114.22,116.43 115.14,117.35 115.14,126.02 119.56,130.45 121.03,130.45 121.56,130.98 121.56,131.98 128.12,138.53 128.12,140.17 128.74,140.79 128.74,142.08 132.86,146.19 139.05,146.19 142.15,149.3 142.15,151.06 143.57,152.47 146.02,152.47 146.89,153.34 147.42,153.34 149.64,155.56 149.64,155.91 149.76,156.03 149.92,156.03 v2(150.17,155.78)
  BOTTOM w0.089: v2(150.17,155.78) 150.36,155.97 150.67,155.97 151.17,156.47 151.17,157.79 151.24,157.86 151.4,157.86 C299.2
DPC_LANE_N1_C: length 1.1
  BOTTOM w0.089: R255.1 C299.1
DPC_LANE_N2: length 79.7
  TOP w0.102: U6.A9 116.6,105.41 v2(116.56,105.45)
  IN1 w0.089: v2(116.56,105.45) 116.25,105.14 116.25,104.92 115.84,104.5 114.31,104.5 113.74,105.07 113.74,106.17 113.94,106.36 113.94,108.58 114.81,109.45 114.81,113.76 116.29,115.24 116.29,124.43 122.17,130.31 122.17,131.23 123,132.06 123,132.57 128.87,138.44 128.87,140.07 129.5,140.71 130.97,140.71 135.82,145.56 139.3,145.56 142.77,149.03 142.77,150.12 143.98,151.32 145.72,151.32 147.13,152.74 148.15,152.74 151.91,156.5 153.6,156.5 v2(153.73,156.63)
  BOTTOM w0.089: v2(153.73,156.63) 153.54,156.44 153.39,156.44 153.11,156.72 153.11,157.24 C306.2
DPC_LANE_N2_C: length 1.1
  BOTTOM w0.089: R263.1 C306.1
DPC_LANE_N3: length 78.4
  TOP w0.089: U6.A10 116.92,106.06 116.74,106.24 116.4,106.24 116.1,106.54 115.29,106.54 114.67,105.92 v2(114.67,105.46)
  IN1 w0.089: v2(155.63,156.36) 155.5,156.23 154.89,156.23 153.69,155.03 151.99,155.03 148.53,151.57 147.27,151.57 146.46,150.75 146.46,150.28 143.2,147.03 142.86,147.03 140.46,144.63 136.37,144.63 127.79,136.05 127.79,135.53 125.14,132.88 124.75,132.88 123.93,132.06 123.93,131.67 123.12,130.86 123.12,129.94 117.26,124.08 117.26,114.59 115.79,113.12 115.79,109.11 114.87,108.2 114.87,105.66 v2(114.67,105.46)
  BOTTOM w0.089: C301.2 155.07,157.29 155.07,156.33 155.23,156.17 155.44,156.17 v2(155.63,156.36)
DPC_LANE_N3_C: length 1.1
  BOTTOM w0.089: R266.1 C301.1
DPC_LANE_P0: length 84.3
  TOP w0.089: v2(116.62,103.73) 116.63,103.74 117.23,103.74 117.6,104.11 U6.B7
  IN1 w0.089: v2(116.62,103.73) 116.62,103.18 115.19,101.75 115.08,101.64 113.25,101.64 111.53,103.36 111.53,107.75 112.09,108.31 112.09,109.35 112.96,110.22 112.96,117.36 113.55,117.95 113.55,126.31 116.31,129.06 116.31,129.62 118.39,131.7 119.46,131.7 126.31,138.55 126.31,140.14 127.49,141.32 127.49,143.94 131.22,147.67 131.22,148.12 136.82,153.73 145.37,153.73 148.05,156.41 v2(148.58,156.41)
  BOTTOM w0.089: C302.2 149,157.47 149,156.62 148.79,156.41 v2(148.58,156.41)
