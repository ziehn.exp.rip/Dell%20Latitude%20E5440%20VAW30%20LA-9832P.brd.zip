# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3TP4_D+: length 4.2
  TOP w0.102: v2(171.02,170.23) 170.83,170.05 170.83,169.83 170.39,169.39 170.39,169.24 170.71,168.92 L56.2 170.71,168.3 R277.2
  BOTTOM w0.102: v2(171.02,170.23) 170.83,170.42 170.83,170.83 170.95,170.95 JDOCK1.92
USB_DB_DET#: length 126.8
  TOP w0.102: U37.A2 170.73,103.58 v2(170.37,103.94) ; R490.1 91.56,77.79 91.3,78.05 JUDB1.20 89.54,78.05 89.21,78.37 89.21,79.42 88.58,80.05 87.88,80.05 87.26,79.43 85.25,79.43 v2(85.13,79.56)
  IN1 w0.097: v2(170.37,103.94) 170.85,104.42 170.85,105.21 170.03,106.04 170.03,109.21 170.5,109.68 v2(170.5,110.54)
  IN2 w0.102: v2(170.5,110.54) 169.93,109.97 168.82,109.97 168.31,109.47 168.31,108.26 165.9,105.85 157.45,105.85 156.44,104.83 156.44,103.43 155.42,102.42 155.02,102.42 154.32,101.72 154.32,101.37 152.94,99.99 150.27,99.99 148.83,98.56 148.14,98.56 147.27,97.68 147.27,96.73 146.54,96 145.84,96 145.52,95.67 145,95.67 144.56,95.24 143.99,95.24 142.79,96.45 141.71,96.45 141.45,96.19 136.75,96.19 136.24,96.7 136.24,97.91 135.93,98.23 133.64,98.23 132.18,96.77 125.05,96.77 123.17,94.89 116.83,94.89 116.14,94.2 115.14,94.2 113.64,92.7 111.61,92.7 111.04,92.13 106.34,92.13 105.57,92.89 94.78,92.89 92.37,90.48 89.95,90.48 85.57,86.1 85.57,80 v2(85.13,79.56)
  BOTTOM w0.102: v1(84.77,79.02) 85.13,79.38 v2(85.13,79.56)
USB_DB_PWR_EN#: length 91.9
  TOP w0.102: v2(166.34,90.21) 166.34,89.8 R291.2 ; v2(167.9,93.78) 167.98,93.69 U37.B44 ; v2(91.84,85.13) 91.84,84.24 91.65,84.05 JUDB1.8
  IN1 w0.097: v2(167.9,93.78) 165.92,91.81 165.92,90.62 v2(166.34,90.21)
  IN3 w0.102: v2(166.34,90.21) 166.34,90 164.35,88.01 164.35,86.58 163.31,85.54 163.31,84.92 162.36,83.96 158.04,83.96 156.95,85.06 152.17,85.06 149.9,87.33 141.44,87.33 140.81,87.96 136.19,87.96 135.46,87.23 130.69,87.23 129.94,87.98 120.89,87.98 120.84,88.03 119.43,88.03 119.16,87.77 119.16,87.49 118.72,87.05 117.5,87.05 117.37,87.18 116.72,87.18 116.53,86.99 111.49,86.99 111.18,86.68 109.53,86.68 109.22,86.99 106.02,86.99 105.26,86.22 102.46,86.22 101.79,85.55 100.36,85.55 99.49,86.42 98.1,86.42 97.36,85.68 94.22,85.68 93.67,85.13 v2(91.84,85.13)
USB_MCARD1_DET#: length 273.3
  TOP w0.076: R459.2 112.15,69.41 v2(111.9,69.16)
  TOP w0.102: v2(173.65,98.94) 173.55,98.84 U37.A59
  IN2 w0.102: v2(290.3,154.17) 286.36,154.17 283.25,157.28 275.25,157.28 274.52,158 266.39,158 265.34,159.06 262.8,159.06 260.7,161.15 254.61,161.15 253.4,162.36 247.12,162.36 246.35,161.6 241.46,161.6 238.3,158.44 238.3,157.45 232.83,151.98 232.83,150.03 226.75,143.94 226.75,142.34 220.21,135.8 218.3,135.8 216.08,133.59 216.08,132.59 210.37,126.89 208.53,126.89 207.21,125.57 197.81,125.57 197.43,125.94 197.43,127.09 196.77,127.75 191.55,127.75 184.57,120.77 184.57,115.36 178.98,109.77 178.98,104.21 175.68,100.91 175.68,100.65 174.39,99.37 174.08,99.37 v2(173.65,98.94) 173.46,98.94 171.99,97.47 171.99,96.33 170.8,95.14 167.09,95.14 164.76,97.46 163.11,97.46 162.08,96.43 159.35,96.43 158.44,95.53 158.44,94.14 157.61,93.31 156.3,93.31 155.66,93.95 154.33,93.95 152.4,92.02 150.82,92.02 147.75,88.94 135.36,88.94 134.67,88.26 133.01,88.26 132.07,89.2 131.19,89.2 130.86,88.87 125.25,88.87 124.26,87.88 121.79,87.88 120.89,88.78 118.56,88.78 117.96,88.18 112.71,88.18 111.42,86.88 111.01,86.88 109.75,85.63 109.75,84.6 102.36,77.21 102.36,73.28 103.65,71.99 111.04,71.99 111.81,71.21 111.81,70.45 112.15,70.11 112.15,69.41 v2(111.9,69.16)
  BOTTOM w0.076: v2(111.9,69.16) 111.9,68.74 112.33,68.31 112.38,68.31 112.8,67.88 112.8,67.64 112.56,67.4 112.56,66.47 112.22,66.13 UC1.K3
  BOTTOM w0.102: JMINI1.40 293.06,150.9 290.3,153.66 v2(290.3,154.17)
USB_MCARD2_DET#: length 109
  TOP w0.102: U37.A18 v2(161.29,100.84) 160.69,100.84 159.78,99.93 RP5.4
  IN2 w0.102: v2(228.73,147.36) 226.26,144.9 226.26,142.5 220.02,136.26 218.11,136.26 215.59,133.75 215.59,132.83 210.38,127.61 197.56,127.61 196.96,128.21 191.25,128.21 184.06,121.02 184.06,115.68 176.82,108.44 176.82,106.78 172.55,102.51 172.55,100.55 171.37,99.37 170.2,99.37 169.8,98.96 167.09,98.96 165.9,100.16 164.98,100.16 164.15,100.99 161.44,100.99 v2(161.29,100.84)
  BOTTOM w0.102: JMINI2.40 226.38,147.9 226.92,147.36 v1(227.99,147.36) v2(228.73,147.36)
USB_OC0#: length 317.2
  TOP w0.102: RP10.1 116.87,86.49 v2(117,86.63) 116.4,87.24 v1(115.97,87.24)
  IN2 w0.102: v2(124.05,71.05) 123.48,71.62 122.53,71.62 121.69,72.45 121.69,73.96 121.49,74.16 121.49,76.14 121.21,76.42 121.21,77.79 121.68,78.26 121.68,80.29 122.97,81.59 126.84,81.59 127.72,82.47 127.72,85.02 v2(127.53,85.21)
  IN3 w0.102: v2(177.27,116.26) 176.82,115.82 176.25,115.82 175.97,115.54 175.97,113.05 176.45,112.56 176.45,110.18 175.74,109.47 175.74,99.75 175.49,99.49 175.49,94.1 173.77,92.38 170.04,92.38 168.96,91.3 168.96,89.98 167.23,88.26 167.23,86.99 166.66,86.41 166.66,86.2 165.37,84.9 164.79,84.9 162.78,82.88 157.64,82.88 157.17,83.35 154.77,83.35 154.14,83.99 151,83.99 149.47,85.53 144.74,85.53 144.45,85.82 140.96,85.82 140.22,86.56 136.79,86.56 136.05,85.82 128.14,85.82 v2(127.53,85.21) ; v2(312.65,164.9) 312.14,165.41 310.74,165.41 310.17,165.98 307.5,165.98 305.98,164.46 304.52,164.46 304.08,164.9 293.48,164.9 288.21,170.17 267.75,170.17 267.44,170.49 260.32,170.49 259.43,169.6 236.32,169.6 235.69,168.96 228.51,168.96 225.81,166.26 216.72,166.26 214.25,163.78 194.47,163.78 191.74,161.05 191.74,157.14 191.29,156.68 191.29,155.21 187.7,151.62 187.7,149.14 186.16,147.59 186.16,134.36 188.7,131.82 188.7,118.29 187.55,117.14 v2(187.55,115.82)
  BOTTOM w0.076: 124.05,69.84 124.05,69.08 123.43,68.46 123.43,67.54 123.22,67.33 123.22,67.1 123.43,66.88 123.67,66.88 123.79,66.77 123.79,66.17 UC1.AL3
  BOTTOM w0.102: 124.05,69.84 v2(124.05,71.05) ; v2(117,86.63) 119.2,86.63 120.15,85.68 123,85.68 123.61,86.29 123.61,86.99 122.97,87.62 122.97,89.34 123.23,89.59 123.86,89.59 127.53,85.92 v2(127.53,85.21) ; v2(177.27,116.26) 177.52,116.26 177.96,115.82 v2(187.55,115.82) ; JIO1.14 312.15,164.4 v2(312.65,164.9)
USB_OC1#: length 128.6
  TOP w0.102: RP12.3 131.16,72.7 129.77,71.31 v2(126.88,71.31)
  IN3 w0.102: v2(29.12,67.05) 36.55,67.05 37.36,67.86 71.88,67.86 73.87,69.85 75.44,69.85 75.6,69.7 76.53,69.7 78.96,72.13 80.17,72.13 81.28,73.23 87.08,73.23 87.52,72.79 88.44,72.79 88.89,73.23 88.89,73.68 89.81,74.6 93.53,74.6 93.72,74.79 93.72,75.73 94.09,76.1 98.13,76.1 100.5,73.73 101.68,73.73 104.05,71.36 109.08,71.36 110.72,73 113.39,73 114.19,72.2 118.63,72.2 118.92,72.49 120.46,72.49 121.77,71.19 123.27,71.19 123.57,71.49 126.71,71.49 v2(126.88,71.31)
  BOTTOM w0.076: 126.88,69.84 126.85,69.8 126.85,67.94 126.53,67.62 UC1.AT1
  BOTTOM w0.102: v2(29.12,67.05) 29.12,67.75 28.94,67.92 v1(27.56,67.92) 27.3,68.18 27.3,73.22 26.47,74.06 24.44,74.06 24.21,73.83 US1.5 ; 126.88,69.84 v2(126.88,71.31)
USB_OC2#: length 73.6
  TOP w0.102: v2(85.04,76.45) 84.62,76.86 84.62,79.75 84.94,80.07 85.36,80.07 85.8,80.51 85.8,81.06 88.3,83.55 JUDB1.9
  IN3 w0.102: v2(127.96,78.79) 127.96,78.62 129.45,77.13 129.45,74.4 127.3,72.25 122.82,72.25 v2(122.64,72.08) 122.2,72.08 120.05,74.22 115.72,74.22 115.06,73.57 110.64,73.57 108.89,71.82 104.24,71.82 101.87,74.19 100.69,74.19 96.76,78.11 93.58,78.11 92.79,77.32 85.91,77.32 v2(85.04,76.45)
  BOTTOM w0.076: 122.07,69.84 121.77,69.54 121.77,67.38 121.72,67.33 121.72,66.84 UC1.AH2
  BOTTOM w0.102: v2(127.96,78.79) 128.12,78.79 128.45,79.12 RP14.8 ; 122.07,69.84 122.27,70.04 122.27,70.68 122.64,71.05 v2(122.64,72.08)
USB_OC3#: length 5.3
  IN3 w0.102: v2(128.49,68.47) v2(128.49,69.27)
  BOTTOM w0.076: v2(128.49,68.47) 128.49,67.74 128.18,67.43 128.18,66.35 127.84,66.01 UC1.AV3
  BOTTOM w0.102: RP13.3 127.93,69.83 v2(128.49,69.27)
USB_PWR_SHR_EN#: length 217.3
  TOP w0.102: R391.2 167.06,107.62 166.47,108.21 166.47,108.19 v2(166.47,108.19) ; U37.B10 166.98,101.5 v2(167.72,100.77) ; v2(312.01,164.9) v1(311.44,164.9)
  IN1 w0.097: 166.47,108.19 165.77,108.89 165.77,111.95 169.35,115.54 171.18,115.54 172.32,116.67 177.74,116.67 v2(177.96,116.45) ; 166.47,108.19 v2(166.47,108.19) ; 166.47,108.19 166.47,107.94 167.23,107.18 167.23,102.54 167.35,102.42 167.35,101.14 v2(167.72,100.77)
  IN3 w0.102: v2(312.01,164.9) 310.87,164.9 310.04,165.73 307.63,165.73 306.11,164.2 304.39,164.2 303.95,164.65 293.41,164.65 288.2,169.85 267.69,169.85 267.31,170.23 260.45,170.23 259.56,169.35 236.45,169.35 235.81,168.71 228.64,168.71 225.93,166.01 216.85,166.01 214.38,163.53 194.6,163.53 192,160.93 192,157.07 191.52,156.59 191.52,155.11 187.93,151.53 187.93,149.03 186.41,147.51 186.41,134.48 188.95,131.94 188.95,117.85 188.16,117.05 v2(188.16,115.85)
  BOTTOM w0.102: v2(177.96,116.45) 178.09,116.32 187.68,116.32 v2(188.16,115.85) ; JIO1.12 v2(312.01,164.9)
USB_PWR_SHR_VBUS_EN#: length 201.8
  TOP w0.102: v2(181.77,91.62) 181.52,91.88 v1(181.14,91.88) R302.2 ; v2(170.79,93.78) 170.98,93.59 U37.B50
  IN2 w0.102: v2(181.77,91.62) 181.77,92.13 185.71,96.07 185.71,100.77 189.71,104.77 189.71,112.7 190.22,113.21 190.22,114.42 189.71,114.93 189.71,116.46 195.05,121.8 205.74,121.8 209.41,125.47 215.11,125.47 219.81,130.17 219.81,132.91 223.14,136.24 225.18,136.24 230.56,141.61 230.56,145.35 238.77,153.56 246.43,153.56 246.93,153.06 250.2,153.06 252.89,155.76 262.61,155.76 262.8,155.95 265.15,155.95 265.53,155.57 268.96,155.57 269.08,155.7 269.23,155.85 272.92,155.85 273.37,156.29 274.77,156.29 276.28,154.78 284.14,154.78 285.65,153.27 295.81,153.27 297.39,154.85 298.81,154.85 304.35,160.39 307.12,160.39 307.69,159.82 313.41,159.82 314.43,160.84 314.43,163.76 v2(313.28,164.9)
  BOTTOM w0.102: JIO1.10 312.78,165.4 v2(313.28,164.9) ; v2(170.79,93.78) 170.79,93.02 172.55,91.25 181.41,91.25 v2(181.77,91.62)
USB_SIDE_EN#: length 168.2
  TOP w0.102: v2(28.68,67.49) v1(27.98,67.49) ; v2(165.71,86.22) 165.59,86.11 164.1,86.11 163.82,86.39 163.82,87.51 164.41,88.1 164.41,88.93 R288.2 163.93,90.67 163.73,90.86 U37.A33
  IN3 w0.102: v2(28.68,67.49) 36.59,67.49 37.21,68.11 71.81,68.11 75.22,71.52 75.22,76.64 78.14,79.56 80.36,79.56 84.02,83.21 90.07,83.21 90.83,83.97 97.49,83.97 97.98,84.46 111.81,84.46 112.81,85.46 116.79,85.46 117.92,86.59 119.46,86.59 120.17,87.29 129.61,87.29 130.38,86.53 135.74,86.53 136.48,87.27 140.52,87.27 141.14,86.64 148.7,86.64 151.13,84.22 154.25,84.22 154.89,83.58 157.3,83.58 157.77,83.11 162.6,83.11 v2(165.71,86.22)
  BOTTOM w0.102: US1.4 24.21,69.59 24.46,69.84 26.52,69.84 26.9,69.46 26.9,68.05 27.46,67.49 v2(28.68,67.49)
USBP0+: length 262.7
  IN1 w0.076: v2(124.61,62.52) 124.84,62.75 124.84,64.11 125.18,64.44 126.52,64.44 126.58,64.51
  IN1 w0.097: v2(312.19,155.92) 311.47,155.92 310.3,157.09 310.3,158.11 309.22,159.19 302.02,159.19 295.55,152.71 277.28,152.71 275.94,151.38 272.26,151.38 269.28,154.36 263.37,154.36 262.5,155.23 262.5,156.1 258.8,159.8 253.76,159.8 253.32,159.35 244,159.35 241.89,157.24 241.89,157.18 241.87,157.16 238.17,157.16 236.55,155.55 236.55,154.19 231.1,148.74 228.21,148.74 227.61,148.14 224.91,148.14 219.76,142.99 218.48,142.99 214.14,138.65 214.14,136.94 212.04,134.84 212.04,132.63 209.61,130.2 201.96,130.2 200.94,129.18 189.54,129.18 185.5,125.15 184.19,125.15 183.84,124.8 177.04,124.8 174.49,122.25 168.35,122.25 167.53,121.42 159.46,121.42 158.32,120.28 156.96,120.28 153.58,116.9 153.58,106.14 153.67,106.05 153.67,99.43 151.97,97.73 151.97,96.41 151.06,95.5 151.06,93.37 149.02,91.32 145.62,91.32 145.15,90.86 143.57,90.86 140.03,87.33 139.71,87.33 137.97,85.59 137.97,84.64 134.16,80.83 134.16,79.11 133.46,78.4 130.75,78.4 129.76,77.41 129.76,71.99 127.91,70.14 127.91,68.29 126.69,67.06 126.69,64.61 126.58,64.51
  BOTTOM w0.076: UC1.AM8 124.29,62.84 v2(124.61,62.52)
  BOTTOM w0.102: v2(312.19,155.92) 312.01,155.73 311.49,155.73 311.32,155.9 JIO1.48
USBP0-: length 262.5
  IN1 w0.076: v2(125.26,62.52) 125.03,62.75 125.03,64.03 125.26,64.25 126.6,64.25 126.71,64.37
  IN1 w0.097: v2(312.19,155.33) 311.82,155.71 311.38,155.71 310.09,157 310.09,158.02 309.13,158.97 302.11,158.97 295.63,152.5 277.37,152.5 276.03,151.16 272.17,151.16 269.19,154.15 263.28,154.15 262.29,155.14 262.29,156.01 258.71,159.59 253.85,159.59 253.4,159.14 244.09,159.14 242.1,157.15 242.1,157.09 241.96,156.95 238.25,156.95 236.77,155.46 236.77,154.11 231.19,148.53 228.29,148.53 227.7,147.93 225,147.93 219.85,142.78 218.56,142.78 214.35,138.57 214.35,136.85 212.25,134.76 212.25,132.54 209.7,129.99 202.04,129.99 201.03,128.97 189.62,128.97 185.59,124.94 184.27,124.94 183.92,124.59 177.13,124.59 174.58,122.04 168.44,122.04 167.61,121.21 159.55,121.21 158.41,120.07 157.05,120.07 153.79,116.81 153.79,106.23 153.88,106.13 153.88,99.35 152.18,97.64 152.18,96.32 151.28,95.41 151.28,93.28 149.11,91.11 145.71,91.11 145.24,90.65 143.65,90.65 140.12,87.12 139.8,87.12 138.18,85.5 138.18,84.55 134.37,80.75 134.37,79.02 133.54,78.19 130.84,78.19 129.97,77.32 129.97,71.9 128.12,70.05 128.12,68.2 126.9,66.98 126.9,64.56 126.71,64.37
  BOTTOM w0.076: v2(125.26,62.52) 124.94,62.84 UC1.AN8
  BOTTOM w0.102: JIO1.50 311.37,155.4 311.49,155.52 312.01,155.52 v2(312.19,155.33)
USBP1+: length 119.2
  TOP w0.102: R249.1 23.13,75.52 L42.4 23.46,75.61 23.77,75.92 24.07,75.92 24.27,75.72 24.27,74.96 25.86,73.37 25.86,73.07 25.84,73.05 25.84,72.47 25.86,72.46 25.86,71.05 26.11,70.79 26.33,70.79 v2(26.52,70.61)
  IN3 w0.102: v2(26.52,70.61) 26.69,70.78 26.82,70.78 26.94,70.67 26.94,66.83 28.46,65.31 37.46,65.31 38.35,66.2 72.4,66.2 73.32,65.28 77.71,65.28 78.3,64.69 79.16,64.69 83.42,60.43 86.36,60.43 86.69,60.1 89.36,60.1 89.74,60.48 95.97,60.48 96.45,60 99.58,60 101.22,61.64 103.15,61.64 103.41,61.37 105.79,61.37 107.34,59.82 116.11,59.82 117.44,61.14 119.85,61.14 120.1,61.4 120.41,61.4 121.5,62.49 122.64,62.49 123.28,63.12 125.79,63.12 126.02,63.35 126.02,63.71 v2(126.17,63.87)
  BOTTOM w0.076: UC1.AT7 v2(126.17,63.87)
USBP1-: length 119
  TOP w0.102: v2(26.52,71.19) 26.33,71.01 26.2,71.01 26.07,71.14 v3(26.07,72.74) 26.07,73.46 24.48,75.05 24.48,75.81 24.16,76.14 23.77,76.14 23.46,76.46 L42.1 23.13,76.54 R251.1
  IN3 w0.102: v2(26.52,71.19) 26.7,71.01 26.9,71.01 27.15,70.76 27.15,66.92 28.55,65.52 37.38,65.52 38.26,66.41 72.49,66.41 73.41,65.5 77.8,65.5 78.39,64.91 79.25,64.91 83.51,60.65 86.45,60.65 86.78,60.32 89.27,60.32 89.65,60.7 96.06,60.7 96.54,60.21 99.49,60.21 101.13,61.85 103.24,61.85 103.5,61.59 105.88,61.59 107.43,60.03 116.02,60.03 117.35,61.36 119.76,61.36 120.01,61.61 120.32,61.61 121.41,62.7 122.55,62.7 123.19,63.34 125.7,63.34 125.78,63.42 125.78,63.75 125.66,63.87 v2(125.52,63.87)
  BOTTOM w0.076: UC1.AR7 v2(125.52,63.87)
USBP1_R_D+: length 9.5
  TOP w0.102: R249.2 21.6,75.52 L42.3 21.26,75.61 20.94,75.92 20.72,75.92 20.61,75.81 20.61,75.3 20.41,75.1 D18.2 19.56,75.85 19.45,75.96 19.03,75.96 18.21,75.14 16.85,75.14 16.24,75.75 15.72,75.75 15.24,75.26 JUSB1.3
USBP1_R_D-: length 9.5
  TOP w0.102: R251.2 21.6,76.54 L42.2 21.26,76.46 20.95,76.14 20.72,76.14 20.61,76.25 20.61,76.83 20.41,77.03 D18.3 19.56,76.27 19.45,76.17 18.94,76.17 18.12,75.35 16.94,75.35 16.33,75.96 15.76,75.96 15.24,76.48 JUSB1.2
USBP2+: length 81.6
  TOP w0.102: v2(91.78,80.51) 91.6,80.69 91.34,80.69 91.2,80.55 JUDB1.15
  IN1 w0.097: v2(138.66,84.82) 138.78,84.7 138.78,84.7 138.84,84.64 138.84,84.53 135.02,80.71 135.02,78.75 134.01,77.75 134.01,74.49 132.35,72.83 131.61,72.83 129.03,70.25 129.03,68.34 127.84,67.15 127.84,64.48 127.41,64.06 127.03,64.06 126.2,63.23 126.2,62.85 126.15,62.8 v2(125.87,62.52)
  IN3 w0.102: v2(91.78,80.51) 92.15,80.88 92.4,80.88 92.64,81.12 98.13,81.12 99.46,82.45 99.92,82.45 100.26,82.11 112.09,82.11 113.29,83.32 117.58,83.32 118.08,83.82 118.08,84.09 119.1,85.11 122.65,85.11 123.45,84.31 125.58,84.31 126.26,83.63 127.99,83.63 128.77,84.41 134.02,84.41 134.54,83.89 136.8,83.89 138.07,85.16 138.62,85.16 138.67,85.1 138.67,84.82 v2(138.66,84.82)
  BOTTOM w0.076: v2(125.87,62.52) 125.59,62.79 UC1.AP8
USBP2-: length 81.8
  TOP w0.102: JUDB1.14 91.2,81.05 91.34,80.91 91.6,80.91 v2(91.78,81.09)
  IN1 w0.097: v2(126.65,62.67) 126.65,62.67 126.41,62.9 126.41,63.14 127.12,63.85 127.5,63.85 128.05,64.39 128.05,67.06 129.24,68.26 129.24,70.16 131.7,72.61 132.43,72.61 134.22,74.4 134.22,77.66 135.23,78.67 135.23,80.62 139.05,84.45 139.05,84.62 v2(139.25,84.82)
  IN3 w0.102: v2(91.78,81.09) 92.31,81.09 92.55,81.33 98.04,81.33 99.37,82.67 100.01,82.67 100.35,82.32 112,82.32 113.2,83.53 117.49,83.53 117.87,83.91 117.87,84.18 119.01,85.32 122.74,85.32 123.53,84.53 125.67,84.53 126.35,83.85 127.9,83.85 128.68,84.62 134.11,84.62 134.63,84.1 136.71,84.1 137.98,85.37 138.71,85.37 138.82,85.26 138.82,85.24 v2(139.25,84.82)
  BOTTOM w0.076: UC1.AR8 126.48,62.67 v2(126.65,62.67)
USBP5+: length 152.3
  TOP w0.102: R2579.1 101.03,133.93 L52.4 101.68,133.93 101.95,134.21 101.95,134.36 101.99,134.4 102.44,134.4 102.89,133.94 102.89,133.67 102.88,133.66 102.88,133.13 102.89,133.11 102.89,119.97 103.33,119.54 103.83,119.54 104.52,118.85 106.42,118.85 106.53,118.74 106.53,118.64 v2(106.16,118.28)
  IN1 w0.097: v2(156.2,113.71) 156.21,113.71 156.49,113.42 156.49,113.21 156.23,112.95 156.23,112.79 155.97,112.53 155.97,109.19 156.25,108.91 156.25,107.81 157.15,106.91 157.15,103.23 156.44,102.52 156.44,98.2 156.1,97.86 156.1,95.98 155.27,95.15 155.27,93.24 149.75,87.72 144.16,87.72 142.14,85.7 142.14,84.89 137.56,80.31 137.56,75.03 136.92,74.39 136.92,73.48 133.11,69.67 133.11,68.09 132.28,67.26 130.63,67.26 130.25,66.88 130.25,63.24 128.6,61.59 128.6,60.15 128.2,59.74 127.42,59.74 126.96,59.29 124.26,59.29 123.96,59.58 123.96,59.79 124.24,60.07 v2(124.38,60.07)
  BOTTOM w0.076: v2(124.38,60.07) 124.38,59.87 UC1.AN13
  BOTTOM w0.102: v2(156.2,113.71) 156.22,113.71 156.43,113.91 156.43,114.14 156.06,114.51 152.83,114.51 151,112.68 146.95,112.68 146.57,113.06 134.95,113.06 132.92,115.09 125.75,115.09 124.68,116.17 123.58,116.17 123.49,116.26 120.52,116.26 120.34,116.44 111.69,116.44 110.35,117.78 108.81,117.78 108.6,117.57 106.63,117.57 106.35,117.85 106.35,118.09 v2(106.16,118.28)
USBP5-: length 152.6
  TOP w0.102: R2580.1 101.03,134.78 L52.1 101.68,134.78 101.85,134.61 102.53,134.61 103.11,134.03 v3(103.11,133.39) 103.11,120.06 103.42,119.75 103.92,119.75 104.61,119.07 106.51,119.07 106.75,118.83 v2(106.75,118.28)
  IN1 w0.097: v2(123.73,60.07) 123.73,60.07 123.73,59.52 123.75,59.5 124.18,59.07 127.04,59.07 127.5,59.53 128.28,59.53 128.81,60.06 128.81,61.5 130.46,63.15 130.46,66.79 130.72,67.05 132.37,67.05 133.32,68 133.32,69.59 137.13,73.4 137.13,74.31 137.77,74.94 137.77,80.23 142.35,84.81 142.35,85.61 144.24,87.5 149.84,87.5 155.49,93.15 155.49,95.07 156.31,95.89 156.31,97.77 156.65,98.11 156.65,102.43 157.36,103.14 157.36,107 156.46,107.9 156.46,109 156.18,109.27 156.18,112.44 156.44,112.7 156.44,112.86 156.7,113.12 156.7,113.63 v2(156.78,113.71)
  BOTTOM w0.076: v2(123.73,60.07) 123.96,59.84 UC1.AM13
  BOTTOM w0.102: v2(106.75,118.28) 106.57,118.09 106.57,117.94 106.72,117.78 108.51,117.78 108.72,118 110.44,118 111.78,116.65 120.43,116.65 120.61,116.48 123.58,116.48 123.67,116.39 124.76,116.39 125.84,115.31 133.01,115.31 135.04,113.28 146.66,113.28 147.04,112.89 150.91,112.89 152.74,114.72 156.15,114.72 156.64,114.23 156.64,113.85 v2(156.78,113.71)
USBP5_D+: length 6.7
  TOP w0.102: R2579.2 100.08,133.93 L52.3 99.47,133.93 99.07,134.33 98.87,134.33 98.12,135.09 98.12,135.55 98.11,135.56 98.11,136.1 98.12,136.11 98.12,136.67 97.22,137.57 96.74,137.57 96.6,137.42 JLVDS1.7
USBP5_D-: length 6.6
  TOP w0.102: R2580.2 100.08,134.78 L52.2 99.42,134.78 99.19,134.55 98.96,134.55 98.34,135.18 v3(98.34,135.83) 98.34,136.76 97.31,137.78 96.74,137.78 96.6,137.92 JLVDS1.6
USBP6+: length 89.4
  TOP w0.102: v2(84.33,89.84) 84.14,89.65 83.56,89.65 83.32,89.89 80.25,89.89 80.16,89.99 80.16,90.46 80.47,90.78 L58.1 80.47,91.34 ; 80.47,91.34 80.47,91.4 R2588.1 80.47,91.34
  IN3 w0.076: 122.03,60.71 122.05,60.71 122.06,60.72 122.73,60.72 123.01,61 125.24,61 125.35,60.89 125.35,60.73 v2(125.17,60.55)
  IN3 w0.102: 122.03,60.71 121.22,60.71 120.34,59.83 117.66,59.83 116.43,58.6 113.89,58.6 113.65,58.84 107.28,58.84 105.52,60.6 101.22,60.6 99.8,59.17 93.72,59.17 93.51,59.39 86.38,59.39 86.05,59.72 83.12,59.72 79.39,63.45 78.09,63.45 77.67,63.87 77.67,64.08 v2(77.49,64.27)
  BOTTOM w0.076: UC1.AN11 124.94,60.85 125.17,60.62 v2(125.17,60.55)
  BOTTOM w0.102: v2(84.33,89.84) 84.14,89.65 83.91,89.65 83.67,89.41 83.67,88.86 84.56,87.98 84.56,84.57 84.4,84.42 84.4,79.66 82.14,77.4 81.2,77.4 78.14,74.34 78.14,68.51 77.66,68.03 v3(77.66,66.71) 77.66,64.44 v2(77.49,64.27)
USBP6-: length 89.3
  TOP w0.102: v2(84.33,89.25) 84.14,89.44 83.47,89.44 83.23,89.67 80.16,89.67 79.94,89.9 79.94,90.46 79.62,90.78 L58.4 79.62,91.4 R2594.1
  IN3 w0.076: 122.03,60.93 122.05,60.93 122.06,60.91 122.65,60.91 122.93,61.19 125.32,61.19 125.54,60.97 125.54,60.82 v2(125.81,60.55)
  IN3 w0.102: 122.03,60.93 121.13,60.93 120.25,60.05 117.58,60.05 116.34,58.82 113.98,58.82 113.74,59.06 107.37,59.06 105.61,60.81 101.13,60.81 99.71,59.39 93.81,59.39 93.6,59.6 86.47,59.6 86.14,59.94 83.21,59.94 79.48,63.67 78.18,63.67 77.89,63.96 77.89,64.08 v2(78.07,64.27)
  BOTTOM w0.076: v2(125.81,60.55) 125.59,60.77 UC1.AP11
  BOTTOM w0.102: v2(78.07,64.27) 77.88,64.46 77.88,66.32 77.9,66.34 77.9,67.02 77.88,67.04 77.88,67.94 78.36,68.42 78.36,74.25 81.29,77.18 82.23,77.18 84.62,79.57 84.62,84.33 84.77,84.48 84.77,88.07 83.88,88.95 83.88,89.32 84,89.44 84.14,89.44 v2(84.33,89.25)
USBP6_D+: length 9.6
  TOP w0.102: 80.47,92.42 80.47,92.35 R2588.2 80.47,92.42 ; 80.47,92.42 L58.2 80.47,92.97 80.15,93.3 80.15,93.59 79.21,94.53 79.21,94.91 78.31,95.82 78.31,96.24 78.41,96.35 79.04,96.35 D88.2 79.04,96.6 78.41,96.6 78.31,96.7 78.31,97.04 77.51,97.84 77.51,98.08 77.81,98.37 JTS1.3
USBP6_D-: length 9.5
  TOP w0.102: JTS1.2 77.01,98.37 77.29,98.09 77.29,97.75 78.09,96.95 78.09,96.69 78,96.6 77.37,96.6 D88.3 77.37,96.35 78,96.35 78.09,96.26 78.09,95.73 79,94.82 79,94.44 79.94,93.5 79.94,93.29 79.62,92.97 L58.3 79.62,92.35 R2594.2
USBP7+: length 90.5
  TOP w0.102: v2(161.63,118.93) 161.76,119.07 162.86,119.07 163.45,118.48 163.45,117.94 164.44,116.94 165.47,116.94 165.67,116.74 165.67,115.58 166,115.25 166.33,115.25 166.51,115.07 L72.1 167.33,115.07 R2694.1
  IN1 w0.097: v2(124.94,60.03) 125.07,60.03 125.57,59.53 126.61,59.53 126.95,59.87 126.95,60.42 129.39,62.86 129.39,66.52 132.37,69.5 132.37,69.65 135.84,73.12 135.84,74.04 136.65,74.85 136.65,80.08 141.6,85.03 141.6,85.84 144.82,89.05 150.41,89.05 153.83,92.48 153.83,94.42 154.47,95.05 154.47,96.94 155.77,98.24 155.77,102.71 156.59,103.52 156.59,106.38 155.72,107.24 155.72,108.64 155.29,109.07 155.29,112.53 155.72,112.96 155.72,115.24 159.6,119.12 161.44,119.12 v2(161.63,118.93)
  BOTTOM w0.076: v2(124.94,60.03) 125.26,59.71 UC1.AP13
USBP7+_D: length 6
  TOP w0.102: R2694.2 168.28,115.07 L72.2 168.87,115.07 169.13,115.33 169.42,115.33 170.13,116.04 171.01,116.04 171.48,116.51 171.48,116.53 171.78,116.83 171.78,117.87 171.82,117.91 U90.31
USBP7-: length 90.6
  TOP w0.102: v2(161.63,119.52) 161.87,119.28 162.95,119.28 163.66,118.57 163.66,118.03 164.53,117.16 165.56,117.16 165.89,116.83 165.89,115.67 166.09,115.47 166.24,115.47 166.34,115.57 166.34,115.86 166.41,115.92 166.41,115.92 L72.4 167.33,115.92 R2697.1
  IN1 w0.097: v2(161.63,119.52) 161.44,119.33 159.51,119.33 155.51,115.33 155.51,113.04 155.08,112.62 155.08,108.98 155.51,108.55 155.51,107.16 156.37,106.29 156.37,103.61 155.56,102.79 155.56,98.32 154.26,97.02 154.26,95.14 153.62,94.5 153.62,92.57 150.32,89.26 144.73,89.26 141.39,85.93 141.39,85.12 136.44,80.17 136.44,74.94 135.63,74.13 135.63,73.21 132.16,69.74 132.16,69.59 129.18,66.61 129.18,62.95 126.74,60.51 126.74,59.95 126.53,59.74 125.66,59.74 125.59,59.81 v2(125.59,60.03)
  BOTTOM w0.076: UC1.AR13 125.78,59.51 125.65,59.51 125.55,59.6 125.55,60 v2(125.59,60.03)
USBP7-_D: length 5.7
  TOP w0.102: U90.30 171.32,118.02 171.56,117.78 171.56,116.92 v3(171.12,116.47) 170.9,116.26 170.04,116.26 169.33,115.55 169.21,115.55 168.84,115.92 L72.3 168.28,115.92 R2697.2
USBRBIAS: length 12.6
  TOP w0.102: v2(131.55,61.97) 131.7,61.81 RC159.1
  IN2 w0.102: v2(123.31,60.62) 123.63,60.95 126.59,60.95 127.58,59.96 128.62,59.96 128.8,60.14 130.56,60.14 131.55,61.13 v2(131.55,61.97)
  BOTTOM w0.076: v2(123.31,60.62) 123.19,60.75 UC1.AJ11 UC1.AJ10
USH_SMBCLK: length 46.3
  TOP w0.102: v2(138.72,107.56) 138.91,107.56 139.41,107.06 U38.A50 ; v2(166.85,124.7) 166.07,123.93 QC4.6 ; R491.2 137.78,113.06 137.78,112.43 138.18,112.03 139.22,112.03 v2(139.4,111.85)
  IN1 w0.097: v2(166.85,124.7) 166.61,124.95 163.7,124.95 161.65,122.89 159.27,122.89 158.34,123.82 154.33,123.82 150.69,120.18 150.69,118.77 149.92,118 144.68,118 141.9,115.23 141.9,113.35 140.59,112.03 139.58,112.03 v2(139.4,111.85)
  IN3 w0.102: v2(139.4,111.85) 139.7,111.55 139.7,108.03 139.23,107.56 v2(138.72,107.56)
USH_SMBDAT: length 46.1
  TOP w0.102: v2(139.4,112.44) 139.22,112.26 v3(138.61,112.26) 138.28,112.26 138.01,112.53 138.01,113.06 R492.2 ; QC4.3 166.98,125.23 v2(166.86,125.34) ; U38.B53 141.06,107.31 v2(141.2,107.17)
  IN1 w0.097: v2(166.86,125.34) 166.7,125.17 163.61,125.17 161.56,123.12 159.36,123.12 158.44,124.04 154.24,124.04 150.47,120.27 150.47,118.86 149.83,118.22 144.58,118.22 141.68,115.32 141.68,113.44 140.5,112.26 139.58,112.26 v2(139.4,112.44)
  IN3 w0.102: v2(141.2,107.17) 141.2,107.18 141.2,107.18 141.07,107.31 140.57,107.31 139.93,107.95 139.93,111.9 v2(139.4,112.44)
USX2064_RBIAS:
  vias: v1(174,117.28)
USX_SCL: length 8.2
  TOP w0.102: QC4.1 167.46,123.93 166.71,123.18 165.58,123.18 165.4,123 R2692.1 165.58,122.55 166.34,121.78 R2696.2 166.34,121.21 166.65,120.9 v1(166.8,120.9) U90.24
USX_SDA: length 9.4
  TOP w0.102: U90.22 168.7,121.9 168.25,122.36 168.25,123.63 168.88,124.26 168.88,125.4 v1(168.55,125.73) 167.81,126.47 R2693.1 R2698.2 165.79,126.36 QC4.4
V_SYS: length 53.6
  TOP w0.102: v2(129.13,106.23) 129.43,105.92 v1(129.68,105.92) R381.2
  TOP w0.254: v2(113.89,143.37) 113.89,143.95 114.46,144.52 PC424.1 114.39,144.71 113.51,144.71 113.31,144.91 PU402.7
  IN3 w0.102: v2(129.13,106.23) 129.49,106.59 129.49,113.07 125.5,117.06 125.5,122.39 126.4,123.3 126.4,132.5 124.18,134.73 124.18,135.38 121.02,138.54 120.94,138.54 120.11,139.37 120.11,141.73 119.58,142.26 118.18,142.26 117.06,141.14 115.87,141.14 113.89,143.12 v2(113.89,143.37)
VCI_IN2#: length 7.9
  TOP w0.102: RP17.4 140.13,96.89 v2(140.03,96.99) ; U38.B63 141.24,102.31 v2(141.23,102.33)
  IN1 w0.097: v2(141.23,102.33) 141.23,101.92 140.79,101.49 140.79,97.76 v2(140.03,96.99)
  BOTTOM w0.102: v2(141.23,102.33) v1(140.62,102.33)
VCP: length 89.1
  TOP w0.102: U38.A12 146.89,98.01 146.96,97.94 146.96,97.4 v2(146.56,96.99)
  TOP w0.254: PR441.1 114.91,126.37 114.91,126.86 114.59,127.18 v2(113.7,127.18) 113.32,127.18 113.07,126.93 v1(112.34,126.93) 111.9,126.93 111.78,127.04 PR402.1 110.96,127.94 110.92,127.91 PU403.1 108.65,127.91 108.44,128.11 108.44,129 108.62,129.18 PU403.2
  IN1 w0.097: v2(146.56,96.99) 146.53,96.99 145.97,97.55 145.97,98.87 145.56,99.28 145.56,101.65 147.87,103.96 147.87,106.99 148.63,107.75 149.77,107.75 150.39,108.37 150.39,111.99 151.23,112.83 151.23,115.58 155.55,119.89 v2(155.55,121.15)
  IN2 w0.254: v2(113.7,127.18) 113.7,124.07 v2(115.61,122.17)
  BOTTOM w0.102: v2(115.61,122.17) 115.73,122.29 121.2,122.29 122.12,123.22 128.09,123.22 128.24,123.37 129.26,123.37 130.22,122.41 132.08,122.41 132.59,121.9 137.27,121.9 137.55,121.62 146.44,121.62 147.47,120.59 154.98,120.59 v2(155.55,121.15)
VCP_1: length 3.3
  TOP w0.254: PR404.2 PR405.1 111.06,130.45 PU403.3
VCT_LAN_R1: length 2.9
  TOP w0.102: R175.2 177.45,133.66 177.77,133.98 178.13,133.98 v1(178.5,134.35) 178.52,134.37 178.52,135.04 178.5,135.06 U21.6
VFB: length 3.6
  BOTTOM w0.203: PU300.24 48.36,19.74 48.27,19.83 47.37,19.83 46.94,19.4 v1(46.94,19.13) 46.47,18.66 PR334.2
VGA_DET: length 4.7
  TOP w0.102: R74.2 127.3,99.11 127.11,99.31 v1(126.2,99.31) 125.71,99.31 124.95,100.07 124.95,100.7 124.32,101.33 U6.M3
VGA_ID: length 8.5
  TOP w0.102: R317.1 175.28,99.06 v1(175.42,98.92) ; R317.1 R320.2 ; R317.1 174.85,99.94 174.7,99.78 v2(174.23,99.78) ; v2(171.09,97.17) 171.17,97.09 U37.B59
  IN3 w0.102: v2(171.09,97.17) 171.09,97.17 171.09,97.45 172.99,99.34 173.82,99.34 174.23,99.76 v2(174.23,99.78)
VGA_IREF: length 3.6
  TOP w0.102: U6.M5 124.44,102.81 124.58,102.67 125.31,102.67 v1(125.87,102.1) 126.07,101.91 R2705.1
VIDALERT_N: length 76.8
  IN3 w0.102: v2(53.5,21.52) 53.5,21.34 55.45,19.4 55.45,15.94 58.44,12.95 71.45,12.95 71.7,13.2 84.24,13.2 85.19,14.15 87.22,14.15 88.18,15.1 91.52,15.1 92.58,16.17 99.08,16.17 101.13,18.22 102.34,18.22 102.53,18.41 104.14,18.41 104.65,18.91 107.61,18.91 109,20.31 110.34,20.31 110.72,20.69 114.13,20.69 116.48,18.34 v2(116.61,18.34)
  BOTTOM w0.102: v2(116.61,18.34) 116.32,18.34 RC248.2 115.94,17.93 RC244.2 ; v2(53.5,21.52) 53,21.01 52.42,21.01 52.24,20.82 PU300.32
VIDSCLK: length 90.7
  IN3 w0.102: v2(52.68,21.52) 52.68,21.26 54.89,19.05 54.89,15.69 58.19,12.39 71.7,12.39 71.94,12.63 86.65,12.63 88.56,14.53 91.76,14.53 92.84,15.61 99.75,15.61 101.33,17.2 104.18,17.2 105,18.03 108.15,18.03 108.41,18.28 108.41,18.76 108.81,19.17 110.46,19.17 111.42,20.12 113.89,20.12 116.31,17.71 v2(116.61,17.71)
  BOTTOM w0.076: UC1.N63 113.72,27.54 114.27,26.98
  BOTTOM w0.102: 114.27,26.98 114.27,23.91 115.65,22.54 115.65,20.18 116.25,19.58 117.04,19.58 117.19,19.43 v1(117.19,18.91) 117.19,17.9 117,17.71 v2(116.61,17.71) ; PU300.31 51.84,20.93 52.12,21.21 52.55,21.21 52.68,21.34 v2(52.68,21.52) 52.68,22.65 PR331.2
VIDSOUT: length 95.7
  IN3 w0.102: v2(54.14,21.52) 54.14,21.5 56.01,19.63 56.01,16.2 58.7,13.5 63.94,13.5 64.06,13.63 64.06,14.1 64.18,14.22 64.35,14.22 64.47,14.1 64.47,13.63 64.6,13.5 64.75,13.5 64.88,13.63 64.88,14.22 65,14.34 65.16,14.34 65.28,14.22 65.28,13.62 65.4,13.5 65.57,13.5 65.69,13.62 65.69,14.49 65.79,14.6 66,14.6 66.1,14.49 66.1,13.62 66.22,13.5 66.38,13.5 66.5,13.62 66.5,14.49 66.6,14.6 66.81,14.6 66.91,14.49 66.91,13.63 67.04,13.5 67.19,13.5 67.32,13.63 67.32,14.49 67.42,14.6 67.62,14.6 67.72,14.49 67.72,13.7 67.84,13.58 68.01,13.58 68.13,13.7 68.13,14.41 68.25,14.53 68.42,14.53 68.54,14.41 68.54,13.61 68.64,13.5 68.84,13.5 68.94,13.61 68.94,14.54 69.06,14.66 69.23,14.66 69.35,14.54 69.35,13.61 69.45,13.5 71.21,13.5 71.47,13.77 83.98,13.77 85.06,14.85 86.97,14.85 87.96,15.84 91.44,15.84 92.33,16.73 98.69,16.73 100.88,18.91 101.49,18.91 102.13,19.55 107.23,19.55 109.57,21.9 113.23,21.9 v2(113.83,22.5)
  BOTTOM w0.076: 113.16,25.9 113.16,26.83 112.66,27.32 112.66,28.03 112.97,28.34 UC1.L63
  BOTTOM w0.102: PR330.2 53.76,21.96 54.14,21.58 v2(54.14,21.52) 54.14,21.14 53.57,20.57 53.57,20.11 53.2,19.74 PU300.1 ; 113.16,25.9 v1(113.16,25.19) 113.16,23.42 113.83,22.74 v2(113.83,22.5) 114.1,22.5 114.42,22.18 114.42,20.8 114.53,20.69 114.53,19.37 RC249.2
VMM2310_BLU: length 77.7
  TOP w0.102: U39.5 158.77,149.79 159.11,149.45 v1(159.11,147.17) 159.11,144.7 v2(160.06,143.76) ; U6.M8 124.48,104.76 v2(124.74,105.02) 124.74,105.14 125.89,106.29 R351.1
  IN2 w0.102: v2(160.06,143.76) 159.49,144.33 158.47,144.33 156.82,142.68 156.82,141.6 155.43,140.21 155.43,131.83 154.15,130.55 154.15,123.18 155.99,121.34 155.99,120.69 153.08,117.78 146.6,117.78 145.29,116.47 135.22,116.47 127.57,108.82 125.13,106.38 125.13,105.4 124.75,105.02 v2(124.74,105.02)
VMM2310_CLK_DDC2: length 79.7
  TOP w0.089: U39.10 160.77,149.97 161.01,149.72 162.14,149.72 163.11,148.75 163.11,144.47 161.05,142.42 v2(161.05,142.09) ; U6.L4 123.74,102.16 124.05,101.85 124.65,101.85 126.56,99.94 130.35,99.94 130.8,99.5 v2(132.37,99.5)
  IN1 w0.089: v2(161.05,142.09) 161.05,141.55 160.5,141 159.29,141 157.77,139.48 157.77,139.48 156.28,137.99 156.28,134.1 147.85,125.67 145.97,125.67 143.89,123.58 142.31,123.58 138.63,119.9 137.91,119.9 137.15,119.13 137.15,118.35 135.21,116.41 135.21,109.91 136.31,108.81 136.31,107.27 135.75,106.71 135.75,104.09 134.64,102.97 134.64,101.27 132.86,99.5 v2(132.37,99.5)
VMM2310_DAT_DDC2: length 79.7
  TOP w0.089: U39.9 160.37,150.67 160.37,149.8 160.85,149.33 161.97,149.33 162.71,148.59 162.71,144.63 160.66,142.58 160.66,142.28 v2(160.47,142.09) ; U6.M4 124.15,102.16 124.05,102.25 124.05,102.39 124.15,102.48 124.53,102.48 124.59,102.42 124.76,102.42 124.89,102.29 124.89,102.16 126.72,100.33 130.52,100.33 130.96,99.89 132.18,99.89 v2(132.37,100.08)
  IN1 w0.089: v2(160.47,142.09) 160.72,141.84 160.72,141.69 160.36,141.33 159.15,141.33 157.63,139.81 157.63,139.81 155.95,138.13 155.95,134.24 147.71,126 145.84,126 143.75,123.91 142.17,123.91 138.49,120.23 137.78,120.23 136.82,119.27 136.82,118.48 134.88,116.55 134.88,109.77 135.98,108.67 135.98,107.41 135.42,106.85 135.42,104.22 134.31,103.11 134.31,101.41 132.73,99.83 132.63,99.83 v2(132.37,100.08)
VMM2310_GRN: length 78.5
  TOP w0.102: U6.M7 124.51,103.92 125.68,103.92 v2(126.47,104.7) 126.91,104.26 126.91,103.94 127.16,103.69 129.15,103.69 R312.1 ; U39.2 157.57,150.24 157.11,149.79 157.11,145.31 v1(158.35,144.07) 158.66,143.76 v2(158.79,143.76)
  IN2 w0.102: v2(158.79,143.76) 158.28,143.76 157.07,142.55 157.07,141.47 155.68,140.07 155.68,131.69 154.41,130.42 154.41,123.31 156.25,121.47 156.25,120.58 152.96,117.29 151.88,117.29 151.5,116.91 150.9,116.91 150.33,117.48 146.62,117.48 145.38,116.24 135.32,116.24 126.47,107.39 v2(126.47,104.7)
VMM2310_HSYNC: length 73.1
  TOP w0.102: v2(124.74,105.85) 124.74,105.83 U6.M9 ; U39.6 159.17,149.81 159.34,149.64 159.34,147.9 160.12,147.12 v1(160.12,145.69) v2(160.12,145.15)
  IN2 w0.102: v2(160.12,145.15) 158.55,145.15 156.25,142.85 156.25,141.85 154.91,140.52 154.91,132.07 153.64,130.8 153.64,122.93 154.85,121.72 154.85,120.26 152.88,118.29 145.63,118.29 144.27,116.93 134.98,116.93 127.42,109.38 126.24,109.38 124.37,107.51 124.37,106.21 v2(124.74,105.85)
VMM2310_RED: length 80.7
  TOP w0.102: v2(159.42,143.76) 159.02,143.35 158.36,143.35 v1(156.98,144.72) 156.88,144.82 156.88,149.91 157.17,150.2 U39.1 ; R311.1 129.02,103.43 127.04,103.43 126.47,104 v2(126.47,104.07) 126.08,103.69 124.55,103.69 U6.M6
  IN2 w0.102: v2(126.47,104.07) 126.87,104.47 126.87,105.02 126.72,105.17 126.72,107.32 135.41,116.02 145.54,116.02 146.73,117.21 150.21,117.21 150.79,116.64 151.61,116.64 151.99,117.02 153.07,117.02 156.5,120.45 156.5,121.59 154.66,123.44 154.66,130.29 155.93,131.56 155.93,139.95 157.39,141.41 157.39,142.49 158.22,143.31 158.98,143.31 v2(159.42,143.76)
VMM2310_VSYNC: length 73.9
  TOP w0.102: v2(160.76,145.15) 160.76,147.03 v1(160.57,147.22) 159.57,148.22 U39.7 ; v2(124.75,106.43) 124.7,106.38 124.21,106.38 123.99,106.16 123.99,105.73 U6.L9
  IN2 w0.102: v2(160.76,145.15) 160.31,144.71 158.47,144.71 156.5,142.74 156.5,141.66 155.17,140.33 155.17,131.94 153.9,130.67 153.9,123.05 155.1,121.85 155.1,120.13 153.01,118.04 145.7,118.04 144.37,116.7 135.13,116.7 127.58,109.15 126.34,109.15 124.75,107.56 v2(124.75,106.43)
VMM_DPB_CTRLCLK: length 57.5
  TOP w0.102: v2(146.5,142.73) 146.5,143.8 146.96,144.26 U11.12 ; v2(125.19,110.14) 124.65,110.14 123.35,108.84 123.35,108.34 U6.K13 ; v2(126.4,108.64) 126.59,108.45 126.91,108.45 127.34,108.88 RP6.1
  IN1 w0.097: v2(146.5,142.73) 146.92,142.31 148.07,142.31 148.18,142.2 148.18,140.29 144.4,136.52 141.34,136.52 139.54,134.72 139.09,134.72 137.07,132.7 135.7,132.7 131.05,128.04 131.05,127.35 127.28,123.58 127.28,121.65 125.73,120.09 125.73,110.12 125.55,109.94 125.4,109.94 v2(125.19,110.14)
  IN3 w0.102: v2(126.4,108.64) 126.02,108.64 125.88,108.78 125.88,109.67 125.57,109.98 125.36,109.98 v2(125.19,110.14)
VMM_DPB_CTRLDAT: length 57.6
  TOP w0.102: U6.L14 123.58,108.57 123.58,108.42 123.68,108.32 123.89,108.32 124,108.44 124,108.78 123.88,108.91 123.88,109.04 124.75,109.91 124.84,109.91 v2(125.19,109.56) ; RP6.2 127.22,108.38 127.04,108.2 126.15,108.2 v2(126.02,108.07) ; U11.9 148.91,144.32 148.27,143.68 148.27,143.54 148.43,143.38 148.57,143.38 v2(148.82,143.63)
  IN1 w0.097: v2(125.19,109.56) 125.35,109.72 125.64,109.72 125.95,110.03 125.95,120 127.5,121.55 127.5,123.49 131.27,127.26 131.27,127.95 135.79,132.47 137.16,132.47 139.18,134.5 139.64,134.5 141.43,136.29 144.49,136.29 148.4,140.2 148.4,142.46 148.82,142.88 v2(148.82,143.63)
  IN3 w0.102: v2(126.02,108.07) 126.02,108.32 125.65,108.69 125.65,109.58 125.48,109.75 125.38,109.75 v2(125.19,109.56)
VMM_DPC_CTRLCLK: length 79.4
  TOP w0.102: U6.B12 117.82,107.45 117.58,107.69 117.01,107.69 116.59,108.11 116.58,108.11 116.2,108.49 115.92,108.77 v3(113.99,108.77) 112.42,108.77 R49.1 111.67,108.94 v2(111.48,109.13) ; U13.12 152.55,144.85 152.82,144.58 152.82,143.76 152.25,143.18 v2(151.8,143.18)
  IN1 w0.097: v2(111.48,109.13) 111.48,109.13 111.12,108.77 110.94,108.77 110.79,108.92 110.79,110.43 112.36,112 112.36,117.65 112.75,118.04 112.75,126.93 118.15,132.33 119.15,132.33 121.21,134.38 121.21,134.91 125.39,139.09 125.39,140.6 126.58,141.8 126.71,141.8 v2(126.89,141.62)
  BOTTOM w0.102: v2(151.8,143.18) 151.99,143.18 152.12,143.31 152.12,143.72 151.99,143.84 150.08,143.84 148.23,142 145.12,142 144.32,142.79 129.05,142.79 128.24,141.98 127.24,141.98 v2(126.89,141.62)
VMM_DPC_CTRLDAT: length 79.3
  TOP w0.102: U6.A12 117.02,107.36 116.49,107.88 116.04,108.33 115.85,108.51 v3(115.58,108.51) 112.55,108.51 R46.1 111.65,108.55 v2(111.48,108.55) ; v2(153.77,143.69) 154.5,144.42 U13.9
  IN1 w0.097: v2(126.89,142.21) 126.71,142.03 126.49,142.03 125.16,140.7 125.16,139.18 120.98,135.01 120.98,134.48 119.06,132.55 118.05,132.55 112.53,127.02 112.53,118.13 112.14,117.74 112.14,112.09 110.57,110.52 110.57,108.82 110.84,108.55 v2(111.48,108.55)
  BOTTOM w0.102: v2(153.77,143.69) 153.39,144.07 149.98,144.07 148.14,142.23 145.21,142.23 144.42,143.02 128.96,143.02 128.14,142.21 v2(126.89,142.21)
VMM_GPIO6: length 18.9
  TOP w0.102: U6.C1 118.47,99.75 v2(118.34,99.62) ; v2(127.25,107.24) 127.39,107.38 RP6.4
  IN2 w0.102: v2(127.25,107.24) 128.03,106.47 128.03,100.79 126.86,99.62 v2(118.34,99.62)
  BOTTOM w0.102: v2(127.25,107.24) v1(127.25,106.63)
VMM_GPIO7: length 4.5
  TOP w0.102: RP6.3 127.38,107.88 127.29,107.79 127.11,107.79 126.83,107.51 126.83,107.15 126.47,106.79 v1(126.02,106.79) 124.88,106.79 U6.M12
VMM_GPIO8: length 4.3
  TOP w0.102: U6.M13 125.07,108.01 126.21,109.15 126.21,109.47 v1(126.47,109.72) 126.85,110.1 R54.1
VMM_GPIO09: length 4.9
  TOP w0.102: R232.1 113.02,103.67 114.31,102.38 v1(115.67,102.38) 115.96,102.38 116.38,102.81 U6.A5
VMM_MESCL: length 5.9
  TOP w0.102: U6.B5 117.65,102.81 117.32,102.48 116.46,102.48 115.9,101.92 114.32,101.92 114.15,101.74 v1(114.01,101.74) 113.74,101.74 113.02,102.47 R40.1
VMM_MESDA: length 6.1
  TOP w0.102: R42.1 113.07,104.58 113.58,104.07 113.58,103.64 v1(114.13,103.08) 114.41,102.8 115.8,102.8 116.12,103.11 117.38,103.11 117.72,103.46 U6.B6
VMM_SPI_CLK: length 27.7
  TOP w0.102: v2(98.21,92.32) 97.07,91.18 U7.6 ; v2(115.73,100.51) 116.18,100.51 116.88,101.21 117.52,101.21 U6.B3
  IN1 w0.097: v2(115.73,100.51) 115.73,100.45 114.59,99.31 109.77,99.31 104.69,94.23 103.16,94.23 101.83,92.89 100.81,92.89 100.24,92.32 v2(98.21,92.32)
VMM_SPI_CS#: length 30.2
  TOP w0.102: v2(103.29,97.91) 103.38,97.82 v1(103.38,95.99) 103.38,92.79 100.75,90.16 100.75,88.89 100.49,88.64 U7.1 98.08,88.64 97.57,88.13 R64.2 ; v2(113.83,100.51) 114.67,101.35 115.89,101.35 116.69,102.16 U6.A4
  IN1 w0.097: v2(103.29,97.91) 104.43,97.91 107.23,100.7 113.64,100.7 v2(113.83,100.51)
VMM_SPI_DIN: length 26.5
  TOP w0.102: v2(102.84,97.4) 103.01,97.24 103.01,92.8 100.11,89.91 U7.2 ; v2(114.46,100.51) 115.07,101.12 115.96,101.12 116.68,101.84 117.5,101.84 U6.B4
  IN1 w0.097: v2(102.84,97.4) 104.37,97.4 107.42,100.45 113.26,100.45 113.6,100.11 114.06,100.11 v2(114.46,100.51)
VMM_SPI_DO: length 27.2
  TOP w0.102: v2(97.51,92.32) 97.38,92.45 U7.5 ; U6.A3 116.79,101.51 116.18,100.89 115.48,100.89 v2(115.1,100.51)
  IN1 w0.097: v2(115.1,100.51) 114.47,99.88 113.5,99.88 113.19,100.19 107.67,100.19 102.15,94.67 101.26,94.67 100.62,94.03 100.62,93.46 99.99,92.83 98.02,92.83 v2(97.51,92.32)
VMM_SPI_HOLD: length 6.4
  TOP w0.102: R65.2 96.56,89.4 96.05,89.91 U7.7 92.81,89.91 v1(92.58,90.14)
VMM_SPI_WP#: length 22.3
  TOP w0.102: v2(101.7,92.38) v1(101.17,91.85) 100.49,91.18 U7.3 ; v2(117.45,99.24) 117.45,99.75 117.82,100.12 U6.B1
  IN1 w0.097: v2(117.45,99.24) 116.62,98.42 109.57,98.42 104.88,93.72 103.35,93.72 102.02,92.38 v2(101.7,92.38)
VOL_DOWN#: length 89.1
  TOP w0.102: v2(135.37,108.32) 135.62,108.58 R349.2 ; v2(175.23,154.93) 176.41,153.75 JMED1.5
  TOP w0.254: v2(132.75,123.82) 132.75,123.03 R360.2
  IN2 w0.102: v2(175.23,154.93) 173.18,152.87 173.18,150.61 168.45,145.89 158.51,145.89 155.68,143.06 155.68,142.8 154.66,141.79 154.66,132.2 153.39,130.93 153.39,125.53 152.69,124.83 151.57,124.83 150.21,126.19 140.47,126.19 139.77,125.49 134.43,125.49 v2(132.75,123.82)
  IN3 w0.102: v2(132.75,123.82) 133.9,122.67 133.9,110.99 135.37,109.52 v2(135.37,108.32)
  BOTTOM w0.102: v2(175.23,154.93) 175.95,155.64 v1(176.4,155.64)
VOL_MUTE#: length 113.5
  TOP w0.102: v2(174.54,154.93) 174.97,155.36 175.39,155.36 176.5,154.25 JMED1.4 ; v2(152.82,128.43) 153.24,128.01 153.24,127.12 154.02,126.34 154.02,122.55 152.56,121.09 152.56,118.03 156.32,114.27 156.96,114.27 157.22,114.01 157.22,113.36 155.58,111.71 155.58,109.04 155.99,108.62 155.99,107.32 156.59,106.72 156.59,103.12 156.07,102.6 156.07,95 155.29,94.23 154.6,94.23 154.02,93.65 154.02,91.75 151.02,88.74 150.26,88.74 147.04,85.53 141.87,85.53 139.8,87.6 139.8,89.07 141.46,90.74 141.46,91.39 R358.2 R352.2
  IN2 w0.102: v2(152.82,128.43) 152.37,128.87 152.37,130.27 154.41,132.3 154.41,141.91 155.29,142.8 155.29,143.06 158.39,146.16 168.3,146.16 172.95,150.8 172.95,153.34 v2(174.54,154.93)
  BOTTOM w0.102: v2(174.54,154.93) 174.54,156.25 v1(174.9,156.62)
VOL_UP#: length 103
  TOP w0.102: v2(148.81,88.63) 149.2,89.02 150.91,89.02 153.77,91.88 153.77,93.78 154.47,94.48 155.17,94.48 155.84,95.15 155.84,102.69 156.36,103.21 156.36,106.63 155.76,107.22 155.76,108.53 155.35,108.95 155.35,111.8 155.74,112.19 155.74,114.53 152.31,117.96 152.31,121.21 153.77,122.67 153.77,126.27 152.88,127.16 152.88,127.75 v2(152.82,127.82) ; R338.2 R362.2 142.09,88.45 v2(141.83,88.19) ; v2(173.9,154.93) 175.58,153.25 JMED1.6
  IN2 w0.102: v2(173.9,154.93) 172.25,153.28 172.25,150.55 168.08,146.38 158.24,146.38 155.04,143.18 155.04,142.93 154.15,142.04 154.15,132.52 152.12,130.48 152.12,128.52 v2(152.82,127.82) ; v2(141.83,88.19) 148.37,88.19 v2(148.81,88.63)
  BOTTOM w0.102: v1(173.34,155.79) 173.9,155.24 v2(173.9,154.93)
VR_EN: length 14.7
  TOP w0.102: v1(98.58,30.08) 98.92,29.74 v2(98.92,29.34)
  IN1 w0.097: v2(109.55,30.2) 109.18,30.56 109.18,31.05 109,31.23 108.43,31.23 106.65,29.46 101.13,29.46 100.68,29.9 99.48,29.9 v2(98.92,29.34)
  BOTTOM w0.076: UC1.F60 109.89,30.54 109.56,30.2 v2(109.55,30.2)
  BOTTOM w0.102: RC246.2 99.17,29.08 v2(98.92,29.34)
VR_HOT#: length 2.7
  BOTTOM w0.203: PU300.30 51.44,21.1 v1(51.98,21.64) PR326.1
VR_READY: length 9.9
  BOTTOM w0.076: v1(101.88,28.02) 101.67,27.8 RC247.2 ; 105.18,29.51 105.18,29.77 106.23,30.82 106.96,30.82 107.16,31.02 107.31,31.02 107.47,31.18 107.71,31.18 UC1.C59
  BOTTOM w0.102: RC247.2 101.45,28.3 101.45,28.98 101.92,29.45 105.13,29.45 105.18,29.51
VREF: length 52.6
  IN2 w0.254: v2(67.51,28.82) 67.07,28.38 64.55,28.38 60.87,24.69 54.52,24.69 54.14,24.31 49.19,24.31 47.79,22.91 v2(47.79,21.84) 47.79,21.58 46.84,20.63 46.84,16.63 49.95,13.52 51.15,13.52 v2(52.8,11.86)
  IN2 w0.508: v2(52.8,11.86) 53.44,12.5 54.84,12.5 v2(55.47,11.87)
  BOTTOM w0.102: PR300.1 46.02,23.81 45.5,24.32 44.27,24.32 v1(43.93,23.98)
  BOTTOM w0.203: 48.55,21.64 49.57,21.64 50.24,20.98 PU300.27
  BOTTOM w0.254: PR300.1 PR322.2 47.03,22.47 PC309.1 v2(47.79,21.84) 48.23,21.84 48.42,21.64 48.55,21.64 ; v2(67.51,28.82) PH300.1
  BOTTOM w0.508: PR304.1 PR303.1 v2(55.47,11.87) ; v2(52.8,11.86) PR302.1
VSET_5075: length 4.4
  TOP w0.102: R394.1 C367.1 v1(152.47,99.96) 152.36,100.06 U38.A17
VSYNC_BUF: length 167
  TOP w0.102: v2(161.14,154.99) 161.14,154.61 160.77,154.24 U39.18
  IN3 w0.102: v2(312.65,161.03) 312.2,161.47 311.63,161.47 311.12,160.96 304.39,160.96 303.31,162.04 292.45,162.04 289.53,164.96 280.01,164.96 279.56,165.41 275.75,165.41 273.98,167.19 266.1,167.19 265.66,166.74 237.34,166.74 236.4,165.8 228.84,165.8 226.96,163.92 221.64,163.92 219.15,161.43 195.9,161.43 195.3,160.84 v2(195.3,160.39)
  BOTTOM w0.102: v2(161.14,154.99) 161.96,154.99 163.36,156.39 164.38,156.39 165.96,154.8 171.11,154.8 171.89,154.02 177.73,154.02 177.93,154.22 187.83,154.22 189.18,155.57 v1(189.18,157.84) 189.18,158.11 191.85,160.77 194.92,160.77 v2(195.3,160.39) ; JIO1.28 311.5,160.9 311.79,160.61 312.24,160.61 v2(312.65,161.03)
VSYNC_DOCK: length 11.7
  TOP w0.102: U39.17 161.17,154.2 161.77,154.8 v2(161.77,156.14)
  BOTTOM w0.102: v2(161.77,156.14) 164.95,159.32 v1(164.95,160) JDOCK1.67
WIGIG60GHZ_DIS#: length 162.8
  TOP w0.102: v2(291.57,154.17) 292.52,153.22 D13.1 293.42,153.22 R224.1 ; U37.A1 171.23,103.4 170.98,103.65 v1(170.98,104.18) 170.98,104.4 v2(171.36,104.78) 171.7,104.78 R289.2
  IN2 w0.102: v2(171.36,104.78) 173.03,104.78 175.87,107.62 175.87,108.96 183.01,116.09 183.01,121.49 190.8,129.29 210.27,129.29 213,132.02 213,134.05 215.68,136.73 215.68,137.09 216.06,137.47 219.82,137.47 225.4,143.04 225.4,145.27 231.91,151.79 231.91,152.36 236.88,157.32 236.88,159.37 237.58,160.07 237.58,161.09 239.23,162.74 246.04,162.74 246.67,163.38 253.97,163.38 255.18,162.17 261.08,162.17 263.18,160.07 266.99,160.07 267.96,159.1 283.14,159.1 284.39,157.85 287.88,157.85 v2(291.57,154.17)
WIGIG60GHZ_DIS#_R: length 8
  TOP w0.102: v1(294.84,151.73) 294.64,151.93 R224.2 292.76,151.93 D13.2 289.86,151.82 v2(289.86,151.82)
  BOTTOM w0.102: JMINI1.32 v2(289.86,151.82)
WIRELESS_LED#: length 223.5
  TOP w0.102: R432.2 v2(175.36,6.26) ; Q28.4 192.88,87.17 192.25,86.54 188.44,86.54 187.58,87.41 187.58,89.37 186.92,90.03 183.43,90.03 v2(182.92,90.54) 182.35,89.97 v1(181.38,89.97) 176.77,89.97 175.39,91.35 171.24,91.35 170.73,91.86 U37.A47
  IN2 w0.102: v2(232.19,144.96) 232.19,141.79 225.8,135.4 223.58,135.4 222.35,134.17 221.72,134.17 221.33,133.79 221.33,132.01 220.64,131.31 220.64,130.29 215.3,124.96 209.54,124.96 205.93,121.34 195.24,121.34 190.22,116.32 190.22,115.24 190.73,114.74 190.73,112.83 190.35,112.45 190.35,104.59 187.87,102.11 187.87,97.28 185.8,95.21 185.8,94.5 182.92,91.62 v2(182.92,90.54) 182.03,89.65 180.19,89.65 178.41,87.88 178.41,86.16 175.09,82.85 171.8,82.85 169.01,80.05 169.01,76.93 170.44,75.49 170.44,50.83 171.29,49.99 174.64,49.99 176.37,48.26 176.37,7.28 v2(175.36,6.26)
  BOTTOM w0.102: v2(232.19,144.96) 228.27,148.88 Q30.3 227.13,148.88 226.86,149.15 226.86,149.99 226.67,150.18 ; 226.67,150.18 227.24,150.76 227.24,151.38 227.35,151.49 Q22.6 ; 226.67,150.18 Q30.6
WIRELESS_ON#_OFF: length 103.4
  TOP w0.102: R293.2 160.03,104.55 v2(160.83,104.55) ; U37.B13 165.48,101.94 165.71,101.72 165.71,101.2 165.26,100.75 v2(165.2,100.75) ; JUDB1.17 89.88,79.55 88.16,81.27 v2(87.03,81.27)
  IN1 w0.097: v2(160.83,104.55) 160.83,104.32 161.3,103.85 161.3,102.65 161.78,102.16 163.68,102.16 165.09,100.75 v2(165.2,100.75)
  IN2 w0.102: v2(160.83,104.55) 159.95,104.55 157.83,102.43 157.83,100.83 155.34,98.33 153.12,98.33 152.67,97.87 150.94,97.87 148.12,95.05 147.57,95.05 147.32,94.8 147.32,93.3 146.32,92.29 139.62,92.29 138.86,91.53 126.11,91.53 125.33,92.32 122.72,92.32 122.11,91.71 117.61,91.71 116.83,90.92 94.84,90.92 93.13,89.21 90.59,89.21 87.03,85.65 v2(87.03,81.27)
  BOTTOM w0.102: v2(87.03,81.27) v1(87.65,81.27)
WLAN_LAN_DISB#: length 55.3
  TOP w0.102: U37.A64 173.35,101.34 173.52,101.5 173.52,104.07 v1(173.77,104.32) 174.03,104.58 176.81,104.58 178.47,106.24 178.47,110.54 179.98,112.05 179.98,118.47 181.52,120.01 v2(182.6,120.01) ; v2(181.82,145.55) 182.12,145.85 182.61,145.85 182.68,145.91 U24.4
  IN3 w0.102: v2(181.82,145.55) 181.79,145.55 179.87,143.63 179.87,141.98 179.23,141.34 179.23,134.9 179.93,134.2 179.93,132.52 179.04,131.63 179.04,128.52 182.6,124.96 v2(182.6,120.01)
WLAN_LED: length 3.7
  TOP w0.102: JLED1.9 183.66,8.85 183.31,8.5 R435.2 v1(182.61,9.69)
WLAN_LED#: length 89
  IN2 w0.102: v2(226.58,151.43) 230.59,151.43 231.43,152.26 231.43,152.52 236.42,157.51 236.42,159.56 237.12,160.26 237.12,161.28 239.09,163.25 245.66,163.25 246.35,163.95 254.23,163.95 255.5,162.68 261.34,162.68 262.74,161.28 266.17,161.28 268.11,159.33 283.29,159.33 284.52,158.11 288.07,158.11 291.18,154.99 291.57,154.99 292.2,154.36 v2(294.66,154.36)
  BOTTOM w0.102: v1(222.78,152.66) 223.38,152.66 224.68,151.36 R227.1 224.83,151.49 Q22.1 226.52,151.49 v2(226.58,151.43) ; v2(294.66,154.36) JMINI1.44
WLAN_RADIO_DIS#: length 152.9
  TOP w0.102: U37.A48 171.23,91.68 171.33,91.58 175.48,91.58 176.72,90.35 v1(178.93,90.35) 180.5,90.35 v2(180.69,90.54)
  IN2 w0.102: v2(180.69,90.54) 181.46,90.54 185.57,94.66 185.57,95.3 187.62,97.34 187.62,102.18 189.97,104.53 189.97,112.58 190.47,113.08 190.47,114.55 189.97,115.05 189.97,116.39 195.14,121.57 205.83,121.57 209.48,125.21 215.18,125.21 220.38,130.42 220.38,131.38 220.57,131.57 220.57,133.35 221.62,134.4 222.26,134.4 223.87,136.01 226.09,136.01 230.83,140.76 230.83,144.67 237.26,151.1 242.2,151.1 243.93,152.84 250.35,152.84 253.02,155.5 261.92,155.5 262.77,154.65 264.62,154.65 265.31,155.34 269.05,155.34 269.33,155.62 273.52,155.62 v2(273.79,155.88)
  BOTTOM w0.102: v2(273.79,155.88) 273.53,156.14 273.53,158.55 273.91,158.93 275.12,158.93 275.67,159.48 D12.1 275.92,160.2 R215.1
WLAN_RADIO_DIS#_R: length 19.8
  BOTTOM w0.102: D12.2 277.07,160.46 276.84,160.69 R215.2 276.84,161.6 277.09,161.85 v1(278.08,161.85) 279.56,161.85 280.11,161.31 280.11,160.73 281.02,159.81 281.02,154.49 285.06,150.45 JMINI1.20
WWAN_RADIO_DIS#: length 81.5
  TOP w0.102: U37.A53 173.3,95.84 173.46,95.69 174.2,95.69 R286.2 174.47,95.49 174.94,95.97 177.35,95.97 178.63,97.24 183.84,97.24 v1(184.69,96.39) 185.58,95.5 v2(189.27,95.5)
  IN3 w0.102: v2(189.27,95.5) 190.73,96.96 190.73,110.06 191.82,111.16 191.82,114.3 198.16,120.64 201.58,120.64 203.78,122.85 203.78,127.29 204.88,128.39 209.2,128.39 213.94,133.13 215.15,133.13 215.49,133.47 215.49,134.1 215.11,134.48 215.11,136.52 217.14,138.55 v2(217.14,139.44)
  BOTTOM w0.102: JMINI2.20 217.61,139.9 v2(217.14,139.44)
