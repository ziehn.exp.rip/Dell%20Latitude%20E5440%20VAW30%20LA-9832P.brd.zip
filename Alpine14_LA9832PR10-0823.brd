# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_ALW2: length 3.3
  TOP w0.127: v5(194.11,144.5) 194.11,143.74 193.97,143.6 PC69.1
  TOP w0.203: PU51.13 193.2,143.06 193.39,143.25 PC69.1
+5V_ALWP: length 50.2
  TOP w0.203: PU51.14 192.96,143.46 193.52,144.02
  TOP w0.254: PR52.2 185.71,144.39 185.33,144.77 v1(185.33,146.45) 185.33,147.37 v2(185.9,147.95)
  TOP w0.508: v2(193.9,151.57) 193.9,148.4 193.08,147.58 193.08,146.1 193.52,145.66 PC67.1 193.9,145.19 193.52,144.81 193.52,144.02
  IN2 w0.254: v2(206.6,152.77) 206.6,152.96 205.97,153.6 194.41,153.6 191.24,150.42 188.38,150.42 187.81,149.85 187.81,148.64 187.11,147.95 v2(185.9,147.95)
  IN3 w0.508: v2(204.63,152.77) 195.11,152.77 v2(193.9,151.57)
  vias: v2(204.48,151.74) v2(205.02,152.14) v2(205.08,151.49) v2(205.27,152.77) v2(205.65,152.14) v2(205.9,152.77) v2(206.29,152.14) v2(206.92,152.14) v2(207.24,152.77) v2(207.56,152.14) v2(207.87,152.77) v2(207.87,151.5) v2(208.14,150.83) v2(208.19,152.14)
+5V_HDD: length 15.9
  TOP w0.254: 83.98,115.94 84.43,115.5 84.43,113.53 83.81,112.91 R125.1
  TOP w1.524: 85.38,128.64 85.38,118.61 84.17,117.4
  vias: v3(83.41,131.12) v3(83.41,130.42) v3(83.41,129.72) v5(84.57,130.43)
+5V_HDMI_DDC: length 12.3
  TOP w0.102: v1(21.12,105.07) 21.19,105 R470.2
  TOP w0.305: R471.2 v2(15.72,104.26)
  TOP w0.508: v2(22.71,104.66) 22.57,104.66 22.17,104.27 R472.2 22.16,104 R470.2 21.19,103.04 D65.1
  IN1 w0.305: v2(15.72,104.26) 22.3,104.26 v2(22.71,104.66)
+5V_MOD: length 13.7
  TOP w1.524: 191.24,27.93 193.9,30.6 193.9,33.52 195.6,35.22 195.6,39.83
  vias: v2(190.97,26.66) v2(190.97,26.05) v2(191.49,26.34) v2(194.02,40.66) v2(194.02,40.05) v2(194.62,40.66) v5(190.41,26.29)
+5V_RUN: length 520.6
  TOP w0.254: U39.16 162.57,153.06 162.79,153.28 C2992.1
  TOP w0.508: v2(246.04,170.3) 246.04,172.58 247.48,174.03 288.21,174.03 290.11,172.14 290.11,164.84 292.39,162.55 302.55,162.55 303.76,163.76 303.76,167.38 304.08,167.69 v2(304.9,167.69) C1001.1 ; JKB1.6 184.51,108.84 C376.1 v2(185.84,108.21) ; v2(57.95,17.72) 68.76,17.72 70.44,19.41 70.44,26.55 v2(70.08,26.92) ; v2(75.01,97.15) 75.01,97.62 D1.1 74.31,97.78 74.09,98 C7.1 73.28,98.96 72.71,99.53 JFAN1.1 68.89,99.53 68.44,99.97 68.44,103.95 69.95,105.46 v2(69.95,108.51) C454.1 70.38,109.33 71.07,110.01 Q137.3 ; v2(129.7,99.11) R74.1 ; C2992.1 v2(163.44,155.11)
  IN1 w0.508: v2(48.44,38.55) 48.44,35.89 49.82,34.51 49.82,33.31 51.76,31.37 51.76,25.54 57.95,19.35 v2(57.95,17.72)
  IN1 w1.016: 25.16,103.59 25.16,103.59 26.39,102.35 35.47,102.35 37.06,103.94 58.01,103.94 59.47,105.4 64.74,105.4 67.73,108.39 ; 14.45,96.19 14.45,98.61 16.36,100.51 20.17,100.51 23.34,103.69
  IN2 w0.508: v2(129.7,99.11) 129.96,99.37 129.96,104.45 132.56,107.05 133.13,107.05 135.17,109.08 135.17,110.04 135.93,110.8 135.93,110.8 139.02,113.9 141.96,113.9 142.54,114.48 v2(145.83,114.48) 146.79,114.48 147.04,114.74 150.66,114.74 152.31,116.39 153.07,116.39 157.01,120.32 159.36,120.32 161.96,122.93 161.96,125.53 161.58,125.91 161.58,128.45 164.18,131.06 164.18,135.3 162.99,136.49 159.61,136.49 158.55,137.56 158.55,141.96 v2(158.09,142.42) ; v2(80.47,24.88) 79.98,25.37 79.98,35.49 83.16,38.66 83.16,60.25 81.38,62.03 81.38,64.57 83.26,66.45 83.26,83.58 81.93,84.92 81.93,88.36 80.53,89.76 80.53,95.45 79.79,96.19 75.77,96.19 75.01,96.96 v2(75.01,97.15) ; v2(36.37,35.4) 37.02,36.05 45.93,36.05 v2(48.44,38.55)
  IN3 w0.508: v2(95.41,24.97) 94.56,24.12 90.46,24.12 89.85,23.51 82.31,23.51 80.94,24.88 v2(80.47,24.88) 72.11,24.88 v2(70.08,26.92) ; v2(163.44,155.11) 161.77,153.45 161.77,151.73 160.53,150.49 160.53,148.57 158.09,146.13 v2(158.09,142.42)
  IN3 w2.54: 186.74,72.69 188.39,74.34 188.39,78.35 184.84,81.91 ; 188.51,41.99 188.51,58.35 187.11,59.74
  BOTTOM w0.102: v2(24.31,103.9) 24.31,102.76 v5(24.34,102.72)
  BOTTOM w0.203: PU301.2 69.31,26.08 69.57,26.34 69.7,26.34 70.08,26.72 v2(70.08,26.92)
  BOTTOM w0.508: v2(234.24,156.21) 239.99,156.21 242.06,158.28 242.06,165.94 246.04,169.91 v2(246.04,170.3) ; v2(57.95,17.72) 57.95,16.95 57.56,16.55 PR314.1 ; v2(70.08,26.92) 70.08,27.54 PC303.1 ; PR710.2 v2(36.37,35.4) ; v2(69.95,108.51) 70.14,108.32 R2605.2 ; v2(145.83,114.48) 146.02,114.67 151.09,114.67 151.85,115.43 158.15,115.43 158.71,114.88 158.71,114.03 159.26,113.48 163.47,113.48 164.63,112.32 164.63,110.99 167.22,108.4 173.64,108.4 174.64,109.4 176.53,109.4 180.28,113.15 v2(183.23,113.15) ; v2(48.44,38.55) 48.44,37.63 PR630.2
  vias: v2(14.55,94.89) v2(14.55,94.29) v2(23.7,103.92) v2(182.7,84.04) v2(182.7,83.4) v2(183.36,84.04) v2(183.36,83.4) v2(187.8,40.19) v2(187.8,39.55) v2(187.8,38.92) v2(189.04,39.4) v2(189.07,38.47) v3(81.76,156.71) v3(81.76,156.07) v3(81.76,155.38) v3(82.46,156.71) v3(82.46,156.07) v3(82.46,155.38) v3(82.84,114.35) v3(83.22,113.78) v3(83.29,135.56) v3(83.29,134.93) v3(83.29,134.23) v3(83.29,133.6) v3(83.29,132.96) v3(83.6,114.35) v3(223.4,154.41) v3(223.4,153.78) v3(223.4,153.14) v3(224.04,154.41) v3(224.04,153.78) v3(224.04,153.14) v3(224.7,154.17) v3(224.7,153.41)
+5V_RUN_AUDIO: length 42.3
  TOP w0.508: R130.1 240.93,157.22 239.69,157.22 238.23,155.76 238.23,148.77 v5(238.86,148.14) 240.21,146.79 243.95,146.79 245.46,145.28 254.99,145.28 256.07,146.36 265.09,146.36 265.66,145.79 v2(265.66,145.22)
  BOTTOM w0.508: L21.2 266.81,145.72 266.3,145.22 v2(265.66,145.22)
+5V_TSP: length 11.8
  TOP w0.508: C455.1 75.65,105.13 76.21,104.58 JTS1.1
  BOTTOM w0.102: v2(73.43,105.11) 73.02,105.11 v5(72.69,104.78)
  BOTTOM w0.508: 76.17,105.71 75.57,105.11 v2(73.43,105.11)
+5V_TSP_Q: length 9.2
  TOP w0.508: v2(77.85,104.43) 77.85,106.72 75.32,109.25 v1(75.27,109.25) 75.03,109.25 73.71,107.93 Q137.1
+5V_USB_CHG_PWR:
  vias: v2(19.28,81.14) v2(19.28,78.73) v2(19.91,81.14) v2(19.91,78.73) v2(24.74,71.81) v2(24.74,71.17) v2(25.31,71.49) v2(25.31,70.88) v5(17.53,81.4)
+DVDD_CORE: length 2.8
  BOTTOM w0.254: U17.1 252.68,156.58 252.3,156.96 252.12,156.96
  BOTTOM w0.508: 252.12,156.96 C121.1
+P1.05V_PEX_VDD:
  vias: v1(82.54,84.19)
+V1.05S_APLLOPI: length 26.3
  TOP w0.381: v2(117.96,55) 117.49,55.47 CC56.1
  IN3 w0.508: v2(95.99,53.67) 95.99,53.69 97.36,55.06 100.43,55.06 101.32,54.17 108.44,54.17 109.13,53.48 111.1,53.48 111.96,54.35 117.31,54.35 v2(117.96,55)
  BOTTOM w0.254: UC1.AA21 118.03,55.07 v2(117.96,55) 117.43,55.53 UC1.W21
  vias: v1(95.25,53.01)
+V1.05SP_B+:
  vias: v1(158.38,77.41)
+VCC_CORE: length 50.4
  TOP w0.508: RC250.1 98.53,27.74 98.14,28.12
  BOTTOM w0.089: 113.15,53.76 113.12,53.73
  BOTTOM w0.127: 109.38,38.41 109.4,38.41 UC1.F48 ; UC1.F48 109.48,37.96 109.26,37.96 ; UC1.F48 109.89,38.38 ; UC1.F48 109.84,37.96 109.96,37.96 ; 109.51,40.95 109.51,40.8 UC1.F44 ; 110.02,40.76 109.77,40.76 UC1.F44 ; 111.27,53.85 111.52,54.1 UC1.J23 ; 110.46,53.84 110.71,54.09 UC1.H23 ; UC1.F32 109.57,48.26 109.57,48.51 ; UC1.F32 109.56,48.18 109.32,47.93 ; UC1.F32 109.86,48.38 110.08,48.38 ; UC1.F32 109.78,48.06 110.08,48.06 ; UC1.F56 109.8,33.27 110.08,33.27 ; UC1.F56 109.51,33.28 109.51,33.46 ; UC1.F56 109.48,32.95 109.38,32.95 ; 109.38,53.39 109.46,53.39 UC1.F24 ; 109.7,36.12 109.78,36.12 UC1.G51 ; UC1.G51 110.11,36.46 110.26,36.46 ; UC1.G51 110.19,36.12 110.27,36.12 ; UC1.G51 109.8,36.52 109.69,36.52 ; UC1.G23 109.98,53.88 109.7,54.16 ; UC1.G23 110.03,53.88 110.39,54.24 110.57,54.24 UC1.H23 ; UC1.G23 109.99,53.87 ; UC1.F40 109.35,42.85 109.32,42.85 ; UC1.F40 109.91,43.4 ; UC1.F40 109.45,43.37 ; UC1.F40 109.84,42.98 110.08,42.98 ; UC1.F24 109.87,53.39 110.02,53.39 ; UC1.F24 109.84,53.01 110.02,53.01 ; UC1.F24 109.48,53.01 109.32,53.01 ; UC1.G33 109.82,47.31 109.69,47.31 ; UC1.G33 110.24,47.74 110.27,47.74 ; UC1.G33 110.16,47.31 110.26,47.31 ; UC1.G33 109.73,47.74 109.7,47.74 ; 109.69,39.82 109.84,39.82 UC1.G45 ; 109.26,50.41 109.39,50.41 UC1.F28 ; 109.96,45.52 109.81,45.52 UC1.F36 ; 110.26,51.51 110.12,51.51 UC1.G27 ; UC1.G43 110.11,41.47 110.26,41.47 ; UC1.G43 109.78,41.14 109.7,41.14 ; UC1.G43 110.19,41.14 110.27,41.14 ; UC1.G43 109.79,41.54 109.69,41.54 ; UC1.G31 110.15,49.03 110.26,49.03 ; UC1.G31 110.22,48.63 ; UC1.G31 109.75,48.63 ; UC1.G31 109.76,49.09 ; UC1.G27 109.85,51.24 109.64,51.24 ; UC1.G27 110.19,51.17 110.34,51.17 ; UC1.G27 109.79,51.57 109.62,51.57 ; 109.69,34.74 109.78,34.74 UC1.G53 ; 110.27,46.16 110.19,46.16 UC1.G35 ; 109.45,38.66 109.81,38.66 UC1.G47 ; 109.62,52.33 109.82,52.33 UC1.G25 ; UC1.G25 110.16,52.33 110.26,52.33 ; UC1.G25 109.79,52.7 109.64,52.7 ; UC1.G25 110.18,52.7 110.27,52.7 ; 109.38,45.39 109.39,45.39 UC1.F36 ; UC1.G35 109.79,46.55 109.69,46.55 ; UC1.G35 110.12,46.49 110.26,46.49 ; UC1.G35 109.78,46.16 109.64,46.16 ; UC1.F28 109.83,50.85 110.02,50.85 ; UC1.F28 109.87,50.47 ; UC1.F28 109.66,50.7 109.38,50.98 ; UC1.G53 110.13,34.8 110.26,34.8 ; UC1.G53 109.76,35.17 ; UC1.G53 110.21,35.17 ; 111.02,54.24 110.85,54.24 UC1.H23 ; 111.66,53.73 111.66,53.97 UC1.J23 ; UC1.G45 110.27,40.25 ; UC1.G45 110.13,39.82 110.26,39.82 ; UC1.G45 109.76,40.19 ; UC1.G29 109.78,49.79 109.69,49.79 ; UC1.G29 109.76,50.22 ; UC1.G29 110.13,49.85 110.26,49.85 ; UC1.G29 110.28,50.28 110.34,50.28 ; UC1.H23 110.71,54.1 110.97,53.84 ; 110.4,38.54 110.29,38.54 UC1.G47 ; UC1.G49 109.81,37.28 109.62,37.28 ; UC1.G49 110.24,37.71 110.27,37.71 ; UC1.G49 109.73,37.71 109.7,37.71 ; UC1.G49 110.16,37.28 110.26,37.28 ; UC1.F52 109.45,35.85 ; UC1.F52 109.83,35.81 109.96,35.81 ; UC1.F52 109.38,35.36 109.38,35.36 ; UC1.F52 109.88,35.42 ; UC1.J23 111.39,54.24 111.21,54.24 ; UC1.G41 110.18,42.66 110.27,42.66 ; UC1.G41 109.81,42.3 109.69,42.3 ; UC1.G41 109.73,42.73 109.7,42.73 ; UC1.G41 110.16,42.3 110.26,42.3 ; UC1.G37 110.13,44.84 110.26,44.84 ; UC1.G37 109.78,44.77 109.69,44.77 ; UC1.G37 110.21,45.2 ; UC1.G37 109.76,45.2 ; UC1.F36 109.45,45.88 ; UC1.F36 109.89,45.9 ; UC1.F44 109.45,40.44 ; UC1.F44 109.81,40.5 110.08,40.5 ; 110.27,53.59 109.99,53.87 ; 109.99,53.87 109.99,53.87 109.7,53.59 ; UC1.G39 110.29,43.55 110.34,43.55 ; UC1.G39 109.75,43.62 ; UC1.G39 109.76,44.08 ; UC1.G39 110.15,44.01 110.26,44.01 ; 109.99,32.79 UC1.G57 109.51,32.44 ; UC1.G47 109.78,39.04 109.57,39.04 ; 110.23,33.58 UC1.G55 109.59,33.82 109.57,33.84
  BOTTOM w0.152: UC1.M23 113.15,54.2 UC1.L22 112.34,54.2 UC1.K23 ; UC1.M23 113.15,53.76 ; UC1.M23 112.81,54.1 ; UC1.K23 112.34,53.81 112.48,53.66 ; UC1.K23 112.66,54.1
  BOTTOM w0.254: v2(112.01,32.92) UC1.K57 ; v2(117.22,32.7) UC1.W57 ; v2(118.52,32.7) UC1.AB57 ; UC1.F59 109.89,31.19 v2(109.6,30.89) ; v2(114.61,32.7) UC1.P57 ; UC1.AD57 119.82,32.61 ; v2(115.91,32.7) UC1.U57 ; v2(113.31,32.7) UC1.M57
  vias: v2(77.82,34.41) v2(77.82,33.77) v2(77.82,33.14) v2(77.82,32.5) v2(78.46,34.41) v2(78.46,33.77) v2(78.46,33.14) v2(78.46,32.5) v2(79.09,34.41) v2(79.09,33.77) v2(79.09,33.14) v2(79.09,32.5) v2(82.52,37.07) v2(82.52,32.63) v2(82.52,31.36) v2(82.52,30.72) v2(82.52,29.45) v2(84.81,47.87) v2(84.81,46.6) v2(84.81,45.96) v2(84.81,44.69) v2(84.81,40.25) v2(84.81,38.98) v2(84.81,38.34) v2(84.81,37.07) v2(84.81,32.63) v2(84.81,31.36) v2(84.81,30.72) v2(84.81,29.45) v2(87.09,47.87) v2(87.09,46.6) v2(87.09,45.96) v2(87.09,44.69) v2(87.09,40.25) v2(87.09,38.98) v2(87.09,38.34) v2(87.09,37.07) v2(87.09,32.63) v2(87.09,31.36) v2(87.09,30.72) v2(87.09,29.45) v2(89.34,40.25) v2(89.36,47.9) v2(89.36,46.6) v2(89.36,45.94) v2(89.36,44.75) v2(89.36,38.95) v2(89.38,38.34) v2(89.38,37.07) v2(89.38,32.63) v2(89.38,31.36) v2(89.38,30.72) v2(89.38,29.77) v2(91.54,38.95) v2(91.54,38.32) v2(91.62,47.81) v2(91.62,46.63) v2(91.62,45.52) v2(91.62,44.89) v2(91.67,40.25) v2(91.67,37.07) v2(91.67,32.63) v2(91.67,31.36) v2(91.67,30.72) v2(91.67,29.45) v2(92.3,38.35) v2(93.64,46.22) v2(93.93,37.07) v2(93.93,32.63) v2(93.93,31.36) v2(93.93,30.72) v2(93.95,29.45) v2(96.24,37.07) v2(96.24,32.63) v2(96.24,29.45) v2(96.25,31.7) v2(96.25,31.07) v2(109.06,50.82) v2(109.06,48.31) v2(109.06,45.8) v2(109.06,43.3) v2(109.12,40.82) v2(109.13,38.22) v2(109.13,35.81) v2(109.06,33.27) v2(110.6,52.5) v2(110.59,51.49) v2(110.6,49.99) v2(110.6,48.87) v2(110.6,47.49) v2(110.6,46.36) v2(110.6,44.98) v2(110.6,43.85) v2(110.6,42.47) v2(110.6,41.34) v2(110.6,39.96) v2(110.6,38.84) v2(110.6,37.46) v2(110.6,36.33) v2(110.6,34.95) v2(110.6,33.82) v2(110.6,32.75) v5(97.93,45.1)
+VCC_PWR_SRC: length 21.6
  IN1 w0.508: v2(44.8,13.26) 45.12,13.26 46.01,14.15 58.27,14.15 59.79,15.68 64.05,15.68 v2(64.11,15.74)
  BOTTOM w0.508: v2(44.8,13.26) 45.26,12.81 PR311.1
  vias: v1(65.39,18.11)
+VCCIO_OUT: length 7.5
  BOTTOM w0.254: 103.46,30.21 104.7,30.21 105.81,31.31 UC1.A59
  BOTTOM w0.508: RC242.1 99.91,30.21 v1(103.16,30.21) 103.46,30.21
+VCCIOA_OUT: length 7.5
  TOP w0.508: v2(108.84,56.57) 108.18,56.57 107.82,56.21 v1(107.82,55.51) 107.82,54.7 108.94,53.59 111.27,53.59 RC134.1
  BOTTOM w0.254: v2(108.84,56.57) 108.84,56.36 109.15,56.04 UC1.E20
+VDDA_AVDD1: length 14.4
  TOP w0.508: v2(258.42,147.88) 258.99,147.31 262.86,147.31 263.31,147.76 v2(263.31,148.26)
  BOTTOM w0.102: v1(268.2,148.44) 267.42,147.66 L21.1
  BOTTOM w0.254: C115.1 257.47,147.83 257.47,148.39 257.18,148.67 U17.27
  BOTTOM w0.508: v2(263.31,148.26) 263.85,147.72 C117.1 265.8,147.72 265.86,147.66 L21.1 ; C115.1 258.1,147.5 258.42,147.82 v2(258.42,147.88)
+VDDA_AVDD2: length 95.3
  TOP w0.508: v2(265.96,154.85) 264.44,154.85 261.09,151.5 259.94,151.5 258.67,150.23 254.55,150.23 253.48,149.17 v2(249.6,149.17)
  IN2 w0.508: v2(309.47,153.4) 310.49,154.42 310.49,157.92 309.35,159.06 303.62,159.06 298.99,154.42 297.6,154.42 296.01,152.84 285.47,152.84 283.96,154.35 275.77,154.35 274.93,155.19 269.72,155.19 269.39,154.85 v2(265.96,154.85)
  IN3 w0.508: v2(249.6,149.17) 248.38,147.95 245.02,147.95 v2(244.51,147.44)
  BOTTOM w0.254: U17.38 251.46,150.46 250.85,149.85 C150.1 ; JIO1.58 v2(309.47,153.4)
  BOTTOM w0.508: R159.1 v2(265.96,154.85) 266.7,154.85 v1(267.58,155.74) 268.41,156.57 268.41,158.97 267.18,160.2 266.31,160.2 R158.1 ; L37.1 C116.1 243.62,147.69 243.88,147.44 v2(244.51,147.44) ; C150.1 v2(249.6,149.17)
+VDDA_PVDD: length 0.6
  BOTTOM w0.508: C129.1 v2(249.61,155.31)
  vias: v1(241.44,149.67) v2(250.42,150.36)
+VDDRP: length 14.6
  TOP w0.127: v2(40.31,46.75) v5(40.31,47.46)
  BOTTOM w0.254: PR707.2 31.9,35.05 34.33,37.48 34.33,44.5 34.96,45.14 36.23,45.14
+VDDRP_B+: length 1.8
  BOTTOM w0.127: 45.66,28.4 v1(47.47,28.4)
GND: length 3438.8
  TOP w0.102: v2(25.88,85.26) v5(25.88,85.86)
  TOP w0.127: v2(136.77,138.55) 137.1,138.89 v5(137.5,138.89) ; v5(47.78,84) 48.58,84.8 CV3059.2 ; v5(50.39,73.38) CV86.2 ; CV3056.2 48.41,70.41 v5(47.53,71.29) ; v2(156.06,73.83) 156.06,73.14 v5(156.11,73.09) ; CV2918.2 v5(42.52,99.57) ; v2(157.39,82.16) v5(158.04,82.16) ; v5(114.13,153.8) 115.34,153.8 PC421.2 ; v5(196.28,42.74) 195.85,43.17 v2(195.41,43.17) ; v2(123.04,165.6) v5(123.76,165.6)
  TOP w0.203: U39.11 161.17,150.33 161.33,150.17 v2(161.58,150.17) ; v2(105.89,108.77) 106.55,108.11 106.77,108.11 107.31,107.56 108.19,107.56 R2583.1 108.19,108.58 107.21,108.58 106.2,109.59 v2(105.89,109.59) ; U6.J6 v4(122.69,103.13) ; U6.G10 v4(121.39,106.38) ; U6.D7 v4(118.79,103.78) ; U6.G8 v4(121.39,105.08) ; U6.D6 v4(118.79,103.13) ; U6.F6 v4(120.09,103.13) 120.42,102.81 U6.F5 ; U6.E11 119.77,106.71 v4(120.09,107.03) U6.F11 ; U52.16 107.78,111.77 v2(107.92,111.62) ; U6.J11 v4(122.69,107.03) ; U6.G11 v4(121.39,107.03) ; U6.E4 v4(119.44,101.83) ; U6.G6 v4(121.39,103.13) 121.07,102.81 U6.G5 ; U6.B13 U6.B14 117.82,108.82 v2(118.15,109.15) 118.15,109.02 118.47,108.7 U6.C14 U6.C13 ; U6.D9 v4(118.79,105.73) ; v2(108.99,113.53) 109.05,113.47 110.78,113.47 C437.2 ; U6.F7 v4(120.09,103.78) ; U6.F9 v4(120.09,105.73) ; U6.J7 v4(122.69,103.78) ; UV5.G8 UV5.G9 ; U52.6 102.96,109.1 103.01,109.05 103.01,108.42 v2(102.84,108.26) ; U6.F10 v4(120.09,106.38) ; U6.J9 v4(122.69,105.73) ; U43.11 v2(92.29,72.53) ; U51.11 v2(213.14,138.04) ; U6.D8 v4(118.79,105.08) ; U6.G9 v4(121.39,105.73) ; v2(155.23,151.67) 155.42,151.67 155.61,151.86 U39.31 ; U6.G4 v4(121.39,101.83) ; U39.28 155.83,153.06 155.42,153.47 v2(155.42,153.72) ; U6.J12 v4(122.69,107.68) ; PU100.14 175.57,78.94 v3(175.44,78.81) ; U6.D13 U6.D14 118.78,108.99 v2(118.78,109.15) ; U6.D4 v4(118.79,101.83) ; U6.D5 v4(118.79,102.48) ; U6.F4 v4(120.09,101.83) ; U6.L7 v4(123.99,103.78) 123.67,103.46 U6.L6 ; U6.C5 v4(118.14,102.48) ; U6.D11 119.12,106.7 v4(118.79,106.38) U6.D10 ; U6.H4 v4(122.04,101.83) ; U6.H10 v4(122.04,106.38) ; U6.F8 v4(120.09,105.08) ; U6.G7 v4(121.39,103.78) ; U18.11 v2(250.61,167.25) ; U6.K5 v4(123.34,102.48) ; v2(157.73,149.8) 157.97,150.04 U39.3 ; UV7.G8 UV7.G9 ; U46.11 v2(218.16,150.61) ; U6.J5 v4(122.69,102.48) ; U6.L8 v4(123.99,105.08) ; U6.J8 v4(122.69,105.08)
  TOP w0.254: v2(96.94,133.42) JLVDS1.15 ; v2(31.68,95.27) 31.74,95.32 32.45,95.32 UV5.M1 ; v2(97,126.92) JLVDS1.28 ; JEXP1.9 96.06,23.26 96.06,23.07 v2(96.44,22.69) ; RP18.3 155.4,104.64 v2(155.68,104.91) 155.45,105.13 RP18.4 ; UV5.T9 29.66,88.26 v2(29.44,88.04) ; JEXP1.38 89.06,18.23 88.87,18.05 v2(88.87,17.77) ; JEXP1.26 92.06,19.67 91.92,19.8 v2(91.92,20.26) ; v2(36.47,88.17) 36.52,88.17 UV5.G9 ; v2(123.04,142.59) 123.03,142.58 PU701.23 ; v2(30.88,88.9) 31.26,88.53 UV5.P9 ; UV5.M9 32.86,88.53 v2(32.48,88.9) ; v2(127.04,138.67) PU701.14 ; v2(41.26,88.11) UV5.B9 ; v2(90.42,20.29) 90.42,20.16 90.56,20.02 JEXP1.32 ; v2(36.48,72.42) 36.83,72.76 UV7.G9 ; JEXP1.8 96.56,17.96 v2(96.75,17.77) ; JEXP1.37 89.06,22.88 v2(88.9,22.72) ; JEXP1.17 94.06,24.54 v2(94.27,24.76) ; 38.9,95.35 UV5.E1 ; 38.9,95.35 38.9,95.27 UV5.D1 ; 38.9,95.35 v2(38.9,95.37) ; UV7.A9 v2(42.07,72.36) ; UV7.M9 32.87,72.78 v2(32.5,73.15) ; v2(96.93,139.42) JLVDS1.3 ; U90.11 173.82,125.1 v2(173.65,125.28) ; v2(165.01,135.75) 164.82,135.56 U91.20 ; v2(41.26,95.31) UV5.B1 ; UV5.P1 31.21,94.91 v2(30.87,95.25) 30.8,95.33 30.08,95.33 UV5.T1 ; PC512.2 123.11,134.24 123.03,134.32 PU701.5 123.03,137.05 122.81,137.28 v2(121.64,137.28) ; UV7.E2 v2(38.87,77.96) ; v2(38.03,72.34) 37.67,72.7 UV7.F9 ; C437.2 111.99,113.02 111.99,111.81 109.83,109.66 v2(107.61,109.66) ; UV7.T1 30.09,79.58 30.81,79.58 v2(30.88,79.5) 31.23,79.16 UV7.P1 ; U91.12 162.03,131.77 v2(161.95,131.69) ; RP16.1 141.5,114.37 v2(141.26,114.61) ; UV7.E1 v2(38.87,79.56) UV7.D1 ; v2(302.99,170.03) U83.10 ; UV5.B3 40.86,92.82 v2(40.97,92.71) ; v2(110.15,148.01) 110.34,147.81 PU402.14 ; v2(92.16,24.76) 92.06,24.65 92.06,24.39 JEXP1.25 ; UV7.E8 v2(38.87,73.16) UV7.D8 ; UV7.T9 29.67,72.73 v2(29.3,72.35) ; UV7.J8 35.27,73.5 v2(35.62,73.15) ; v2(93.16,17.71) 93.16,17.86 93.56,18.26 93.56,18.39 JEXP1.20 ; UV5.E2 v2(38.86,93.71) ; UV7.B1 40.87,79.22 v2(41.27,79.62) ; v2(41.27,72.36) UV7.B9 ; U91.25 163.03,138.54 163.3,138.8 v2(163.42,138.8) ; v2(297.09,170.03) U83.21 ; UV5.G1 v2(37.26,95.31) ; U91.14 163.03,132.15 163.3,131.88 v2(163.3,131.69) ; v2(41.17,76.96) 40.87,77.26 UV7.B3 ; v2(30.9,73.15) 31.27,72.78 UV7.P9 ; JEXP1.14 95.06,18.81 95.06,18.05 v2(94.9,17.9) ; v2(159.68,137.77) 159.89,137.56 U91.1 ; U91.27 162.03,138.72 161.82,138.93 v2(161.76,138.93) ; UV5.E8 v2(38.86,88.91) UV5.D8 ; UV7.J2 35.27,78.37 v2(35.67,78.77) ; JTP1.8 153.68,94.29 153.39,94 153.39,93.4 152.82,92.83 v2(152.31,92.83) ; v2(96.93,131.92) JLVDS1.18 ; RP18.2 v2(155.68,104.14) ; UV7.M1 32.47,79.57 31.75,79.57 v2(31.7,79.52) ; UV5.F9 37.53,88.51 v2(37.06,88.04) ; UV5.A9 v2(42.06,88.11) ; v2(159.68,133.06) U91.10 ; v2(35.66,94.52) 35.26,94.12 UV5.J2 ; v2(97,128.42) JLVDS1.25 ; v2(96.91,138.42) JLVDS1.5 ; v2(123.03,138.67) PU701.32 ; UV7.G1 v2(37.27,79.56)
  TOP w0.279: v2(144.15,4.97) JXDP1.20 ; JXDP1.13 v2(145.65,10.61) ; v2(144.15,10.6) JXDP1.19 ; v2(134.78,10.66) 134.4,10.66 134.15,10.91 JXDP1.59 ; v2(139.65,8) JXDP1.38 ; v2(136.65,10.66) JXDP1.49 ; v2(141.15,10.61) JXDP1.31 ; v2(142.65,4.96) JXDP1.26 ; v2(142.65,10.66) JXDP1.25 ; v2(136.12,8.18) 136.65,7.65 JXDP1.50 ; JXDP1.14 v2(145.65,8.02) ; v2(141.15,5.01) JXDP1.32 ; JXDP1.8 v2(147.15,5.01) ; v2(139.65,10.68) JXDP1.37 ; v2(148.37,10.6) 148.65,10.88 JXDP1.1 ; JXDP1.7 v2(147.15,10.55) ; JXDP1.2 v2(148.65,5.02)
  TOP w0.305: U38.B60 140.55,103.82 141.42,103.82 v2(141.83,103.4) ; v2(186.16,8.82) 186.16,9.01 185.82,9.35 JLED1.10 ; v2(34.9,88.87) 35.26,89.23 UV5.J8 ; v2(150.52,99.24) 149.95,99.81 U38.B18 ; U38.B66 140.88,100.81 140.89,100.8 141.49,100.8 v2(141.79,100.5) ; JMED1.1 177.96,155.75 178.17,155.96 178.17,156.34 177.85,156.66 v2(177.52,156.66) ; U37.B27 163.66,97.09 163.74,97.01 v2(163.74,97) ; U38.B54 140.82,106.81 140.97,106.66 141.52,106.66 141.81,106.38 v2(141.81,106.23) ; v2(146.05,99.87) 146.14,99.78 U38.B11 ; JDEG1.10 151.1,126.26 152.22,126.26 v2(152.37,126.1) ; v2(156.44,69.4) 156.69,69.15 JAPS1.10 ; JAPS1.12 157.69,69.37 v2(157.71,69.4) ; JAPS1.8 155.69,67.99 v2(155.2,68.47) ; U15.15 159.74,124.01 v2(159.99,123.75) 160.24,124 U15.16 ; U15.5 161.09,127.04 160.95,127.18 v2(160.95,127.56) ; JAPS1.14 158.69,69.3 v2(158.79,69.4) ; JPWR1.6 v2(280.55,169.09) ; 93.7,72.53 v2(92.29,72.53) ; U15.13 157.69,125.04 v2(157.45,125.28) 157.72,125.54 U15.12 ; JPWR1.9 v2(279.05,169.09) ; U15.10 v2(157.45,126.54) ; JLED1.12 v2(185.96,10.35)
  TOP w0.381: v2(74.36,97.1) 74.36,96.87 D1.2 ; CC39.2 131.66,65.54 131.29,65.91 v2(130.92,65.91) ; v2(147.47,95.95) 147.1,96.32 C356.2 ; v2(167.04,122.67) 167.03,122.69 R2696.1 ; PQ516.4 139.78,140.09 v2(140.05,139.82) ; v2(130.28,124.26) 130.4,124.14 PQ515.1 130.9,124.58 131.15,124.83 133.48,124.83 133.75,124.56 PQ519.1 ; UC4.3 138.01,69.19 137.85,69.03 137.85,68.8 v2(138.05,68.6) ; U25.2 164.33,114.76 v2(164.26,114.69) ; PQ409.1 115.85,119.39 115.66,119.57 PC439.2 ; v2(27.79,103.31) 27.79,102.99 27.55,102.75 QZ5.4 ; U11.7 149.56,140.85 v2(148.88,141.53) ; U5.3 191.44,35.85 191.82,36.22 v2(192.12,36.22) ; v2(136.77,138.55) PQ503.4 ; R399.1 136.99,92.12 137.32,92.45 137.32,93.28 v2(137.2,93.4) 136.33,93.4 C365.2 ; v2(123.74,148.45) 123.24,148.95 PQ506.4 ; PC508.2 143.66,153.58 143.24,153.17 PU505.3 ; v2(135.48,126.55) 135.05,126.12 PQ519.4 ; v2(107.92,111.62) 108.05,111.5 C436.2 ; PQ523.1 130.58,139.71 130.35,139.94 v2(129.77,139.94) ; PQ507.4 140.1,131.45 139.86,131.69 139.86,131.82 v2(140.12,132.07) 140.55,132.5 PQ502.1 ; PU1.2 125.07,123.62 v2(125.07,123.63) ; U25.11 158.48,114.91 v2(158.08,114.52) ; v2(164.98,114.67) U25.1 ; v2(61.82,70.59) QZ21.4 ; QZ5.1 28.53,101.45 v2(28.23,101.15) ; v2(143.51,129.44) 143.29,129.66 143.29,129.85 142.99,130.15 PQ507.1 ; v2(158.91,111.31) 158.48,110.87 U25.18 ; RV2435.2 70.15,76.26 v4(69.82,76.6) ; v2(132.82,126.15) 132.31,126.15 PQ515.4 ; PU504.3 146.79,152.7 146.79,150.99 146.28,150.49 v2(145.96,150.49) ; PU503.3 146.16,148.9 v2(146.05,148.78) ; v2(155.29,141.66) 155.29,141.15 155.15,141 U13.7 ; v2(163.61,114.68) 163.68,114.74 U25.3 ; v2(120.13,66.21) 120.31,66.21 120.64,65.89 CC54.2 ; RC235.2 116.73,23.88 v2(116.29,23.88) ; C459.1 98.84,95.24 98.41,94.81 U86.3 ; U25.9 159.78,114.79 v2(159.9,114.67) ; v2(169.94,115.08) 170.1,115.08 CC86.2 ; v2(192.57,92.07) 192.57,91.62 192.68,91.51 U47.3 ; v2(97.87,81.74) 97.65,81.53 C207.2 ; PQ503.1 135.47,135.99 135.25,136.21 134.88,136.21 134.64,135.97 v2(134.64,135.67) ; QZ21.1 60.28,71.89 v2(60.24,71.94) ; Q19.1 84.38,111.36 84.11,111.62 v2(83.79,111.62) ; PQ523.4 131.88,142.1 v2(131.8,142.18) ; v2(160.57,114.67) 160.43,114.81 U25.8 ; U25.25 v2(163.03,108.83) ; C371.2 154.6,112.58 155.1,113.08 v2(155.1,113.21) ; PU500.3 137.63,130.15 138.09,130.61 v2(138.09,130.8) ; v2(221.93,132.46) 220.24,132.46 219.57,133.14 U30.3 219.57,134.25 219.99,134.66 R26.2 ; v2(82.21,108.51) 82.9,108.51 83.08,108.69 Q19.4 ; v2(120.94,120.26) 120.94,119.58 121.07,119.45 PU405.3 ; PQ409.4 118.08,118.06 v2(118.08,117.28) ; PU506.3 147.06,129.51 147.36,129.81 v2(147.7,129.81) ; PQ521.3 141.66,136.32 141.85,136.14 PQ502.4 ; v4(69.42,95.3) 69.9,94.82 RV2648.2 ; v2(163.03,114.67) U25.4 ; v2(141.26,144.14) 141.08,143.96 PQ516.1 ; v4(50.83,94.75) 50.83,94.17 CV232.2 ; v2(74.33,73.98) UV14.3
  TOP w0.4: v4(64.04,78.19) 63.81,77.96 CV88.2
  TOP w0.406: v2(172.25,147.26) 172.42,147.26 172.74,146.95 U20.3 ; v2(101.89,93.84) 102.16,94.11 U87.3 ; U42.3 144.45,119.2 144.63,119.37 v2(144.63,119.69) ; PU401.1 115.43,130.98 v2(115.16,131.25) 115.54,131.63 PU401.2 ; U24.3 v2(182.68,143.55)
  TOP w0.432: Q5.4 173.31,105.64 v2(173.71,106.04) ; v2(97.87,81.74) 96.95,82.65 Q143.4 ; PU502.3 140.5,125.66 v2(140.82,125.34) ; v2(174.88,107.88) 174.61,107.61 Q5.1
  TOP w0.457: C368.2 v2(144.82,91.3) C369.2 ; C202.2 162.04,107.47 v2(161.57,107.47) 161.52,107.42 R305.1 ; v2(191.54,133.77) SW5.6 189.7,133.77 189.02,133.1 SW5.4 ; v2(188.25,130.55) 189.97,130.55 190.6,129.91 SW5.5 ; C75.2 99.06,76.67 99.5,77.11 v2(99.5,77.39) U94.5 ; RC85.2 103.99,82.35 v2(103.61,82.73) ; CC10.2 v2(138.11,2.78) ; v2(136.03,171.3) 135.61,170.88 PQ525.3 ; v2(164.44,72.92) 164.44,73.1 163.75,73.79 CD57.2 ; QZ22.4 22.82,90.64 23.05,90.42 R474.2 ; CC13.2 131.75,47.79 131.6,47.94 v2(131.6,48.89) ; CC74.2 111.61,65.7 111.13,66.18 v2(111.13,66.28) ; CD61.2 160.26,71.64 v2(160.26,70.21)
  TOP w0.508: v2(173.52,38.22) 173.96,38.66 175.1,38.66 CD16.2 175.23,37.47 CD5.2 ; R320.1 R308.1 176.71,101.72 v2(176.88,101.54) ; v2(146.6,120.2) 146.6,120.64 146.03,121.2 C387.2 ; JKB1.1 189.51,110.74 189.85,111.08 v2(190.92,111.08) 191.57,111.08 192.51,112.02 JKB1.11 ; CC44.2 119.28,55.19 v2(119.24,55.15) 119.15,55.06 CC26.2 ; CC33.2 113.1,59.57 v2(113.1,60.41) 112.47,60.41 CC29.2 ; v2(80.43,101.78) 80.95,101.26 JTS1.7 ; v2(135.29,65.24) 135.4,65.13 CC15.1 CC14.1 ; v2(135.17,83.3) 135.17,82.99 134.54,82.36 CC22.2 ; v3(175.81,75.75) 176.35,76.29 PC107.1 ; C404.2 189.84,91.69 189.27,92.26 v2(188.25,92.26) ; UC5.4 127.36,83.37 127.55,83.18 127.55,82.87 v2(127.19,82.52) 127.35,82.35 CC32.2 ; v2(117.77,130.04) 117.77,130.48 PC406.2 ; v2(77.77,92.18) 77.61,92.34 76.8,92.34 RV2652.2 ; CV2967.2 31.15,68.94 CV2968.2 v2(31.1,68.25) ; v4(54.89,87.35) 55.03,87.49 CV101.2 ; v2(129.58,135.37) 129.38,135.57 PC513.2 129.14,136.82 PC514.2 ; v2(230.83,157.69) 230.83,158.37 230.96,158.5 C267.2 ; CD24.2 CD25.2 174.2,72.22 v2(174.2,71.54) ; JMED1.7 175.28,157.9 v2(175.68,158.3) ; PC666.2 62.84,82.35 v2(62.39,81.91) ; v4(56.61,78.19) 56.54,78.26 CV94.2 ; C435.2 95.15,108.77 v2(94.65,108.77) ; R2592.1 R2593.1 v2(96.05,101.78) ; CD58.2 162.58,73.79 CD57.2 ; v2(102.15,56.58) CC58.2 ; C379.2 181.91,104.31 v2(181.46,104.77) ; v2(133.15,147.1) 133.34,146.9 PR509.2 ; CC61.2 102.2,61.19 v2(102.21,61.21) ; C384.2 159.41,107.23 v2(159.68,107.5) ; C384.2 159.04,106.67 160.26,105.45 CC84.2 ; C384.2 C203.2 ; PR56.1 v2(184.82,140.71) ; v2(26.67,82.44) 26.77,82.34 CV2921.2 ; C319.2 180.45,165.15 v2(180.14,165.46) ; v2(116.18,125.09) 116.18,124.49 115.7,124.01 PC432.2 ; v4(60.45,81.94) 60.8,82.29 PC660.2 ; C459.1 99.67,94.6 v2(99.48,94.42) ; v2(200.63,122.42) 200.38,122.67 DE2.1 ; CV2902.2 RV2710.2 34.47,99.29 v2(34.39,99.37) ; v2(35.72,68.06) 35.72,68.43 RV2907.1 ; v2(76.11,90.16) 75.88,89.93 CV3057.2 ; CV2938.2 39.27,99.29 v2(39.34,99.37) ; v2(182.99,134.23) C184.2 183,133.39 R185.2 ; v4(52.47,89.83) 51.98,90.32 CV3058.2 ; v2(155.23,90.04) 155.23,91.28 JTP1.9 ; PC502.1 141.63,129.22 v2(141.36,129.48) ; CD11.2 176.44,45.83 CD21.2 177.52,44.82 177.93,45.23 v2(177.93,45.49) ; v2(110.91,115.31) 110.78,115.43 C441.2 ; v2(159.8,87.81) 159.55,87.56 C328.2 ; C97.2 151.71,148.34 v2(152.22,147.83) 152.63,147.42 Q135.3 ; v2(92,137.99) JLVDS1.44 ; v2(177.71,126.99) 177.66,126.94 C3023.2 ; C262.2 v2(294.61,158.49) ; CV234.2 66.46,88.02 v4(66.85,87.63) ; Q143.1 94.97,84.19 v2(94.46,84.7) ; v2(155.04,13.07) 155.04,12.32 RC128.2 RC132.2 ; v2(172.12,17.76) 171.92,17.56 CD34.2 ; v2(110.46,125.28) PU404.4 ; CV2929.2 29.81,85.41 v2(30.22,85) ; v2(36.99,96.83) 36.99,97.01 36.24,97.76 CV2941.2 ; PD2.1 v2(97.88,169.49) ; v2(38.26,70.6) 38.26,69.09 CV2944.2 ; CC65.2 135.98,57.15 133.48,57.15 133.07,56.75 v2(133.07,56.11) ; v2(179.04,160.58) 178.53,160.07 C192.2 ; PC156.1 v2(156.06,73.83) ; v2(182.03,146.61) 182.23,146.81 C198.2 ; C194.2 184.33,162.56 v2(183.87,162.11) ; CD40.2 171.63,33.39 v2(172.21,33.96) 171.63,34.53 CD48.2 ; v2(136.63,85.81) 136.27,86.16 CC80.1 CC23.2 ; v2(173.58,10.47) 173.21,10.1 CD2.2 CD1.2 ; v2(22.08,91.43) QZ22.4 ; v2(37.77,97.15) 37.3,97.62 CV2935.2 ; v2(146.56,172.17) R120.1 ; JTS1.5 v2(79.41,100.19) 79.31,100.29 78.84,100.29 78.61,100.06 JTS1.4 ; R2638.2 v2(298.16,176.06) ; v2(109.45,118.42) 109.32,118.55 PC428.2 PC429.2 ; v2(134.34,168.56) 134.7,168.2 PR516.2 ; v2(121.13,116.96) 121.45,116.64 PC433.2 ; PC67.2 v2(193.9,146.36) ; CV2960.2 CV2962.2 37.79,81.7 v2(37.79,81.17) ; C201.2 C204.2 156.76,118.24 v2(156.63,118.1) ; v2(187.51,137.49) 186.92,138.09 PC51.1 ; RV2444.1 64.54,94.94 v2(64.59,94.99) ; v2(186.22,97.86) C268.2 187.5,97.86 187.62,97.97 JBIO1.2 ; C440.2 97.5,142.73 v2(96.94,142.17) 97.5,141.61 C451.2 ; v2(234.83,157.67) 235.47,158.3 C266.2 ; v2(116.37,57.49) 116.52,57.33 CC34.2 ; JTP1.10 148.03,90.96 147.55,90.48 v2(146.72,90.48) ; v2(155.12,98.75) 155,98.86 C367.2 R394.2 ; RC198.2 120.43,86.41 v2(120.37,86.48) ; v2(39.09,97.08) 39.09,97.15 39.27,97.32 CV2933.2 ; v2(140.56,90.46) 140.49,90.46 140.48,90.47 140.49,90.47 140.14,90.82 C340.2 140.99,91.24 C343.2 ; v2(229.56,161.29) 230.28,162 C264.2 ; CD23.2 v2(187.72,36.68) ; v4(62.53,83.96) 62.83,84.26 PC664.2 ; RC168.2 133.65,59.8 v2(133.06,60.4) ; C34.2 94.7,86.59 v2(94.59,86.48) 93.65,86.48 C1186.2 ; v2(177.45,170.73) 177.44,170.74 C316.2 ; v2(117.52,59.12) 117.18,58.78 CC43.2 CC28.2 ; RC238.2 120.23,32.29 v2(120.39,32.45) ; RC129.2 131.46,28.61 131.46,28.53 v2(131.36,28.43) ; v4(62.39,91.55) 62.58,91.55 CV3061.2 ; v2(177.45,131.88) R175.1 ; Q9.3 137.83,117.78 138.21,118.16 v2(138.21,118.23) ; v2(147.29,131.87) 147,132.16 PC515.2 ; DE1.1 v2(198.28,126.67) ; v2(231.53,157.69) 231.53,157.11 C263.2 ; 125.01,92.38 125,92.39 C42.2 ; v2(155.14,101.34) 154.89,101.59 C346.2 C352.2 ; PR12.2 116.99,120.26 v2(118.08,120.26) 118.85,120.26 119.12,120.53 PQ3.3 ; C1187.2 v2(185.58,3.93) ; C402.2 C401.2 v2(220.95,151.06) ; PC111.2 171.36,77.93 172.15,77.14 v3(172.34,77.14) ; C443.2 v2(98.08,106.23) ; RC83.2 RC69.2 160.68,27.18 161.19,26.67 v2(161.19,26.25) ; D22.1 184.47,106.73 185.34,105.87 v2(185.34,105.87) ; v2(69.07,79.09) 69.06,79.1 CV3054.2 ; R354.1 176.01,96.41 v2(176,96.4) 175.95,96.45 C331.2 ; R2678.2 91.72,95.7 v2(91.79,95.62) ; CC39.2 RC136.1 ; C452.2 v2(202.35,166.68) ; C360.2 134.97,110.42 134.4,110.99 v2(134.4,112.01) ; CD52.2 163.1,34.97 162.86,34.73 CD37.2 164.21,34.34 v2(164.27,34.28) ; v2(168.93,106.86) 169.01,106.79 R326.2 R303.1 ; v2(63.47,86.93) 63.04,87.35 PC671.2 ; v2(94.72,117.47) 94.72,118.3 94.49,118.52 JLVDS1.41 ; v2(220.95,139.5) 220.95,138.28 C338.2 ; CC66.2 120.56,58.28 v2(120.23,57.95) 119.7,57.95 CC60.2 ; RC50.2 RC52.2 136.31,67.44 136.31,67.62 v2(136.82,68.13) ; v2(167.02,69.08) 167.02,69.78 167.42,70.18 CD55.2 ; v2(147.93,161.98) 147.44,162.47 R121.1 ; v2(129.77,139.94) 129.33,139.5 PR556.2 ; v2(114.91,115.31) 113.97,115.31 PQ410.3 ; PC435.2 104.29,123.06 PR452.2 103.67,123.94 v2(103.67,123.94) ; v2(152.95,129.02) 153.79,129.02 JDEG1.11 ; v2(101.7,60.18) 101.43,60.44 CC79.2 ; v2(128.64,116.91) 129.17,116.37 131.32,116.37 131.88,116.93 PQ528.3 ; R2644.2 v2(302.55,164.08) ; v2(128.24,118.86) 127.23,119.88 PC4.2 ; CC50.2 120.56,51.62 v2(121.59,52.64) ; CC59.2 114.85,57.7 v2(114.65,57.51) ; v2(175.3,87.05) 175.42,86.92 PC112.2 ; v4(54.97,76.61) 55.3,76.94 CV95.2 ; v4(52.47,87.35) 52.04,87.78 CV102.2 ; v2(148.26,148.64) 148.26,147.56 147.99,147.3 Q133.3 ; CV87.2 75.46,77.67 74.97,78.17 v2(74.97,78.67) 74.64,79 RV29.2 ; PC669.2 66.36,85.63 v4(66.77,85.63) ; v2(96.56,101.15) 96.24,100.83 C430.2 ; RV2721.2 RV2722.2 54.91,95 v2(55.66,95.75) ; v2(167.73,87.14) 167.99,87.4 C336.2 168.5,88.51 C330.2 R313.1 169.97,88.5 R310.1 ; CD38.2 161.77,42.87 CD50.2 161.77,44 159.86,44 159.52,43.65 v2(159.52,43.28) ; CV2949.2 29.88,98.67 29.31,99.24 v2(29.31,99.3) ; JBIO1.7 v2(191.72,95.72) ; RV2712.2 37.23,98.67 CV2927.2 v2(37.3,99.62) ; R2586.2 97.83,101.26 v2(97.83,99.88) 98.27,99.88 98.53,99.62 C458.1 ; v2(135.55,61.27) 136.63,61.27 137.31,60.58 CC30.2 ; v2(184.76,142.61) PR53.1 PR55.2 ; v2(128.37,92.38) 128.37,92.89 128.58,93.1 Y1.2 ; v4(57.38,84.95) 56.89,85.44 PC661.2 ; v2(160.58,45.46) 160.58,45.85 161.39,46.66 CD49.2 161.95,46.42 CD35.2 ; PC69.2 v2(193.96,142.55) ; JAPS1.20 162.01,64.19 v2(161.21,63.39) ; CV2932.2 32.69,97.48 v2(32.29,97.08) ; CD47.2 171.04,37.6 CD41.2 171.74,37.52 172.18,37.96 v2(172.18,38.03) ; C406.1 171.61,146.63 v2(172.25,147.26) ; D78.1 v2(186.22,99.53) ; C344.2 C342.2 138.98,94.26 138.82,94.1 v2(138.78,94.1) ; CD4.2 174.6,41.46 v2(174.34,41.71) 175.3,42.66 CD18.2 ; JUDB1.22 87.1,78.29 v2(88.37,79.56) ; U22.1 v2(198.85,166.68) ; JBIO1.8 v2(191.72,103.24) ; C395.2 136.5,115.24 136.18,115.56 v2(135.67,115.56) ; v2(96.75,61.89) 96.75,62.22 96.24,62.73 94.72,62.73 CC75.2 ; CD44.2 CD43.2 174.82,52.58 v2(174.16,51.92) ; C257.2 294.12,155.74 v2(294.26,155.6) ; RC240.2 116.76,20.43 v2(116.68,20.5) ; v2(160.25,37.9) 160.25,38.41 161.26,39.42 CD51.2 161.9,38.59 CD36.2 ; Y3.4 v2(185.27,131.84) ; C193.2 190.42,160.4 v2(189.97,159.95) ; v4(65.51,84.95) 66.27,84.19 PC668.2 ; C400.2 v2(217.59,155.69) ; CV235.2 64.22,88.37 64.63,88.78 64.63,88.88 ; PR537.2 PR547.2 v2(124.24,147.82) ; v2(120.94,120.26) 121.57,120.89 PD5.2 ; CV88.2 CV3048.2 ; v2(32.74,99.37) 32.69,99.32 CV2950.2 ; CC48.2 137.05,17.09 v2(137,17.14) ; JFAN1.6 v2(67.59,105.48) ; v2(42.9,96.76) 42.52,97.15 CV2918.2 ; v2(147.93,116.32) 147.88,116.27 R373.1 ; CV236.2 68.92,88.27 v2(69,88.19) ; v2(167.04,165.25) 166.53,164.74 CE9.2 ; C2989.2 C2991.2 C2987.2 v2(152.75,150.87) ; CV3053.2 71.86,74.41 v2(72.52,73.75) ; v2(215.49,139.12) 215.06,138.69 C409.2 C427.2 ; v2(125.2,125.72) 125.01,125.53 PQ5.6 ; CD6.2 184.95,34.1 CD14.2 185.33,35.17 v2(185.71,35.55) ; CV3060.2 50.2,93.47 v2(49.88,93.78) ; R309.1 164.88,87.68 v2(164.76,87.56) ; C249.2 220.89,142.09 v2(220.89,142.19) ; CV2961.2 CV2964.2 v2(28.41,70.48) ; CE14.2 CE20.2 89.13,27.28 v2(89.19,27.35) ; v2(172.06,86.52) 172.6,86.52 PC114.2 ; CV86.2 v2(49.69,74.86) ; v2(106.4,139.31) PC411.1 ; R2695.1 163.3,120.7 v2(162.33,119.74) ; v2(34.01,70.5) 34.01,70.02 CV2942.2 RV2714.2 ; CC31.2 114.63,60.85 v2(114.64,60.84) 114.64,60.34 CC27.2 ; C2988.2 v2(158.2,156.65) ; v2(109.32,108.07) R2583.1 ; PQ411.3 126.39,118.81 v2(126.4,118.8) ; v2(172.26,69.51) 171.54,70.22 CD59.2 ; C2992.2 163.25,156.02 v2(163.44,155.83) ; PC506.2 v2(137.07,147.06) ; CC81.2 132.37,40.57 v2(132.42,40.51) ; v2(138.6,122.97) 138.91,123.28 PQ508.3 ; v2(104.75,134.74) 104.44,135.04 CE10.2 ; CD56.2 165.86,70.23 v2(164.75,70.23) ; R2585.2 v2(102.35,133.04) ; v2(174.01,149.34) JMED1.8 ; v2(96.68,27.3) 96.62,27.23 96.62,26.68 C635.2 C636.2 ; PR59.2 v2(189.2,147.88) ; CC64.2 115.99,54.75 v2(115.99,55.15) ; v4(69.87,91.45) 70.03,91.61 RV2723.2 ; R32.1 v2(193.08,42.98) ; v2(155.1,108.25) 154.98,108.13 R371.1 C350.2 R383.2 ; PC510.2 v2(142.93,156.39) ; D88.1 78.21,93.78 78.54,93.45 v2(78.54,93.27) ; C434.2 v2(106.73,106.66) ; C2963.2 295.31,164.52 v2(295.75,164.07) 296.38,163.45 R2639.2 ; v2(142.02,138.36) 141.66,137.99 PQ521.3 ; C376.2 185.64,107.29 v2(185.84,107.5) ; v2(115.67,57.52) 115.67,58.02 CC45.2 ; D87.1 v2(195.96,171.8) ; C43.2 128.57,97.01 v2(128.18,97.4) ; v2(151.18,73.32) 151.36,73.5 PC157.2 ; v2(166.32,45.51) 166.47,45.66 CD45.2 ; v2(181.52,129.64) Y3.2 ; C337.2 178.84,93.67 v2(179.04,93.46) ; PR109.2 170.59,85.53 v2(169.49,86.62) ; C186.2 v2(184.71,139.3) ; v4(60.48,83.93) 60.53,83.87 PC663.2 ; PC68.2 v2(194.79,139.31) ; v2(132.71,27.16) 132.08,26.53 RC125.2 ; JLVDS1.43 v2(89.57,130.67) ; PD1.1 v2(95.49,169.47) ; v2(109.07,116.07) 108.88,115.88 C442.2 ; PC410.2 v2(105,147.95) ; 64.63,88.88 v4(64.63,89.01) ; 64.63,88.88 65.14,88.37 CV233.2 ; v2(105.76,85.21) 105.76,85.53 105.12,86.17 RC287.2 ; v2(221.78,156.58) 222.05,156.32 C248.2 ; PQ512.3 144.24,140.9 v2(144.69,140.45) ; v2(112.7,130.47) PR405.2 ; C7.2 73.28,95.58 v2(73.25,95.56) ; CD12.2 CD13.2 184.88,49.91 v2(185.33,49.47) ; v2(92,123.42) JLVDS1.42 ; RC159.2 134.19,61.81 v2(134.26,61.74) ; R2577.1 v2(106.67,103.04) ; JEXP1.41 100.96,20.54 v2(101.45,20.54) ; v2(145.13,116.89) 145.31,117.07 U41.2 ; D77.1 v2(103.35,137.28) ; v2(174.09,69.4) 174.61,69.92 RD6.1 RD5.1 ; CV2943.2 36.58,81.7 v2(36.58,81.12) ; CD29.2 CD28.2 177.12,72.18 CD30.2 177.58,71.74 v2(177.58,71.24) ; JEXP1.42 86.36,22.65 v2(86.43,22.72) ; v2(67.73,97.84) 67.29,97.84 66.77,97.33 JFAN1.5 ; C311.2 R271.2 158.06,170.68 v2(157.95,170.57) ; PC70.2 186.85,146.36 v2(187.11,146.1) 186.54,146.1 186.2,145.77 PR57.1 ; D18.1 17.18,76.35 v2(17.18,77.08) ; v2(103.67,125.72) PC434.2 ; v4(69.89,86.51) 69.74,86.36 CV240.2 ; v2(141.83,159.22) 141.83,159.22 PC503.2 ; CV2930.2 29.99,97.64 v2(29.5,97.15) ; v2(84.91,90.31) 86.49,90.31 JUDB1.21 ; v2(135.04,101.27) 135.42,101.27 135.67,101.53 C353.2 C347.2 ; v2(150.79,113.59) 150.28,113.59 149.9,113.21 C351.2 ; R92.2 113.05,106.43 v2(113.32,106.16) ; PC670.2 58.53,83.93 v2(58.52,83.94) ; v2(99.86,93.59) 99.86,92.64 99.67,92.45 U7.4 ; RC133.2 131.59,25.02 129.94,25.02 v2(129.86,25.1) ; Y1.4 125.66,95.47 v2(125.32,95.81) ; JBIO1.6 v2(189.71,101.97) ; v2(32.67,87.16) 32.67,86.99 32.56,86.87 CV2936.2 RV2909.1 ; CC36.2 120.91,60.53 CC46.2 121.64,60.38 v2(121.69,60.33) ; v2(130.45,36.13) 130.91,36.59 CC12.2 ; v2(96.04,142.82) JLVDS1.45 ; CC52.2 130.65,44.14 v2(130.65,43.55) ; v2(170.73,127.37) 170.74,127.38 C3028.2 ; v2(291.38,165.54) 292.17,165.54 C2964.2 292.49,164.42 v2(292.77,164.14) ; v2(166.32,43.41) 166.32,43.73 CD39.2 ; v2(115.59,30.84) 115.52,30.92 RC239.2 ; v2(297.15,164.09) C2965.2 C2962.2 ; C437.2 v2(111.16,114.55) ; v2(100.49,98.67) 100.38,98.78 R2581.2 ; CC57.1 CC25.1 123.42,85.78 122.99,86.21 v2(122.99,86.43) ; C188.2 186.09,129.33 v2(185.33,130.09) ; C180.2 v2(172.31,136.64) ; v2(169.77,162.61) 169.35,163.04 CE8.2 ; JLED1.13 188.25,4.43 v2(188.25,4.44) ; v2(107.54,120.76) 107.54,120.58 PR453.2 ; v2(139.1,16.87) CC11.2 ; v2(179.55,104.77) 179.22,104.44 C380.2 ; C182.2 183.87,135.83 v2(184.58,136.54) ; v2(107.99,126.61) PR451.2 ; C125.2 203.89,124.15 v2(204.44,124.71) 204.01,125.14 C126.2 ; C634.2 100.25,16.7 v2(100.11,16.56) ; C3027.2 167.06,122.69 v2(167.04,122.67) ; v2(67.33,77.35) 67.36,77.38 CV226.2 ; v2(157.39,94.81) 157.52,94.68 C329.2 R307.1 ; C455.2 v2(74.08,106.8) ; PQ529.3 v2(112.89,152.95) ; v2(136.94,97.14) 136.94,97.08 136.74,96.88 C364.2 ; v4(54.86,81.55) 55.64,80.76 PC662.2 ; v2(157.83,103.5) 158.09,103.24 R321.2 158.52,102.98 158.07,102.53 C332.2 C334.2 ; v2(300.77,164.08) 300.77,164.08 R2626.2 ; C265.2 235.9,161.94 236.65,161.19 v2(236.65,160.64) ; v2(136.33,2.78) CC68.2 ; R438.2 178.74,3.34 v2(179.11,2.98) ; v2(167.87,117.21) 168.12,116.96 C3025.2 ; C374.2 145.95,90.4 v2(146.02,90.48) ; v2(38,83.81) CV2939.2 CV2937.2 ; CD61.2 CD60.2 159.41,72.64 RD11.2 ; CD9.2 176.88,33.77 v2(177.33,33.33) 176.69,32.69 CD17.2 ; v2(135.04,102.57) 135.1,102.63 JTAG1.2 135.13,103.48 R384.2 C362.2 ; C444.2 RC32.2 99.21,108.82 v2(99.22,108.83) ; v2(141.26,114.61) 141.26,115.29 R342.1 ; PQ527.3 v2(147.7,129.81) ; C348.2 150.91,119.94 v2(151.17,119.69) ; v2(307.82,167.25) 307.38,167.69 C1001.2 ; C375.2 v2(179.49,106.73) ; v2(140.94,119.5) C386.2 ; CC24.2 142.87,70.1 143.26,69.71 v2(143.26,69.65) ; CC63.2 113.1,58.49 v2(113.07,58.47) ; v2(131.73,58.05) 131.73,57.56 CC47.2 ; JDEG1.12 153.44,119.61 v2(153.08,119.24) ; R2698.1 v2(165.26,127.38) ; U28.2 v2(233.12,160.71) ; PQ514.3 143.5,147.96 v2(143.86,148.33) ; v2(31.1,70.48) CV2966.2 ; C354.2 v2(135.36,107.69) ; JLED1.14 v2(188.25,10.72) ; C93.2 144.32,145.55 v2(144.88,146.1) ; RC260.2 111.25,23.69 v2(110.96,23.69) ; CC40.2 CC53.2 118.98,60.75 v2(119.02,60.71) 119.57,61.26 CC37.2 ; PC673.2 58.51,82.91 v2(58.52,82.92) ; v2(169.72,81.8) 169.89,81.97 PC115.2 ; R34.1 190.33,33 v2(190.16,32.82) ; CV3056.2 v2(49,69.71) ; C426.2 v2(201.08,169.16) ; CD42.2 172.06,41.52 v2(172.31,41.77) 171.42,42.66 CD46.2 ; PC507.2 v2(143.8,149.91) ; v2(25.56,88.45) 26.01,88.89 CV2926.2 ; JAPS1.19 150.09,65.21 v2(150.53,65.65) ; v2(161.11,10.18) 160.37,9.44 RC195.2 RC221.2 ; v2(185.77,38.73) 185.71,38.66 CD15.2 184.82,38.15 184.64,37.98 CD8.2 ; C377.2 181.18,98.91 v2(180.54,98.91) 180.07,98.91 179.74,99.24 C378.2 ; v2(111.4,55.62) 111.42,55.6 CC51.2 ; v2(171.36,143.31) R25.2 C183.2 ; PU403.4 v2(108.24,131.72) ; CV100.2 57.07,83.32 v4(57.31,83.56) 57.07,83.8 CV228.2 ; C261.1 v2(297.79,151.18) ; CC56.2 118.4,56.3 v2(118.2,56.5) ; R366.1 v2(143.93,113.85) C355.2 ; v2(221.14,131.18) 220.52,130.56 C252.2 C250.2 ; v2(157.68,148.4) 157.96,148.12 C2990.2 ; v2(59.24,89.84) CV231.2 ; v2(185.84,42.73) 185.01,42.73 CD19.2 185.01,41.76 CD7.2 ; JTS1.8 v2(74.91,100) ; C260.1 v2(296.84,151.18) ; R184.2 v2(179.36,145.79) ; v2(152.94,110.93) 153.07,110.8 C363.2 ; CE11.2 v2(103.49,139.01) ; RC154.2 113.41,65.81 113.81,66.21 v2(114.13,66.21) ; CV89.2 v4(59.08,78.19) ; v2(168.55,69.08) 168.55,70.63 CD54.2 ; PC672.2 65.96,81.47 v2(66.52,82.03) ; C349.2 143.36,93.91 v2(143.67,93.59) 143.99,93.91 C366.2 ; RV2715.2 32.22,82.1 v2(32.22,81.4) ; CD3.2 185.86,16.1 v2(186.09,15.87) ; v2(144.44,152.07) 144.44,152.9 144.37,152.96 PC508.2 ; C2972.2 v2(302.6,176.06) ; PC504.2 v2(143.61,159.05) ; v2(100.94,63.87) 100.37,64.44 CC62.2 ; JKB1.3 v2(187.51,111.24) ; JPWR1.12 v2(276.4,169.21) ; v2(181.2,130.93) C190.1 ; v2(164.94,8.94) 164.94,9.15 164.43,9.66 CD32.2 CD33.2 ; CD10.2 184.76,44.58 CD20.2 185.46,45.58 v2(185.58,45.71) ; v2(205.9,124.83) 205.9,127.31 205.32,127.89 C127.2 ; v2(159.66,95.57) C339.2 ; v2(138.33,134.59) PC500.1 ; v2(307.82,166.4) 307.54,166.4 C482.2 ; PC3.2 v2(101.12,169.78) ; C1185.2 v2(313.98,165.71) ; PC439.2 115.16,119.75 v2(115.61,120.2) ; C200.2 v2(163.36,117.33) ; C357.2 v2(155.1,99.81) ; C185.2 v2(184.71,138.41) ; PC431.2 PR444.2 115.1,121.54 v2(115.63,121.54) ; JFAN1.4 v2(72.77,103.28) ; C124.2 v2(203.75,120.45) ; C454.2 v2(69.95,110.86) ; RC305.1 v2(106.96,86.29) ; JPWR1.11 v2(285.2,169.28)
  GND1 w0.203: 210.2,119.27 H11.1 ; H11.1 208.86,119.76 ; H11.1 208.86,122.44 ; H11.1 212.03,121.1 ; H11.1 211.54,122.44 ; H11.1 210.2,122.93 ; H11.1 208.37,121.1 ; H11.1 211.54,119.76 ; 140.97,169.98 JDOCK1.145 ; JDOCK1.145 142.03,169.98 ; JDOCK1.145 143.08,169.98 ; JDOCK1.145 143.08,166.02 ; JDOCK1.145 143.08,168 ; JDOCK1.145 140.97,166.02 ; JDOCK1.145 142.03,166.02 ; JDOCK1.145 140.97,168 ; 12.48,90.22 JHDMI1.2 ; JHDMI1.2 11.89,90.8 ; JHDMI1.2 12.01,90.34 ; JHDMI1.2 12.01,91.26 ; JHDMI1.2 12.94,91.26 ; JHDMI1.2 13.06,90.8 ; JHDMI1.2 12.94,90.34 ; JUSB1.13 7.13,83.13 ; JUSB1.13 5.76,84.88 ; JUSB1.13 7.13,84.88 ; JUSB1.13 4.39,83.13 ; JUSB1.13 4.39,84 ; JUSB1.13 7.13,84 ; JUSB1.13 5.76,83.13 ; H24.1 81.91,121.93 ; H24.1 81.91,119.25 ; H24.1 79.23,121.93 ; H24.1 80.57,118.76 ; H24.1 82.4,120.59 ; H24.1 79.23,119.25 ; H24.1 80.57,122.42 ; H24.1 78.74,120.59 ; 141.64,164.08 JDOCK1.153 ; JDOCK1.153 145.76,164.08 ; JDOCK1.153 141.64,165.05 ; JDOCK1.153 145.76,163.1 ; JDOCK1.153 141.64,163.1 ; JDOCK1.153 143.7,163.1 ; JDOCK1.153 143.7,165.05 ; JDOCK1.153 145.76,165.05 ; JDOCK1.163 172.2,172.9 ; JDOCK1.163 173.25,172.9 ; JDOCK1.163 171.15,172.9 ; JDOCK1.163 173.25,170.95 ; JDOCK1.163 171.15,171.93 ; JDOCK1.163 172.2,170.95 ; JDOCK1.163 173.25,171.93 ; JDOCK1.163 171.15,170.95 ; 123.88,11.72 H4.1 ; H4.1 125.87,12.47 ; H4.1 123.88,7.76 ; H4.1 127.85,11.72 ; H4.1 127.85,7.76 ; H4.1 123.13,9.74 ; H4.1 125.87,7.01 ; H4.1 128.6,9.74 ; 205.67,171.5 H14.1 ; H14.1 207.5,169.67 ; H14.1 206.16,170.16 ; H14.1 208.84,172.84 ; H14.1 206.16,172.84 ; H14.1 209.33,171.5 ; H14.1 208.84,170.16 ; 93.59,173 PBATT2.4 ; PBATT2.4 94.46,173.88 ; PBATT2.4 93.79,173.67 ; PBATT2.4 93.79,172.33 ; PBATT2.4 95.13,173.67 ; PBATT2.4 95.13,172.33 ; PBATT2.4 94.46,172.12 ; PBATT2.4 95.34,173 ; 3.15,103.02 JHDMI1.23 ; JHDMI1.23 5.71,103.95 ; JHDMI1.23 3.15,104.88 ; JHDMI1.23 4.43,103.02 ; JHDMI1.23 3.15,103.95 ; JHDMI1.23 5.71,103.02 ; JHDMI1.23 4.43,104.88 ; JHDMI1.23 5.71,104.88 ; H19.1 45.3,58.78 ; H19.1 45.3,54.61 ; H19.1 46.82,58.22 ; H19.1 43.77,55.17 ; H19.1 46.82,55.17 ; H19.1 43.21,56.7 ; H19.1 47.38,56.7 ; H19.1 43.77,58.22 ; 78.73,19.3 H22.1 ; H22.1 80.81,21.38 ; H22.1 82.33,17.78 ; H22.1 79.29,20.82 ; H22.1 82.33,20.82 ; H22.1 82.89,19.3 ; H22.1 79.29,17.78 ; H22.1 80.81,17.22 ; JDOCK1.155 173.25,165.05 ; JDOCK1.155 173.25,164.08 ; JDOCK1.155 173.25,163.1 ; JDOCK1.155 172.2,163.1 ; JDOCK1.155 172.2,165.05 ; JDOCK1.155 171.15,163.1 ; JDOCK1.155 171.15,165.05 ; JDOCK1.155 171.15,164.08 ; 107.59,170.99 PBATT2.10 ; PBATT2.10 106.53,173 ; PBATT2.10 108.64,170.99 ; PBATT2.10 108.64,173 ; PBATT2.10 106.53,170.99 ; PBATT2.1 89.13,172.33 ; PBATT2.1 88.46,173.88 ; PBATT2.1 88.46,172.12 ; PBATT2.1 87.79,172.33 ; PBATT2.1 87.79,173.67 ; PBATT2.1 89.13,173.67 ; PBATT2.1 87.59,173 ; PBATT2.1 89.34,173 ; 10.47,97.84 JHDMI1.17 ; JHDMI1.17 10.34,98.3 ; JHDMI1.17 11.39,98.76 ; JHDMI1.17 11.39,97.84 ; JHDMI1.17 11.51,98.3 ; JHDMI1.17 10.47,98.76 ; H13.1 95.54,10.96 ; H13.1 95.54,13.64 ; H13.1 94.2,14.13 ; H13.1 96.03,12.3 ; H13.1 94.2,10.47 ; H13.1 92.86,13.64 ; H13.1 92.86,10.96 ; H13.1 92.37,12.3 ; JUSB1.12 7.13,68.58 ; JUSB1.12 5.76,66.83 ; JUSB1.12 7.13,66.83 ; JUSB1.12 5.76,68.58 ; JUSB1.12 7.13,67.7 ; JUSB1.12 4.39,67.7 ; JUSB1.12 4.39,68.58 ; JUSB1.12 4.39,66.83 ; 171.4,168.8 JDOCK1.159 ; JDOCK1.159 173,168.8 ; JDOCK1.159 172.2,169.05 ; JDOCK1.159 171.4,167.2 ; JDOCK1.159 171.15,168 ; JDOCK1.159 173,167.2 ; JDOCK1.159 172.2,166.95 ; JDOCK1.159 173.25,168 ; JDOCK1.154 161.25,165.05 ; JDOCK1.154 160.2,163.1 ; JDOCK1.154 159.15,163.1 ; JDOCK1.154 159.15,164.08 ; JDOCK1.154 160.2,165.05 ; JDOCK1.154 161.25,164.08 ; JDOCK1.154 159.15,165.05 ; JDOCK1.154 161.25,163.1 ; H23.1 95.48,114.53 ; H23.1 96.04,113.01 ; H23.1 93.96,115.09 ; H23.1 95.48,111.49 ; H23.1 92.43,111.49 ; H23.1 92.43,114.53 ; H23.1 91.87,113.01 ; H23.1 93.96,110.93 ; 16.36,88.84 H9.1 ; H9.1 17.7,85.67 ; H9.1 19.04,88.84 ; H9.1 17.7,89.33 ; H9.1 15.87,87.5 ; H9.1 19.04,86.16 ; H9.1 19.53,87.5 ; H9.1 16.36,86.16 ; 160.2,170.95 JDOCK1.162 ; JDOCK1.162 159.15,171.93 ; JDOCK1.162 160.2,172.9 ; JDOCK1.162 159.15,170.95 ; JDOCK1.162 159.15,172.9 ; JDOCK1.162 161.25,172.9 ; JDOCK1.162 161.25,171.93 ; JDOCK1.162 161.25,170.95 ; JHDMI1.8 13.06,93.8 ; JHDMI1.8 12.01,94.26 ; JHDMI1.8 11.89,93.8 ; JHDMI1.8 12.94,94.26 ; JHDMI1.8 12.94,93.34 ; JHDMI1.8 12.01,93.34 ; 13.74,75.17 JUSB1.7 ; JUSB1.7 13.74,76.54 ; JUSB1.7 14.27,76.39 ; JUSB1.7 14.27,75.32 ; JUSB1.7 14.42,75.85 ; JUSB1.4 15.77,71.82 ; JUSB1.4 15.24,71.67 ; JUSB1.4 15.77,72.89 ; JUSB1.4 15.92,72.35 ; JUSB1.4 15.24,73.04 ; JUSB1.4 14.7,71.82 ; JUSB1.4 14.55,72.35 ; JUSB1.4 14.7,72.89 ; JDOCK1.152 191.43,166.02 ; JDOCK1.152 189.32,169.98 ; JDOCK1.152 190.38,166.02 ; JDOCK1.152 191.43,169.98 ; JDOCK1.152 190.38,169.98 ; JDOCK1.152 189.32,166.02 ; JDOCK1.152 191.43,168 ; JDOCK1.152 189.32,168 ; 84.23,150.68 H16.1 ; H16.1 85.4,150.26 ; H16.1 85.4,153.44 ; H16.1 84.23,153.02 ; H16.1 86.57,153.02 ; H16.1 86.99,151.85 ; H16.1 86.57,150.68 ; H16.1 83.81,151.85 ; H5.1 196.74,17.84 ; H5.1 195.4,14.67 ; H5.1 194.06,15.16 ; H5.1 194.06,17.84 ; H5.1 196.74,15.16 ; H5.1 195.4,18.33 ; H5.1 197.23,16.5 ; H5.1 193.57,16.5 ; 11.08,68.58 JUSB1.10 ; JUSB1.10 14.64,66.83 ; JUSB1.10 12.86,66.83 ; JUSB1.10 11.08,66.83 ; JUSB1.10 11.08,67.7 ; JUSB1.10 14.64,68.58 ; JUSB1.10 12.86,68.58 ; JUSB1.10 14.64,67.7 ; 8.2,103.02 JHDMI1.22 ; JHDMI1.22 10.76,103.95 ; JHDMI1.22 10.76,104.88 ; JHDMI1.22 10.76,103.02 ; JHDMI1.22 9.48,103.02 ; JHDMI1.22 8.2,104.88 ; JHDMI1.22 9.48,104.88 ; JHDMI1.22 8.2,103.95 ; H17.1 19.2,71.03 ; H17.1 18.17,70 ; H17.1 19.98,70.78 ; H17.1 19.98,69.22 ; H17.1 18.42,70.78 ; H17.1 18.42,69.22 ; H17.1 19.2,68.97 ; H17.1 20.23,70 ; 105.87,73.16 H3.1 ; H3.1 104,77.61 ; H3.1 107.74,77.61 ; H3.1 104,73.87 ; H3.1 108.45,75.74 ; H3.1 107.74,73.87 ; H3.1 103.29,75.74 ; H3.1 105.87,78.32 ; 125.87,73.01 H1.1 ; H1.1 127.85,77.72 ; H1.1 123.13,75.74 ; H1.1 128.6,75.74 ; H1.1 125.87,78.47 ; H1.1 123.88,77.72 ; H1.1 123.88,73.76 ; H1.1 127.85,73.76 ; 103.13,9.74 H2.1 ; H2.1 103.88,7.76 ; H2.1 107.85,11.72 ; H2.1 105.87,12.47 ; H2.1 105.87,7.01 ; H2.1 107.85,7.76 ; H2.1 103.88,11.72 ; H2.1 108.6,9.74 ; 6.77,6.73 H8.1 ; H8.1 6.77,2.47 ; H8.1 11.83,4.6 ; H8.1 8.9,1.67 ; H8.1 11.03,6.73 ; H8.1 5.97,4.6 ; H8.1 11.03,2.47 ; H8.1 8.9,7.53 ; JSATA2.14 198.8,23.27 ; JSATA2.14 198.8,22.49 ; JSATA2.14 197.4,22.49 ; JSATA2.14 196,24.04 ; JSATA2.14 196,23.27 ; JSATA2.14 196,22.49 ; JSATA2.14 198.8,24.04 ; JSATA2.14 197.4,24.04 ; 183.4,168.8 JDOCK1.160 ; JDOCK1.160 185.25,168 ; JDOCK1.160 183.4,167.2 ; JDOCK1.160 184.2,166.95 ; JDOCK1.160 183.15,168 ; JDOCK1.160 185,168.8 ; JDOCK1.160 184.2,169.05 ; JDOCK1.160 185,167.2 ; 196,45.82 JSATA2.15 ; JSATA2.15 198.8,45.82 ; JSATA2.15 197.4,45.04 ; JSATA2.15 196,45.04 ; JSATA2.15 198.8,45.04 ; JSATA2.15 198.8,46.59 ; JSATA2.15 196,46.59 ; JSATA2.15 197.4,46.59 ; 124.9,169.67 H15.1 ; H15.1 123.07,171.5 ; H15.1 126.24,170.16 ; H15.1 126.24,172.84 ; H15.1 123.56,172.84 ; H15.1 126.73,171.5 ; H15.1 123.56,170.16 ; 104.29,21.68 H21.1 ; H21.1 107.33,24.72 ; H21.1 104.29,24.72 ; H21.1 103.73,23.2 ; H21.1 105.81,25.28 ; H21.1 107.89,23.2 ; H21.1 107.33,21.68 ; H21.1 105.81,21.12 ; 78.64,110.12 H20.1 ; H20.1 78.64,114.29 ; H20.1 77.12,110.68 ; H20.1 80.17,113.73 ; H20.1 76.56,112.21 ; H20.1 77.12,113.73 ; H20.1 80.73,112.21 ; H20.1 80.17,110.68 ; JDOCK1.164 190.76,171.93 ; JDOCK1.164 188.7,172.9 ; JDOCK1.164 186.64,170.95 ; JDOCK1.164 190.76,172.9 ; JDOCK1.164 188.7,170.95 ; JDOCK1.164 190.76,170.95 ; JDOCK1.164 186.64,171.93 ; JDOCK1.164 186.64,172.9 ; JHDMI1.11 11.51,95.3 ; JHDMI1.11 10.34,95.3 ; JHDMI1.11 10.47,94.84 ; JHDMI1.11 11.39,95.76 ; JHDMI1.11 10.47,95.76 ; JHDMI1.11 11.39,94.84 ; JSATA1.24 88.31,141.94 ; JSATA1.24 85.79,144.46 ; JSATA1.24 87.05,144.92 ; JSATA1.24 88.76,143.2 ; JSATA1.24 85.79,141.94 ; JSATA1.24 87.05,141.49 ; JSATA1.24 85.33,143.2 ; JSATA1.24 88.31,144.46 ; H18.1 10.47,15.44 ; H18.1 10.47,18.49 ; H18.1 8.94,14.89 ; H18.1 7.42,15.44 ; H18.1 11.02,16.97 ; H18.1 8.94,19.05 ; H18.1 6.86,16.97 ; H18.1 7.42,18.49 ; JSATA1.23 88.76,103.2 ; JSATA1.23 85.79,101.94 ; JSATA1.23 87.05,101.49 ; JSATA1.23 87.05,104.92 ; JSATA1.23 88.31,104.46 ; JSATA1.23 88.31,101.94 ; JSATA1.23 85.33,103.2 ; JSATA1.23 85.79,104.46 ; JDOCK1.158 161.25,168 ; JDOCK1.158 160.2,169.05 ; JDOCK1.158 159.15,168 ; JDOCK1.158 161,167.2 ; JDOCK1.158 161,168.8 ; JDOCK1.158 159.4,167.2 ; JDOCK1.158 159.4,168.8 ; JDOCK1.158 160.2,166.95 ; 85.24,93.77 H7.1 ; H7.1 83.9,94.26 ; H7.1 87.07,95.6 ; H7.1 83.41,95.6 ; H7.1 86.58,94.26 ; H7.1 86.58,96.95 ; H7.1 85.24,97.43 ; H7.1 83.9,96.95 ; JDOCK1.161 145.76,170.95 ; JDOCK1.161 143.7,172.9 ; JDOCK1.161 143.7,170.95 ; JDOCK1.161 141.64,171.93 ; JDOCK1.161 141.64,172.9 ; JDOCK1.161 145.76,171.93 ; JDOCK1.161 145.76,172.9 ; JDOCK1.161 141.64,170.95 ; PBATT2.2 91.13,173.67 ; PBATT2.2 90.46,173.88 ; PBATT2.2 89.59,173 ; PBATT2.2 90.46,172.12 ; PBATT2.2 89.79,173.67 ; PBATT2.2 91.34,173 ; PBATT2.2 91.13,172.33 ; PBATT2.2 89.79,172.33 ; 3.15,85.65 JHDMI1.21 ; JHDMI1.21 4.43,86.58 ; JHDMI1.21 4.43,84.72 ; JHDMI1.21 5.71,86.58 ; JHDMI1.21 3.15,84.72 ; JHDMI1.21 5.71,85.65 ; JHDMI1.21 3.15,86.58 ; JDOCK1.157 148.2,169.05 ; JDOCK1.157 149.25,168 ; JDOCK1.157 147.4,168.8 ; JDOCK1.157 149,167.2 ; JDOCK1.157 148.2,166.95 ; JDOCK1.157 147.15,168 ; JDOCK1.157 147.4,167.2 ; JDOCK1.157 149,168.8 ; H12.1 310.94,172.26 ; H12.1 309.6,171.77 ; H12.1 308.26,172.26 ; H12.1 311.43,173.6 ; H12.1 307.77,173.6 ; H12.1 309.6,175.43 ; H12.1 308.26,174.94 ; H12.1 310.94,174.94 ; JHDMI1.20 9.48,86.58 ; JHDMI1.20 10.76,86.58 ; JHDMI1.20 10.76,85.65 ; JHDMI1.20 9.48,84.72 ; JHDMI1.20 10.76,84.72 ; JHDMI1.20 8.2,84.72 ; JHDMI1.20 8.2,85.65 ; JHDMI1.20 8.2,86.58 ; 195.4,51.67 H10.1 ; H10.1 197.48,53.5 ; H10.1 193.32,51.67 ; H10.1 193.32,53.5 ; H10.1 193.32,55.33 ; H10.1 197.48,55.33 ; H10.1 197.48,51.67 ; H10.1 195.4,55.33 ; 186.64,163.1 JDOCK1.156 ; JDOCK1.156 186.64,165.05 ; JDOCK1.156 190.76,165.05 ; JDOCK1.156 188.7,163.1 ; JDOCK1.156 190.76,164.08 ; JDOCK1.156 190.76,163.1 ; JDOCK1.156 186.64,164.08 ; JDOCK1.156 188.7,165.05 ; 84.28,173 PBATT2.11 ; PBATT2.11 86.39,173 ; PBATT2.11 86.39,170.99 ; PBATT2.11 84.28,170.99 ; PBATT2.11 85.34,170.99 ; JUSB1.11 14.64,83.13 ; JUSB1.11 14.64,84 ; JUSB1.11 14.64,84.88 ; JUSB1.11 11.08,83.13 ; JUSB1.11 11.08,84 ; JUSB1.11 12.86,84.88 ; JUSB1.11 12.86,83.13 ; JUSB1.11 11.08,84.88 ; 10.47,91.84 JHDMI1.5 ; JHDMI1.5 10.47,92.76 ; JHDMI1.5 11.39,92.76 ; JHDMI1.5 11.51,92.3 ; JHDMI1.5 11.39,91.84 ; JHDMI1.5 10.34,92.3
  VCC w0.203: 11.89,90.8 JHDMI1.2 ; JHDMI1.2 12.48,90.22 ; JHDMI1.2 12.94,90.34 ; JHDMI1.2 13.06,90.8 ; JHDMI1.2 12.01,90.34 ; JHDMI1.2 12.94,91.26 ; JHDMI1.2 12.01,91.26 ; 4.39,66.83 JUSB1.12 ; JUSB1.12 4.39,67.7 ; JUSB1.12 5.76,66.83 ; JUSB1.12 7.13,66.83 ; JUSB1.12 7.13,67.7 ; H9.1 17.7,89.33 ; H9.1 17.7,85.67 ; H9.1 19.53,87.5 ; H9.1 19.04,88.84 ; H9.1 16.36,88.84 ; H9.1 15.87,87.5 ; H9.1 19.04,86.16 ; H9.1 16.36,86.16 ; JHDMI1.21 5.71,85.65 ; JHDMI1.21 4.43,84.72 ; JHDMI1.21 3.79,84.72 ; 3.15,104.88 JHDMI1.23 ; JHDMI1.23 5.71,103.95 ; JHDMI1.23 4.43,104.88 ; JHDMI1.23 3.15,103.95 ; JHDMI1.23 5.71,104.88 ; JHDMI1.22 10.76,104.88 ; JHDMI1.22 9.48,104.88 ; JHDMI1.22 8.2,104.88 ; JHDMI1.22 10.76,103.95 ; JHDMI1.22 8.2,103.95 ; JHDMI1.8 12.94,94.26 ; JHDMI1.8 13.06,93.8 ; JHDMI1.8 11.89,93.8 ; JHDMI1.8 12.94,93.34 ; JHDMI1.8 12.01,93.34 ; JHDMI1.8 12.01,94.26 ; JUSB1.10 14.64,67.7 ; JUSB1.10 12.86,66.83 ; JUSB1.10 14.64,66.83 ; JUSB1.10 11.08,67.7 ; JUSB1.10 11.08,66.83 ; JHDMI1.11 11.39,95.76 ; JHDMI1.11 11.51,95.3 ; JHDMI1.11 11.39,94.84 ; 8.2,84.72 JHDMI1.20 ; JHDMI1.20 10.76,84.72 ; JHDMI1.20 9.48,84.72 ; JHDMI1.20 10.76,85.65 ; JHDMI1.20 8.2,85.65 ; 15.24,71.67 JUSB1.4 ; JUSB1.4 15.24,73.04 ; JUSB1.4 14.7,71.82 ; JUSB1.4 15.92,72.35 ; JUSB1.4 15.77,71.82 ; JUSB1.4 15.77,72.89 ; JUSB1.4 14.55,72.35 ; JUSB1.4 14.7,72.89 ; H18.1 10.47,18.49 ; H18.1 8.94,14.89 ; H18.1 8.94,19.05 ; H18.1 7.42,18.49 ; H18.1 6.86,16.97 ; H18.1 10.47,15.44 ; H18.1 11.02,16.97 ; H18.1 7.42,15.44 ; 11.08,84.88 JUSB1.11 ; JUSB1.11 14.64,84 ; JUSB1.11 11.08,84 ; JUSB1.11 14.64,84.88 ; JUSB1.11 12.86,84.88 ; 4.39,84 JUSB1.13 ; JUSB1.13 7.13,84 ; JUSB1.13 5.76,84.88 ; JUSB1.13 7.13,84.88 ; JHDMI1.17 11.51,98.3 ; JHDMI1.17 11.39,98.76 ; JHDMI1.17 11.39,97.84 ; JHDMI1.5 11.39,92.76 ; JHDMI1.5 11.39,91.84 ; JHDMI1.5 11.51,92.3 ; 8.9,1.67 H8.1 ; H8.1 11.03,2.47 ; H8.1 11.83,4.6 ; H8.1 5.97,4.6 ; H8.1 6.77,6.73 ; H8.1 11.03,6.73 ; H8.1 6.77,2.47 ; H8.1 8.9,7.53 ; JUSB1.7 14.27,76.39 ; JUSB1.7 14.27,75.32 ; JUSB1.7 14.42,75.85
  GND2 w0.203: JDOCK1.161 145.76,170.95 ; JDOCK1.161 141.64,172.9 ; JDOCK1.161 145.76,171.93 ; JDOCK1.161 143.7,170.95 ; JDOCK1.161 145.76,172.9 ; JDOCK1.161 141.64,170.95 ; JDOCK1.161 141.64,171.93 ; JDOCK1.161 143.7,172.9 ; 93.96,110.93 H23.1 ; H23.1 95.48,111.49 ; H23.1 92.43,111.49 ; H23.1 95.48,114.53 ; H23.1 91.87,113.01 ; H23.1 96.04,113.01 ; H23.1 92.43,114.53 ; H23.1 93.96,115.09 ; 19.2,68.97 H17.1 ; H17.1 20.23,70 ; H17.1 18.42,70.78 ; H17.1 19.98,70.78 ; H17.1 19.2,71.03 ; H17.1 18.17,70 ; H17.1 18.42,69.22 ; H17.1 19.98,69.22 ; 78.73,19.3 H22.1 ; H22.1 80.81,21.38 ; H22.1 82.89,19.3 ; H22.1 82.33,17.78 ; H22.1 80.81,17.22 ; H22.1 79.29,20.82 ; H22.1 82.33,20.82 ; H22.1 79.29,17.78 ; JHDMI1.17 11.51,98.3 ; JHDMI1.17 11.39,98.76 ; JHDMI1.17 10.34,98.3 ; JHDMI1.17 11.39,97.84 ; JHDMI1.17 10.47,98.76 ; JHDMI1.17 10.47,97.84 ; PBATT2.1 89.34,173 ; PBATT2.1 87.79,172.33 ; PBATT2.1 89.13,172.33 ; PBATT2.1 89.13,173.67 ; PBATT2.1 87.59,173 ; PBATT2.1 88.46,172.12 ; PBATT2.1 88.46,173.88 ; PBATT2.1 87.79,173.67 ; 124.9,169.67 H15.1 ; H15.1 126.24,170.16 ; H15.1 123.56,172.84 ; H15.1 123.56,170.16 ; H15.1 126.24,172.84 ; H15.1 126.73,171.5 ; H15.1 123.07,171.5 ; 93.79,173.67 PBATT2.4 ; PBATT2.4 93.79,172.33 ; PBATT2.4 94.46,173.88 ; PBATT2.4 95.13,172.33 ; PBATT2.4 95.13,173.67 ; PBATT2.4 93.59,173 ; PBATT2.4 94.46,172.12 ; PBATT2.4 95.34,173 ; 183.4,167.2 JDOCK1.160 ; JDOCK1.160 184.2,169.05 ; JDOCK1.160 183.15,168 ; JDOCK1.160 185,168.8 ; JDOCK1.160 183.4,168.8 ; JDOCK1.160 184.2,166.95 ; JDOCK1.160 185.25,168 ; JDOCK1.160 185,167.2 ; 12.86,66.83 JUSB1.10 ; JUSB1.10 11.08,68.58 ; JUSB1.10 11.08,66.83 ; JUSB1.10 14.64,66.83 ; JUSB1.10 14.64,68.58 ; JUSB1.10 12.86,68.58 ; JUSB1.10 14.64,67.7 ; JUSB1.10 11.08,67.7 ; JHDMI1.8 13.06,93.8 ; JHDMI1.8 12.94,94.26 ; JHDMI1.8 11.89,93.8 ; JHDMI1.8 12.94,93.34 ; JHDMI1.8 12.01,93.34 ; JHDMI1.8 12.01,94.26 ; H11.1 211.54,122.44 ; H11.1 208.86,122.44 ; H11.1 212.03,121.1 ; H11.1 210.2,119.27 ; H11.1 211.54,119.76 ; H11.1 208.86,119.76 ; H11.1 208.37,121.1 ; H11.1 210.2,122.93 ; JSATA2.14 197.4,24.04 ; JSATA2.14 198.8,23.27 ; JSATA2.14 196,23.27 ; JSATA2.14 197.4,22.49 ; JSATA2.14 198.8,22.49 ; JSATA2.14 198.8,24.04 ; JSATA2.14 196,24.04 ; JSATA2.14 196,22.49 ; 186.64,172.9 JDOCK1.164 ; JDOCK1.164 190.76,171.93 ; JDOCK1.164 186.64,171.93 ; JDOCK1.164 186.64,170.95 ; JDOCK1.164 190.76,172.9 ; JDOCK1.164 188.7,170.95 ; JDOCK1.164 190.76,170.95 ; JDOCK1.164 188.7,172.9 ; 4.43,84.72 JHDMI1.21 ; JHDMI1.21 5.71,85.65 ; JHDMI1.21 3.15,84.72 ; JHDMI1.21 5.71,86.58 ; JHDMI1.21 3.15,86.58 ; JHDMI1.21 3.15,85.65 ; JHDMI1.21 4.43,86.58 ; 16.36,86.16 H9.1 ; H9.1 19.53,87.5 ; H9.1 19.04,88.84 ; H9.1 17.7,85.67 ; H9.1 15.87,87.5 ; H9.1 19.04,86.16 ; H9.1 16.36,88.84 ; H9.1 17.7,89.33 ; H21.1 107.33,21.68 ; H21.1 105.81,25.28 ; H21.1 104.29,24.72 ; H21.1 107.89,23.2 ; H21.1 104.29,21.68 ; H21.1 107.33,24.72 ; H21.1 105.81,21.12 ; H21.1 103.73,23.2 ; JHDMI1.5 11.39,91.84 ; JHDMI1.5 11.51,92.3 ; JHDMI1.5 10.47,91.84 ; JHDMI1.5 10.34,92.3 ; JHDMI1.5 11.39,92.76 ; JHDMI1.5 10.47,92.76 ; 172.2,170.95 JDOCK1.163 ; JDOCK1.163 173.25,170.95 ; JDOCK1.163 173.25,172.9 ; JDOCK1.163 173.25,171.93 ; JDOCK1.163 171.15,171.93 ; JDOCK1.163 171.15,172.9 ; JDOCK1.163 172.2,172.9 ; JDOCK1.163 171.15,170.95 ; H12.1 310.94,174.94 ; H12.1 311.43,173.6 ; H12.1 309.6,171.77 ; H12.1 310.94,172.26 ; H12.1 308.26,172.26 ; H12.1 309.6,175.43 ; H12.1 308.26,174.94 ; H12.1 307.77,173.6 ; PBATT2.2 91.34,173 ; PBATT2.2 91.13,172.33 ; PBATT2.2 89.79,172.33 ; PBATT2.2 91.13,173.67 ; PBATT2.2 90.46,173.88 ; PBATT2.2 90.46,172.12 ; PBATT2.2 89.59,173 ; PBATT2.2 89.79,173.67 ; 5.76,66.83 JUSB1.12 ; JUSB1.12 5.76,68.58 ; JUSB1.12 4.39,66.83 ; JUSB1.12 4.39,67.7 ; JUSB1.12 7.13,68.58 ; JUSB1.12 7.13,67.7 ; JUSB1.12 7.13,66.83 ; JUSB1.12 4.39,68.58 ; H10.1 195.4,55.33 ; H10.1 197.48,53.5 ; H10.1 195.4,51.67 ; H10.1 197.48,55.33 ; H10.1 197.48,51.67 ; H10.1 193.32,51.67 ; H10.1 193.32,53.5 ; H10.1 193.32,55.33 ; 85.24,93.77 H7.1 ; H7.1 87.07,95.6 ; H7.1 83.9,96.95 ; H7.1 86.58,96.95 ; H7.1 85.24,97.43 ; H7.1 83.41,95.6 ; H7.1 83.9,94.26 ; H7.1 86.58,94.26 ; H24.1 82.4,120.59 ; H24.1 81.91,119.25 ; H24.1 78.74,120.59 ; H24.1 80.57,118.76 ; H24.1 80.57,122.42 ; H24.1 81.91,121.93 ; H24.1 79.23,119.25 ; H24.1 79.23,121.93 ; JDOCK1.159 173,168.8 ; JDOCK1.159 173,167.2 ; JDOCK1.159 171.4,167.2 ; JDOCK1.159 171.4,168.8 ; JDOCK1.159 171.15,168 ; JDOCK1.159 172.2,166.95 ; JDOCK1.159 172.2,169.05 ; JDOCK1.159 173.25,168 ; 84.23,153.02 H16.1 ; H16.1 86.57,150.68 ; H16.1 86.57,153.02 ; H16.1 85.4,153.44 ; H16.1 84.23,150.68 ; H16.1 86.99,151.85 ; H16.1 85.4,150.26 ; H16.1 83.81,151.85 ; H20.1 80.17,110.68 ; H20.1 80.73,112.21 ; H20.1 78.64,114.29 ; H20.1 77.12,113.73 ; H20.1 76.56,112.21 ; H20.1 78.64,110.12 ; H20.1 77.12,110.68 ; H20.1 80.17,113.73 ; JHDMI1.20 9.48,86.58 ; JHDMI1.20 10.76,85.65 ; JHDMI1.20 9.48,84.72 ; JHDMI1.20 10.76,86.58 ; JHDMI1.20 8.2,85.65 ; JHDMI1.20 8.2,86.58 ; JHDMI1.20 8.2,84.72 ; JHDMI1.20 10.76,84.72 ; JDOCK1.162 160.2,172.9 ; JDOCK1.162 161.25,171.93 ; JDOCK1.162 159.15,171.93 ; JDOCK1.162 160.2,170.95 ; JDOCK1.162 159.15,172.9 ; JDOCK1.162 161.25,172.9 ; JDOCK1.162 159.15,170.95 ; JDOCK1.162 161.25,170.95 ; JHDMI1.11 11.39,95.76 ; JHDMI1.11 11.39,94.84 ; JHDMI1.11 10.47,94.84 ; JHDMI1.11 10.47,95.76 ; JHDMI1.11 11.51,95.3 ; JHDMI1.11 10.34,95.3 ; 147.4,167.2 JDOCK1.157 ; JDOCK1.157 148.2,169.05 ; JDOCK1.157 149,167.2 ; JDOCK1.157 147.4,168.8 ; JDOCK1.157 149.25,168 ; JDOCK1.157 148.2,166.95 ; JDOCK1.157 149,168.8 ; JDOCK1.157 147.15,168 ; JDOCK1.155 173.25,164.08 ; JDOCK1.155 171.15,164.08 ; JDOCK1.155 171.15,163.1 ; JDOCK1.155 173.25,163.1 ; JDOCK1.155 172.2,163.1 ; JDOCK1.155 172.2,165.05 ; JDOCK1.155 173.25,165.05 ; JDOCK1.155 171.15,165.05 ; JDOCK1.156 190.76,165.05 ; JDOCK1.156 190.76,163.1 ; JDOCK1.156 188.7,163.1 ; JDOCK1.156 190.76,164.08 ; JDOCK1.156 186.64,164.08 ; JDOCK1.156 188.7,165.05 ; JDOCK1.156 186.64,165.05 ; JDOCK1.156 186.64,163.1 ; 84.28,170.99 PBATT2.11 ; PBATT2.11 84.28,173 ; PBATT2.11 86.39,170.99 ; PBATT2.11 86.39,173 ; PBATT2.11 85.34,170.99 ; 14.7,72.89 JUSB1.4 ; JUSB1.4 14.7,71.82 ; JUSB1.4 14.55,72.35 ; JUSB1.4 15.24,71.67 ; JUSB1.4 15.77,72.89 ; JUSB1.4 15.24,73.04 ; JUSB1.4 15.92,72.35 ; JUSB1.4 15.77,71.82 ; JDOCK1.145 143.08,168 ; JDOCK1.145 142.03,169.98 ; JDOCK1.145 140.97,169.98 ; JDOCK1.145 140.97,166.02 ; JDOCK1.145 140.97,168 ; JDOCK1.145 143.08,166.02 ; JDOCK1.145 143.08,169.98 ; JDOCK1.145 142.03,166.02 ; 196,46.59 JSATA2.15 ; JSATA2.15 198.8,45.04 ; JSATA2.15 197.4,46.59 ; JSATA2.15 196,45.04 ; JSATA2.15 198.8,45.82 ; JSATA2.15 197.4,45.04 ; JSATA2.15 196,45.82 ; JSATA2.15 198.8,46.59 ; H3.1 107.74,73.87 ; H3.1 107.74,77.61 ; H3.1 104,77.61 ; H3.1 104,73.87 ; H3.1 103.29,75.74 ; H3.1 105.87,78.32 ; H3.1 105.87,73.16 ; H3.1 108.45,75.74 ; 12.86,83.13 JUSB1.11 ; JUSB1.11 14.64,84.88 ; JUSB1.11 11.08,83.13 ; JUSB1.11 14.64,84 ; JUSB1.11 12.86,84.88 ; JUSB1.11 14.64,83.13 ; JUSB1.11 11.08,84 ; JUSB1.11 11.08,84.88 ; 6.77,2.47 H8.1 ; H8.1 8.9,1.67 ; H8.1 11.83,4.6 ; H8.1 8.9,7.53 ; H8.1 11.03,2.47 ; H8.1 5.97,4.6 ; H8.1 11.03,6.73 ; H8.1 6.77,6.73 ; JDOCK1.153 145.76,163.1 ; JDOCK1.153 141.64,164.08 ; JDOCK1.153 143.7,165.05 ; JDOCK1.153 145.76,165.05 ; JDOCK1.153 143.7,163.1 ; JDOCK1.153 145.76,164.08 ; JDOCK1.153 141.64,163.1 ; JDOCK1.153 141.64,165.05 ; 92.37,12.3 H13.1 ; H13.1 94.2,10.47 ; H13.1 92.86,10.96 ; H13.1 95.54,13.64 ; H13.1 92.86,13.64 ; H13.1 95.54,10.96 ; H13.1 96.03,12.3 ; H13.1 94.2,14.13 ; 45.3,54.61 H19.1 ; H19.1 43.21,56.7 ; H19.1 45.3,58.78 ; H19.1 46.82,55.17 ; H19.1 46.82,58.22 ; H19.1 47.38,56.7 ; H19.1 43.77,55.17 ; H19.1 43.77,58.22 ; H2.1 105.87,12.47 ; H2.1 105.87,7.01 ; H2.1 103.88,7.76 ; H2.1 107.85,11.72 ; H2.1 103.13,9.74 ; H2.1 107.85,7.76 ; H2.1 103.88,11.72 ; H2.1 108.6,9.74 ; 8.94,14.89 H18.1 ; H18.1 6.86,16.97 ; H18.1 8.94,19.05 ; H18.1 7.42,18.49 ; H18.1 10.47,18.49 ; H18.1 7.42,15.44 ; H18.1 10.47,15.44 ; H18.1 11.02,16.97 ; JHDMI1.22 10.76,103.02 ; JHDMI1.22 9.48,103.02 ; JHDMI1.22 8.2,104.88 ; JHDMI1.22 8.2,103.95 ; JHDMI1.22 8.2,103.02 ; JHDMI1.22 9.48,104.88 ; JHDMI1.22 10.76,103.95 ; JHDMI1.22 10.76,104.88 ; 123.88,11.72 H4.1 ; H4.1 123.88,7.76 ; H4.1 125.87,7.01 ; H4.1 125.87,12.47 ; H4.1 127.85,7.76 ; H4.1 127.85,11.72 ; H4.1 128.6,9.74 ; H4.1 123.13,9.74 ; JUSB1.7 14.27,76.39 ; JUSB1.7 14.27,75.32 ; JUSB1.7 14.42,75.85 ; JUSB1.7 13.74,75.17 ; JUSB1.7 13.74,76.54 ; 85.33,103.2 JSATA1.23 ; JSATA1.23 87.05,104.92 ; JSATA1.23 85.79,104.46 ; JSATA1.23 88.31,104.46 ; JSATA1.23 88.76,103.2 ; JSATA1.23 85.79,101.94 ; JSATA1.23 88.31,101.94 ; JSATA1.23 87.05,101.49 ; H1.1 127.85,77.72 ; H1.1 125.87,78.47 ; H1.1 123.13,75.74 ; H1.1 123.88,77.72 ; H1.1 128.6,75.74 ; H1.1 123.88,73.76 ; H1.1 125.87,73.01 ; H1.1 127.85,73.76 ; JDOCK1.158 161.25,168 ; JDOCK1.158 160.2,169.05 ; JDOCK1.158 159.4,167.2 ; JDOCK1.158 161,168.8 ; JDOCK1.158 160.2,166.95 ; JDOCK1.158 161,167.2 ; JDOCK1.158 159.4,168.8 ; JDOCK1.158 159.15,168 ; 205.67,171.5 H14.1 ; H14.1 208.84,170.16 ; H14.1 206.16,170.16 ; H14.1 209.33,171.5 ; H14.1 207.5,169.67 ; H14.1 206.16,172.84 ; H14.1 208.84,172.84 ; 3.15,103.02 JHDMI1.23 ; JHDMI1.23 3.15,103.95 ; JHDMI1.23 5.71,104.88 ; JHDMI1.23 3.15,104.88 ; JHDMI1.23 4.43,103.02 ; JHDMI1.23 5.71,103.95 ; JHDMI1.23 5.71,103.02 ; JHDMI1.23 4.43,104.88 ; 85.79,144.46 JSATA1.24 ; JSATA1.24 88.31,141.94 ; JSATA1.24 85.33,143.2 ; JSATA1.24 87.05,144.92 ; JSATA1.24 88.76,143.2 ; JSATA1.24 85.79,141.94 ; JSATA1.24 88.31,144.46 ; JSATA1.24 87.05,141.49 ; H5.1 197.23,16.5 ; H5.1 196.74,17.84 ; H5.1 194.06,15.16 ; H5.1 196.74,15.16 ; H5.1 193.57,16.5 ; H5.1 195.4,14.67 ; H5.1 194.06,17.84 ; H5.1 195.4,18.33 ; 159.15,163.1 JDOCK1.154 ; JDOCK1.154 160.2,163.1 ; JDOCK1.154 159.15,165.05 ; JDOCK1.154 159.15,164.08 ; JDOCK1.154 161.25,165.05 ; JDOCK1.154 161.25,163.1 ; JDOCK1.154 161.25,164.08 ; JDOCK1.154 160.2,165.05 ; 189.32,169.98 JDOCK1.152 ; JDOCK1.152 189.32,166.02 ; JDOCK1.152 190.38,166.02 ; JDOCK1.152 191.43,169.98 ; JDOCK1.152 190.38,169.98 ; JDOCK1.152 191.43,168 ; JDOCK1.152 191.43,166.02 ; JDOCK1.152 189.32,168 ; 12.01,90.34 JHDMI1.2 ; JHDMI1.2 13.06,90.8 ; JHDMI1.2 12.94,90.34 ; JHDMI1.2 11.89,90.8 ; JHDMI1.2 12.48,90.22 ; JHDMI1.2 12.94,91.26 ; JHDMI1.2 12.01,91.26 ; 107.59,170.99 PBATT2.10 ; PBATT2.10 108.64,173 ; PBATT2.10 106.53,170.99 ; PBATT2.10 106.53,173 ; PBATT2.10 108.64,170.99 ; JUSB1.13 7.13,84.88 ; JUSB1.13 5.76,83.13 ; JUSB1.13 4.39,83.13 ; JUSB1.13 5.76,84.88 ; JUSB1.13 4.39,84 ; JUSB1.13 7.13,83.13 ; JUSB1.13 7.13,84
  BOTTOM w0.102: 129.62,59.07 129.93,59.38 130.74,59.38 131.43,60.06 132.72,60.06 v2(133.06,60.4) ; 130.08,58.67 131.86,58.67 131.98,58.78 133.07,58.78 133.33,59.05 RC237.2 ; v2(103.49,51.85) 103.91,52.27 105.12,52.27 105.56,51.82 107.15,51.82
  BOTTOM w0.127: v2(285.2,169.28) v5(285.91,169.28) ; C5.2 29.36,18.67 v5(29.56,18.88) ; RV90.1 58.32,100.22 57.97,100.22 v5(57.67,100.52) ; 126.84,42.85 126.87,42.83 127.34,42.83 127.71,42.47 UC1.AV41 ; v2(274.36,171.44) 275.57,171.44 v5(276.06,171.92) ; UC1.AV39 127.71,44.04 127.34,44.41 126.79,44.41 ; v2(25.56,88.45) v5(25.56,89.18) ; UC1.AV43 127.71,40.89 127.34,41.26 127.07,41.26 126.82,41.5 ; v2(5.31,28.06) v5(4.66,28.06) ; v2(39.98,11.99) v5(40.74,11.99) ; 126.82,38.27 126.98,38.11 127.34,38.11 127.52,37.93 127.68,37.93 UC1.AV49 ; UC1.AV36 127.71,45.62 127.34,45.98 126.94,45.98 126.82,46.1 ; v2(28.23,101.15) 28.35,101.15 v5(28.73,100.77) ; v2(39.34,99.37) 39.34,99.73 v5(39.62,100.02) ; v2(72.77,103.28) v5(72.77,102.62) ; v2(80.43,101.78) v5(81.54,101.78) ; R163.2 v5(265.53,162.18) ; v2(4.93,22.53) v5(4.11,22.53) ; C396.2 v5(82.93,13.71)
  BOTTOM w0.178: v2(128.01,33.77) 127.91,33.67 UC1.AV55 UC1.AU55 ; v2(126.25,46.96) 126.43,46.78 UC1.AT35 126.76,46.35 126.82,46.28 126.82,45.64 126.76,45.57 UC1.AT37 126.76,44.44 126.82,44.37 126.82,44 126.76,43.94 UC1.AT40 126.76,42.94 126.84,42.85 126.84,42.14 UC1.AT42 126.76,41.98 126.82,41.91 126.82,40.55 UC1.AT43 ; v2(126.25,46.96) 126.05,47.16 UC1.AR33 ; v2(126.25,46.96) 126.87,47.57 UC1.AU33 ; UC1.AJ63 122.49,28.22 122.82,27.89 v2(122.82,27.67) ; v2(128.05,55.5) 128.01,55.46 UC1.AV20 UC1.AU20 ; UC1.AN60 124.51,30.86 124.49,30.88 124.21,30.88 124.19,30.86 UC1.AL60 ; UC1.AL33 123.45,47.31 v2(123.71,47.05) ; v2(119.58,28.03) 119.71,28.17 UC1.AD63 ; v2(125.08,42.69) 124.75,42.37 UC1.AN42 124.75,42.05 v2(125.03,41.78) 124.75,41.5 UC1.AN43 UC1.AN45 ; UC1.AT61 126.17,29.46 UC1.AT62 126.24,29.39 126.24,28.9 126.27,28.87 126.27,28.7 UC1.AT63 126.38,28.33 127.16,27.56 v2(127.26,27.56) ; UC1.AV49 127.9,37.71 127.9,37.61 128.16,37.34 v2(128.16,37.33) 128.18,37.33 128.36,37.15 128.36,37.07 UC1.AW50 ; UC1.AV34 128.19,47.52 UC1.AW33 ; UC1.AV34 127.86,47.09 128.16,46.79 v2(128.16,46.78) 128.18,46.78 128.51,46.44 UC1.AW35 ; UC1.AV34 127.54,47.52 UC1.AV33 ; UC1.AY18 129.69,56.68 v2(129.76,56.61) ; 123.45,53.6 v2(123.78,53.27) 124.1,53.6 UC1.AM23 ; 123.45,53.6 v2(123.13,53.27) 122.8,53.6 ; 123.45,53.6 UC1.AL23 ; UC1.AW44 128.51,40.14 128.18,40.48 v2(128.16,40.48) 128.16,40.49 127.86,40.79 UC1.AV43 ; UC1.AY22 129.72,54.25 v2(129.78,54.31) ; UC1.Y59 117.39,31.19 v2(117.09,30.89) ; 122.8,53.6 UC1.AK23 ; 122.8,53.6 v2(122.48,53.27) 121.85,53.27 UC1.AH24 121.82,53.83 UC1.AJ23 122.26,54.27 v2(122.26,54.67) 121.74,54.67 UC1.AH22 ; UC1.AN31 UC1.AP31 UC1.AR31 125.99,48.95 126.15,49.11 UC1.AU30 ; UC1.AN31 124.75,48.63 UC1.AN32 ; UC1.AN31 UC1.AM31 ; v2(128.05,50.36) 128.01,50.33 UC1.AV28 UC1.AU28 ; UC1.AY30 129.64,49.11 v2(129.8,48.95) ; 121.84,31.03 v2(121.83,31.03) ; 121.84,31.03 121.82,31.05 121.33,31.05 UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 121.14,27.96 v2(121.22,27.88) ; 121.84,31.03 121.84,31.03 122.15,31.34 UC1.AJ58 122.13,31.84 121.82,32.14 UC1.AH57 121.82,32.81 122.15,33.14 UC1.AJ56 ; 121.84,31.03 121.84,31.08 122.06,30.86 UC1.AJ60 122.9,30.86 122.92,30.88 123.2,30.88 123.22,30.86 UC1.AL60 ; UC1.AW40 128.51,43.29 128.18,43.63 v2(128.16,43.63) 128.16,43.64 127.86,43.94 UC1.AV39 ; v2(123.75,35.04) 123.44,35.34 123.44,35.62 UC1.AL52 ; UC1.AU33 126.89,47.81 UC1.AV33 ; UC1.AU33 126.87,48.58 126.89,48.6 UC1.AU30 ; v2(124.97,35.09) 124.99,35.09 125.4,35.51 UC1.AP52 125.53,35.63 125.54,35.62 125.91,35.62 125.92,35.63 UC1.AR52 ; UC1.AU55 126.89,33.18 126.87,33.16 126.87,32.88 126.89,32.86 UC1.AU57 126.89,31.94 126.87,31.92 126.87,31.63 126.89,31.62 UC1.AU59 UC1.AV59 UC1.AW59 ; UC1.AU55 126.89,34.15 126.87,34.17 126.87,34.46 126.89,34.47 UC1.AU53 126.89,35.4 126.87,35.42 126.87,35.7 126.89,35.72 UC1.AU51 ; UC1.AU51 UC1.AV51 UC1.AW51 UC1.AY51 129.45,36.23 129.54,36.13 v2(130.45,36.13) ; UC1.AU51 126.89,36.48 126.77,36.6 126.77,37.29 UC1.AT49 126.78,37.74 126.82,37.78 126.82,38.84 UC1.AT46 ; UC1.AU30 126.89,49.52 126.87,49.54 126.87,49.83 126.89,49.84 UC1.AU28 ; v2(130,51.35) 129.98,51.35 129.79,51.55 UC1.AY26 ; v2(123.74,29.7) 123.7,29.74 UC1.AL61 UC1.AL60 ; UC1.AB7 118.29,63.28 v2(118.11,63.46) ; UC1.AV33 127.59,47.76 UC1.AW33 ; UC1.AY33 UC1.AW33 ; UC1.AR23 126.15,53.58 126.68,53.58 126.87,53.78 126.89,53.8 UC1.AU22 126.89,54.66 126.87,54.67 126.87,54.96 126.89,54.98 UC1.AU20 ; UC1.AY16 128.8,57.99 UC1.AW16 UC1.AV16 UC1.AU16 126.89,57.51 126.87,57.5 126.87,57.21 126.89,57.19 UC1.AU18 126.89,56.27 126.87,56.25 126.87,55.97 126.89,55.95 UC1.AU20 ; v2(114.08,30.9) 114.37,31.19 UC1.P59 ; UC1.AN49 125.01,37.72 125.01,38.1 UC1.AN48 124.76,38.37 124.76,38.59 v2(124.48,38.92) ; UC1.AW42 128.51,41.72 128.18,42.06 v2(128.16,42.06) 128.16,42.07 127.86,42.37 UC1.AV41 ; UC1.A28 105.44,50.68 v2(105.23,50.47) ; UC1.AU28 126.89,50.82 126.87,50.83 126.87,51.12 126.89,51.14 UC1.AU26 126.89,52.06 126.87,52.08 126.87,52.36 126.89,52.38 UC1.AU24 UC1.AV24 UC1.AW24 UC1.AY24 129.7,52.9 v2(129.77,52.82) ; UC1.AJ52 122.69,35.74 UC1.AK52 122.8,35.27 v2(122.97,35.11) ; UC1.AP23 125.4,53.6 125.06,53.25 v2(124.51,53.25) 124.51,53.44 UC1.AN23 ; v2(125.19,27.48) 125.19,27.83 124.92,28.1 UC1.AN63 ; UC1.Y63 117.46,27.96 v2(117.63,27.79) ; v2(129.77,32.38) 129.7,32.45 UC1.AY57 ; UC1.AY53 129.47,34.88 129.51,34.84 129.89,34.84 v2(130.07,34.66) ; v2(108.84,62.32) 108.32,62.84 UC1.D8 ; UC1.AR17 UC1.AP17 UC1.AN17 UC1.AM17 UC1.AL17
  BOTTOM w0.2: UV1.B20 57.13,94.47 57.13,95.64 v4(57.02,95.75) ; UV1.B14 61.89,94.43 61.89,94.99 v4(61.91,94.99) ; v4(54.27,95.77) 54.4,95.64 54.4,94.47 UV1.B23 ; UV1.AF5 69.52,74.45 69.52,73.3 v4(69.57,73.25) ; v4(66.93,73.18) UV1.AF8 ; UV1.Y26 52.01,79.55 51.32,79.55 v4(50.82,79.05) ; v4(72.81,76.99) 71.88,76.99 UV1.AC2 ; UV1.P26 v4(51.09,84.45)
  BOTTOM w0.203: v2(118.59,29.59) 118.89,29.89 UC1.AC61 ; v2(126.06,30.68) 125.8,30.94 125,30.94 UC1.AN60 ; v2(126.06,30.68) 126.17,30.57 UC1.AT61 ; v2(126.06,30.68) 126.29,30.92 126.59,30.92 UC1.AU59 ; v2(123.8,42.66) 123.45,43.01 UC1.AL40 ; v2(112.42,67.76) 112.26,67.6 UC1.K1 ; v2(130.01,58.07) 128.88,58.07 UC1.AY16 ; v2(129.7,31.01) 129.59,31.13 UC1.AY59 ; UC1.AN49 124.75,37.31 124.86,37.2 124.86,36.83 124.75,36.72 UC1.AN51 124.75,36.38 124.88,36.25 124.88,35.87 124.75,35.74 UC1.AN52 ; UC1.AP54 125.4,34.54 v2(125.73,34.21) ; UC1.AH20 122.01,55.57 v2(122.2,55.38) 122.09,55.26 UC1.AG21 ; UC1.B56 UC1.A56 ; UC1.AV8 127.45,61.97 v2(127.44,61.97) ; UC1.P59 115.15,31.84 UC1.T58 ; UC1.AU16 126.89,58.37 v2(126.56,58.7) ; UC1.AW59 128.51,30.89 UC1.AW60 ; UC1.AJ27 122.19,51.3 123.1,51.3 123.45,51.65 UC1.AL26 ; 126.68,53.58 126.89,53.38 UC1.AU24 ; v2(130.09,60.75) 130,60.84 UC1.AY11 ; PU300.22 48.02,18.94 v2(47.92,19.04) ; UC1.AM1 v2(124.25,67.7) ; v2(109.47,55.61) 109.47,55.5 UC1.D21 ; v2(124.38,35.08) 124.38,35.27 124.74,35.63 UC1.AN52 ; UC1.U22 v2(115.99,55.15) ; v2(108.29,28.08) 108.51,28.3 UC1.D63 108.57,28.64 UC1.D62 ; UC1.D5 108.38,65.01 108.21,65.18 108.21,65.52 ; UC1.AN52 124.97,35.42 v2(124.97,35.09) ; UC1.AN7 124.61,63.5 124.31,63.8 v2(124.31,63.9) ; UC1.AP29 125.43,49.85 125.73,49.56 UC1.AR31 ; 108.21,65.52 107.42,65.52 UC1.B4 ; 108.21,65.52 v2(108.21,66.24) 108.54,66.56 UC1.D2 ; UC1.AR17 125.86,57.99 v2(126.56,58.7) ; PU150.14 153.11,81.93 v2(152.95,82.1) 152.71,81.86 PU150.13 ; PU300.19 47.89,17.74 v2(47.79,17.64) ; v2(126.12,66.21) 125.95,66.21 125.71,65.98 UC1.AP3 ; UC1.AR39 125.73,44.07 v2(125.65,44.15) 125.65,44.31 125.4,44.55 UC1.AP38 ; UC1.AL29 123.13,49.53 UC1.AL31 ; UC1.AP39 125.08,43.41 UC1.AN40 ; v2(120,64.18) 120.4,64.58 UC1.AE5 ; PU150.10 151.51,81.93 v2(151.68,82.1) 151.91,81.86 PU150.11 ; UC1.G8 110.45,62.94 v2(110.13,63.26) 110.45,63.59 UC1.G6 ; v2(123.75,35.04) 123.75,35.28 UC1.AM52 ; UC1.AL45 123.72,40.07 v2(123.72,39.87) 123.72,39.68 UC1.AL46 ; UC1.U61 115.89,29.89 v2(115.59,29.59) ; v2(126.56,58.7) 126.24,59.02 UC1.AR15 ; UC1.V3 116.86,65.91 v2(117.16,66.21) ; UC1.N21 114.06,55.53 114.19,55.39 114.19,55.39 114.46,55.12 114.46,54.7 UC1.P22 v2(114.37,53.73) ; UC1.AN40 124.43,43.41 UC1.AN39 ; UC1.AN40 124.75,43.02 v2(125.08,42.69) ; v2(125.73,32.31) 125.4,32.63 UC1.AP57 ; v2(121.7,57.08) 121.7,57.19 UC1.AH17 122.22,57.71 122.22,58.1 UC1.AH16 ; UC1.W22 116.81,54.51 UC1.V23 116.03,53.73 v2(115.99,53.73) ; UC1.AV36 127.86,45.61 v2(128.25,45.22) 128.51,44.96 UC1.AW37 ; UC1.AL54 123.45,34.54 v2(123.78,34.21) ; UC1.W20 116.81,56.04 v2(116.81,56.56) ; UC1.AT49 126.21,37.3 UC1.AR49 126.05,37.54 v2(125.7,37.89) 125.4,38.19 UC1.AP48 UC1.AN48 ; UC1.AR23 126.05,53.79 v2(125.73,54.12) ; v2(112.38,63.81) 112.87,63.31 UC1.L7 ; UV6.G8 36.82,78.41 36.82,79.11 UV7.G1 ; v2(152.53,75.76) 152.71,75.94 PU150.25 ; UC1.AL51 123.45,36.39 123.7,36.14 123.7,36.04 v2(123.71,36.04) ; UC1.AV46 127.86,39.21 v2(128.16,38.91) 128.51,38.56 UC1.AW47 ; UC1.AD3 119.83,65.91 v2(120.13,66.21) ; v2(129.77,63.97) 129.63,63.84 UC1.AY6 ; v2(125.08,46.11) 124.75,45.78 UC1.AN36 ; UC1.N3 113.83,65.91 v2(114.13,66.21) ; PU300.29 v2(51.04,21.52) ; 121.89,50.63 122.15,50.37 UC1.AJ29 v2(121.59,50.04) ; UC1.D59 108.75,31.31 109.27,31.84 UC1.F58 ; v2(77.11,86.29) 77.25,86.15 U19.11 ; v2(109.6,29.59) 109.89,29.89 UC1.F61 ; U45.15 U45.11 ; v2(124.48,38.92) 124.75,39.19 UC1.AN46 124.75,39.61 124.83,39.68 124.83,40.06 124.75,40.14 UC1.AN45 ; v2(126.21,60.11) 126.21,60.27 126.24,60.29 UC1.AR11 ; PU150.19 v2(152.31,78.92) ; v2(123.12,66.21) 123,66.21 122.71,65.93 UC1.AK3 ; UC1.L61 112.89,29.89 v2(112.59,29.59) ; PU150.12 v2(152.31,82.1) ; PU150.23 154.48,77.32 154.6,77.21 154.6,76.76 v2(154.41,76.57) ; UC1.AT43 126.72,40.48 v2(126.38,40.83) 126.05,41.15 UC1.AR43 ; UC1.R22 v2(115.18,53.73) ; PU150.24 153.11,76.34 153.33,76.13 153.53,76.13 v2(153.54,76.12) ; UC1.AV14 127.61,59.12 127.61,58.98 v2(127.6,58.98) ; UC1.AU1 127.19,67.68 127.29,67.78 127.29,68.27 v2(127.41,68.39) ; v2(123.78,32.31) 123.45,32.63 UC1.AL57 ; v2(123.77,45.23) 123.45,45.55 UC1.AL36 ; UC1.A24 106.1,53.19 v2(105.75,53.54) ; UC1.P63 UC1.P62 ; v2(129.77,65.49) 129.56,65.29 UC1.AY4 129.12,65.24 UC1.AW4 ; UV4.G8 UV5.G1 ; UC1.AG1 v2(121.25,67.75) ; UC1.R8 UC1.R10 ; UC1.AL31 122.72,48.95 122.65,48.89 v2(122.65,48.89) ; UC1.AL31 UC1.AM31 ; v2(115.26,67.75) UC1.T1
  BOTTOM w0.229: UC1.M22 v2(113.55,53.73) ; v2(112.1,53.47) 111.93,53.64 UC1.J22
  BOTTOM w0.25: v4(50.51,81.99) 50.53,81.97 UV1.U26 ; v4(69.42,95.3) UV1.B5 ; v4(52.07,73.18) UV1.AG26 ; UV1.B11 64.59,94.49 v2(64.59,94.99)
  BOTTOM w0.254: UC1.AF15 120.23,58.13 v2(120.23,57.95) 120.28,57.9 UC1.AF17 UC1.AF18 ; v2(116.18,60.78) 116.67,60.78 UC1.Y10 ; UC1.AH46 122.31,38.99 v2(122.38,38.92) ; JIO1.19 v2(305.29,162.9) ; JDOCK1.55 161.95,165.05 v2(162.24,165.33) 162.45,165.12 JDOCK1.57 ; v2(123.78,54.12) 123.78,54.16 123.45,54.49 UC1.AL22 ; UV1.AE11 64.41,75.35 UV1.AD12 ; JDOCK1.125 180.45,165.15 v2(180.14,165.46) 179.95,165.27 JDOCK1.123 ; UV4.A9 v2(41.26,95.31) UV5.B1 ; UC1.AP22 125.4,54.49 125.73,54.17 v2(125.73,54.12) ; v2(39.67,72.36) UV6.D1 ; UC1.G3 110.72,65.98 111.02,66.28 v2(111.13,66.28) ; v2(122.38,38.92) 122.38,38.57 UC1.AJ47 122.15,38.15 122.38,37.92 v2(122.38,37.8) ; v2(122.38,38.92) 122.38,39.41 UC1.AJ45 121.82,39.96 UC1.AH44 121.82,40.61 UC1.AJ43 122.39,41.18 v2(122.39,41.71) ; JIO1.34 311.8,159.4 v2(312.01,159.19) ; 113.07,58.52 112.68,58.12 UC1.L17 ; 113.07,58.52 112.69,58.9 UC1.L15 ; 113.07,58.52 v2(113.07,58.47) ; UV7.M9 32.87,72.78 v2(32.5,73.15) ; v2(312.2,154.75) 311.89,154.75 311.73,154.9 JIO1.52 ; JIO1.25 v2(305.29,161.4) ; v2(121.59,43.54) 121.59,43.96 UC1.AH38 122.33,44.19 v2(122.4,44.12) 122.4,44 122.72,43.67 UC1.AL39 123.13,43.41 UC1.AL40 ; v2(121.59,43.54) 121.59,43.12 UC1.AH40 121.96,42.75 v2(122.38,42.75) 122.38,42.47 UC1.AJ41 122.39,42 v2(122.39,41.71) ; v2(121.59,43.54) UC1.AJ39 ; UC1.AH42 122.27,41.59 v2(122.39,41.71) ; v2(27.66,27.62) 27.72,27.68 28.78,27.68 JTAA1.18 ; UC1.AF14 120.03,59.53 v2(119.93,59.43) ; v2(179.38,162.54) 178.95,162.97 JDOCK1.119 ; UC1.C11 107.94,60.86 UC1.D12 ; v2(36.47,88.17) 36.52,88.17 UV5.G9 ; UC1.AL17 123.12,58.42 v2(123.38,58.68) 123.11,58.68 UC1.AJ14 122.8,59.12 UC1.AL13 123.12,59.83 v2(123.12,60.09) 122.81,60.09 UC1.AJ13 ; UC1.A18 106.65,56.72 107.72,56.72 UC1.C18 107.91,56.71 UC1.D18 108.42,57.11 v2(108.83,57.52) 108.83,57.62 UC1.E17 ; UC1.AT13 126.53,59.67 126.53,59.74 126.21,60.06 v2(126.21,60.11) ; v2(27.66,28.25) 27.72,28.19 28.78,28.19 JTAA1.20 ; UC1.J63 111.41,28.59 v2(111.1,28.9) ; UC1.AJ52 122.15,36.06 UC1.AH51 122.15,36.71 UC1.AJ50 122.15,37.05 122.38,37.28 v2(122.38,37.8) ; UC1.D42 UC1.F42 110.24,41.91 v2(110.24,41.9) ; UV1.AB17 59.48,77.79 v4(59.08,78.19) ; v2(121.59,46.14) 120.94,46.79 120.94,47.87 121.16,48.09 UC1.AH32 ; v2(121.59,46.14) 121.59,46.56 UC1.AH34 122.25,46.79 v2(122.41,46.95) ; v2(121.59,46.14) UC1.AJ35 ; v2(121.59,46.14) 121.59,45.73 UC1.AH36 ; UV1.Y2 71.95,79.49 v4(72.33,79.11) ; U17.42 v2(250.99,152.46) ; UC1.AB22 118.65,54.61 119.07,55.03 119.12,55.03 v2(119.24,55.15) 119.62,55.53 UC1.AD21 ; v2(168.44,162.67) 168.45,162.68 JDOCK1.81 ; v2(121.31,53.56) 121.31,54.06 UC1.AG23 ; v2(110.24,44.41) 110.24,44.41 UC1.F38 UC1.D38 ; UV4.D8 39.25,94.1 v2(38.86,93.71) UV5.E2 ; UC1.AP20 125.4,56.38 125.56,56.22 125.56,56.21 125.73,56.05 v2(125.73,56.02) ; UV1.AE20 57.05,75.35 v2(57.45,75.75) UV1.AD19 v2(58.25,75.75) UV1.AD18 v2(59.05,75.75) 59.45,75.35 UV1.AE17 59.53,75.35 UV1.AD16 ; UV7.E2 v2(38.87,77.96) 39.26,78.35 UV6.D8 ; UV5.P1 31.21,94.91 v2(30.87,95.25) 30.8,95.33 29.84,95.33 29.66,95.15 UV5.T1 ; UV1.AD13 62.73,76.15 v2(62.39,75.81) 61.97,75.39 UV1.AE14 ; JDOCK1.138 183.45,171.16 184.01,170.6 v2(184.07,170.6) ; v2(157.95,170.57) JDOCK1.44 ; v2(255.68,157.21) U17.7 ; v2(123.64,61.96) 123.5,61.82 123.52,61.8 123.52,61.76 UC1.AL10 ; JDOCK1.91 170.95,162.97 171.32,162.6 v2(171.89,162.6) 171.45,163.04 JDOCK1.93 ; UC1.AB10 119.02,61.3 v2(119.02,60.71) ; PU301.3 v2(69.7,25.68) ; v2(110.24,49.43) 110.24,49.43 UC1.F30 UC1.D30 ; UC1.AJ27 122.15,51.02 UC1.AH28 121.89,50.63 ; v2(122.38,37.8) 121.94,37.8 UC1.AH49 ; v2(109.47,55.61) 109.47,55.71 UC1.F20 ; UV5.J2 35.26,94.12 v2(35.66,94.52) ; JDOCK1.38 156.45,170.92 156.52,170.85 156.52,170.29 v2(156.27,170.03) ; UV1.AC8 v2(67.33,77.35) UV1.AB7 ; JDOCK1.137 183.45,165.32 v2(183.46,165.33) ; v2(41.27,72.36) UV7.B9 ; v2(104.18,62.03) 104.51,62.03 105.69,60.85 UC1.A11 ; JIO1.46 311.89,156.4 v2(312.01,156.52) ; v2(112.66,32.38) UC1.L58 ; v2(154.81,162.6) 154.95,162.74 JDOCK1.31 ; v2(41.08,90.59) 40.86,90.37 UV4.B3 ; v2(35.62,73.15) 35.6,73.18 35.6,73.24 UV7.J8 ; UC1.G18 110.78,57.32 v2(110.78,57.52) 110.78,57.62 UC1.H17 ; UV5.E8 v2(38.86,88.91) UV4.E1 ; JDOCK1.75 166.95,165.16 v2(167.04,165.25) ; v2(32.48,88.9) 32.86,88.53 UV5.M9 ; UV1.AB14 61.97,77.84 v4(61.62,78.19) ; UV1.H2 v2(72.43,89.41) ; v2(16.74,74.73) D17.3 D17.8 ; UC1.AB20 118.43,56.26 v2(118.2,56.5) ; v2(180.26,170.67) 180.26,171 180.45,171.19 JDOCK1.126 ; UC1.J59 111.39,31.19 v2(111.09,30.89) ; UC1.L13 112.69,59.85 113.1,60.26 v2(113.1,60.41) 113.02,60.33 UC1.K12 ; JDOCK1.132 181.95,170.95 182.28,170.62 v2(182.28,170.43) ; UC1.D46 UC1.F46 110.24,39.4 v2(110.24,39.4) ; UC1.F58 110.08,31.84 v2(110.22,31.71) 110.64,32.13 UC1.H57 ; UC1.D34 UC1.F34 110.24,46.92 v2(110.24,46.92) ; UC1.AT40 125.77,43.63 UC1.AR39 UC1.AP39 UC1.AN39 ; v2(110.24,36.89) 110.24,36.89 UC1.F50 UC1.D50 ; UV7.T1 29.67,79.4 29.86,79.58 30.81,79.58 v2(30.88,79.5) 31.23,79.16 UV7.P1 ; v2(116.56,32.38) UC1.V58 ; v2(181.96,165.35) 181.95,165.33 JDOCK1.131 ; v2(148.95,170.73) JDOCK1.8 ; v2(122.97,35.11) 122.95,35.09 UC1.AH53 122.15,34.76 UC1.AJ54 122.15,34.11 UC1.AH55 122.15,33.46 UC1.AJ56 ; UC1.AP26 125.4,51.75 125.73,51.42 125.73,51.4 v2(125.73,51.4) ; JDOCK1.107 175.95,162.76 v2(175.81,162.61) ; JIO1.16 v2(312.01,163.9) ; UC1.D59 108.41,31.31 107.81,30.71 107.38,30.71 107.25,30.59 107.23,30.59 UC1.B60 ; v2(30.9,73.15) 31.27,72.78 UV7.P9 ; UC1.U20 v2(115.99,55.15) ; v2(36.48,72.42) 36.53,72.42 UV7.G9 ; UV1.K11 64.97,88.67 v4(64.63,89.01) ; v2(121.7,57.08) 121.7,57 UC1.AH19 ; JIO1.37 v2(307.82,158.4) ; UC1.AH30 121.59,49.63 v2(121.59,50.04) ; v2(111.41,61.22) 111.76,61.56 UC1.J10 ; v2(151.95,170.73) JDOCK1.20 ; v2(168.29,170.6) 168.29,170.73 168.45,170.89 JDOCK1.82 ; v2(111.4,55.62) 111.4,55.59 110.42,54.61 UC1.G22 ; UC1.AE10 120.49,61.65 120.5,61.65 120.5,61.47 UC1.AF11 121.22,60.75 UC1.AG11 ; v4(64.04,78.19) 64.44,77.79 UV1.AB11 ; v2(110.24,34.38) 110.24,34.38 UC1.F54 UC1.D54 ; JDOCK1.7 148.95,164.9 v2(148.58,165.27) ; UV6.A9 41.67,79.22 v2(41.27,79.62) 40.87,79.22 UV7.B1 ; v2(150.45,170.73) JDOCK1.14 ; JIO1.5 v2(307.82,166.4) ; JDOCK1.120 178.95,170.78 v2(179.06,170.67) ; v2(114.1,29.57) 114.43,29.24 UC1.P62 ; v2(125.59,61.95) 125.26,61.63 UC1.AP10 ; JDOCK1.94 v2(171.45,170.67) ; UV7.M1 32.87,79.16 32.47,79.56 31.75,79.56 31.71,79.52 v2(31.7,79.52) ; UC1.D12 108.75,60.48 v2(108.83,60.4) 108.83,60.48 UC1.E11 ; UC1.D12 UC1.D14 107.91,59.29 UC1.C14 107.72,59.3 106.65,59.3 UC1.A14 106.33,59.18 106.02,59.49 105.14,59.49 105.05,59.58 104.73,59.58 v2(104.12,60.19) ; UV6.B3 40.87,74.6 41.13,74.86 v2(41.13,74.86) ; JDOCK1.58 v2(162.45,170.74) ; UV5.G1 v2(37.26,95.31) UV4.F9 ; UV1.U5 69.45,81.97 v4(69.05,81.57) ; JDOCK1.70 v2(165.45,170.74) ; JDOCK1.114 v2(177.45,170.73) ; UV1.Y5 v2(69.07,79.09) ; v2(120.39,32.45) 120.47,32.38 UC1.AE58 ; UC1.U9 116.24,62.18 UC1.V10 116.34,61.4 v2(116.18,61.4) ; JIO1.24 v2(312.01,161.9) ; UV1.E5 v4(69.87,91.45) ; JDOCK1.13 150.45,165.18 v2(150.36,165.27) ; v2(170.11,170.73) 169.95,170.89 JDOCK1.88 ; v2(153.45,162.73) JDOCK1.25 ; v2(110.13,64.22) 110.45,64.54 UC1.G5 ; UV1.AA7 v2(68.17,79.05) ; v2(151.95,165.28) JDOCK1.19 ; UV5.M1 32.85,94.91 32.45,95.31 31.74,95.31 31.7,95.27 v2(31.68,95.27) ; RP11.1 116.64,75.8 116.23,76.2 RC306.1 ; v2(153.6,170.73) 153.6,170.79 153.45,170.94 JDOCK1.26 ; JDOCK1.113 177.45,162.87 v2(177.7,162.61) ; JDOCK1.1 147.45,163.25 147.44,163.24 147.44,162.47 v2(147.93,161.98) ; v2(29.44,88.04) 29.66,88.26 UV5.T9 ; v2(172.95,162.74) JDOCK1.95 ; v2(169.77,162.61) 169.95,162.79 JDOCK1.87 ; v2(35.67,78.77) 35.27,78.37 UV7.J2 ; JDOCK1.63 163.95,164.89 163.63,165.21 v2(163.63,165.33) 163.45,165.15 JDOCK1.61 ; UV7.G1 v2(37.27,79.56) UV6.F9 ; JDOCK1.32 154.95,170.89 v2(154.81,170.74) ; UC1.N10 113.86,61.7 114.74,61.7 UC1.R10 114.78,60.98 v2(114.64,60.84) ; UC1.AG11 120.92,60.34 UC1.AF12 ; UC1.AG11 121.33,60.69 v2(121.69,60.33) ; UV1.U2 71.87,81.96 71.86,81.96 v2(71.47,82.35) ; UC1.AR5 125.91,64.34 126.17,64.6 v2(126.17,64.82) ; UC1.B20 107.09,55.45 v2(107.09,55.87) 107.57,55.87 UC1.C20 ; JIO1.40 v2(309.54,157.9) ; v2(123.78,56.02) 123.78,56.07 123.45,56.39 UC1.AL20 ; UC1.AR52 126.05,35.45 126.62,34.88 UC1.AU53 ; v2(110.78,59.43) 110.78,59.5 111.11,59.82 UC1.H13 ; v2(117.87,32.38) UC1.AA58 ; JDOCK1.37 v2(156.45,162.73) ; JDOCK1.96 v2(172.95,170.6) ; UV7.T9 29.67,72.73 v2(29.3,72.35) ; UV7.E8 v2(38.87,73.16) UV6.E1 ; v2(30.88,88.9) 31.26,88.53 UV5.P9 ; JIO1.13 v2(307.89,164.4) ; UC1.L18 112.74,56.93 UC1.L20 112.69,55.98 112.69,55.18 v2(112.69,55.17) ; v2(174.3,170.67) 174.3,170.73 174.45,170.88 JDOCK1.102 ; UV1.AD21 UV1.AD22 ; JDOCK1.76 166.95,170.84 v2(166.85,170.74) ; v2(110.24,51.93) 110.24,51.94 UC1.F26 UC1.D26 ; v2(54.12,74.15) UV1.AF23 ; JDOCK1.69 v2(165.45,162.58) ; UV1.AG2 v2(72.52,73.75) ; JDOCK1.52 v2(160.95,170.74) ; UC1.A24 UC1.B24 ; JDOCK1.101 v2(174.45,162.74) ; v2(107.35,18.47) 107.35,18.22 107.71,17.85 UC6.7 ; JDOCK1.43 v2(157.95,165.27) ; UC1.A28 UC1.B28 ; JDOCK1.47 v2(158.95,165.27) ; v2(116.21,63.46) 116.51,63.46 UC1.V7 ; JIO1.31 v2(305.29,159.9) ; v2(118.21,67.75) 118.25,67.71 UC1.AA1 ; UC1.AN35 124.75,46.43 v2(125.08,46.11) ; JDOCK1.108 v2(175.95,170.73) ; v2(56.74,38.57) PU600.22 ; v2(121.59,52.64) UC1.AJ25 ; JDOCK1.64 v2(163.95,170.74) ; v2(41.26,88.11) UV5.B9 ; v2(39.66,88.11) UV4.D1
  BOTTOM w0.3: UV1.AE17 UV1.AF17 v4(59.49,73.13) ; v4(57.01,73.18) UV1.AF20 UV1.AE20 57,75.35 56.2,76.15 UV1.AD21 ; v4(64.45,73.02) UV1.AF11 UV1.AE11 ; UV1.AC22 55.31,76.95 v4(54.97,76.61) 55.37,76.21 UV1.AD22 ; UV1.AD16 UV1.AD15 61.16,76.15 v4(61.56,75.75) ; v4(69.82,76.6) 69.42,77 UV1.AC5 ; UV1.AD12 UV1.AD13
  BOTTOM w0.305: UV1.P2 v2(72.49,84.45) ; UV1.V13 62.93,80.45 v4(62.54,80.06) ; UV1.R18 57.99,83.45 v2(58.52,82.92) 58.97,82.47 UV1.T17 ; UV1.A26 52.07,95.2 v4(51.67,95.6) ; v4(59.72,95.31) 59.41,95 59.41,94.43 UV1.B17 ; UV1.AB20 57.01,77.79 v4(56.61,78.19) ; v4(66.51,91.53) UV1.E8 ; UV1.R16 60,83.45 v4(60.48,83.93) 60.97,84.42 UV1.P15 ; v4(57.38,87.11) 57.5,87.11 57.84,87.45 UV1.L18 58.03,87.45 v2(58.46,87.88) 58.97,88.39 UV1.K17 ; v4(62.39,91.55) 62.37,91.55 UV1.E14 ; v2(66.52,82.03) 65.97,81.48 UV1.U10 ; UV1.U16 59.97,81.46 v4(60.45,81.94) 60.96,82.45 UV1.T15 ; UV1.K15 60.97,88.42 v4(60.43,87.88) 60,87.45 UV1.L16 59.97,87.42 v2(59.47,86.92) 59,86.45 UV1.M17 ; v4(54.87,79.91) 54.87,79.89 UV1.Y23 ; 65.47,84.95 UV1.N10 66.59,85.45 v4(66.77,85.63) ; 65.47,84.95 UV1.P11 ; 65.47,84.95 v4(65.51,84.95) ; v2(59.89,92.33) 59.51,91.95 UV1.E17 ; v4(53.28,77.45) 53.28,77.46 UV1.AB24 ; UV1.U12 63.97,81.43 v4(64.43,80.97) 64.95,80.45 UV1.V11 ; v4(52.47,89.83) 52.47,89.81 UV1.H25 ; UV1.R12 63.9,83.45 v4(63.48,83.03) 63.48,82.96 UV1.T13 62.94,82.45 v2(62.39,81.91) 61.97,81.48 UV1.U14 ; UV1.N18 57.87,85.45 v4(57.38,84.95) ; v4(51.66,76.6) 51.67,76.6 UV1.AC26 ; v4(72.27,95.55) UV1.A2 ; v4(66.52,94.03) 66.84,94.35 UV1.B8 ; UV1.H23 54.08,89.8 v4(54.08,89.83) ; UV1.L23 v4(54.89,87.35) ; UV1.E11 64.47,91.95 v4(64.87,92.35) ; v2(34.9,88.87) 35.26,89.23 UV5.J8 ; UV1.R10 v2(65.47,82.95) UV1.T11 ; UV1.U23 54.47,81.93 v4(54.86,81.55) ; v4(60.47,80.09) 60.6,80.09 60.96,80.45 UV1.V15 ; UV1.N14 62.01,85.45 v4(62.51,85.95) 62.51,85.99 UV1.M13 63.45,86.93 v2(63.47,86.93) 63.97,87.43 UV1.L12 ; v4(66.85,87.63) 66.67,87.45 UV1.L10 65.97,87.32 v4(65.46,86.82) 65.1,86.45 UV1.M11 ; UV1.N16 60.01,85.45 v4(60.49,85.93) 60.49,85.97 UV1.M15 61.38,86.86 v4(61.63,86.86) 61.97,87.2 UV1.L14 ; UV1.L5 69.89,86.51 v4(69.89,86.51) ; v4(62.9,89.06) 62.97,88.99 UV1.K13 ; UV1.H5 v4(69.05,88.99) ; v4(72.66,94.9) 72.67,94.91 UV1.B1 ; UV1.L25 52.47,87.33 v4(52.47,87.35) ; UV1.E2 v2(72.43,91.9) ; v2(58.52,83.94) 58.97,84.39 UV1.P17 ; UV1.R14 62.02,83.45 v4(62.53,83.96) 62.97,84.4 UV1.P13 62.97,84.46 v4(63.49,84.98) 63.96,85.45 UV1.N12 ; v4(52.46,92.32) 52.46,92.31 UV1.E25 ; UV1.V17 58.96,80.45 58.43,80.98 v4(58.3,80.98) 57.97,81.31 UV1.U18 ; UV1.P5 v2(69.07,84.05) ; v4(54.93,92.34) 54.98,92.34 UV1.E22 ; v4(50.83,94.75) 50.87,94.75 UV1.B27 ; UV1.L2 71.86,86.93 v2(71.46,87.33) ; UV1.E20 v4(56.61,91.55) ; v4(61.76,73.14) 61.97,73.35 UV1.AF14 UV1.AE14 61.57,75.75 v4(61.56,75.75) ; UV1.AF1 v4(73.25,74.55)
  BOTTOM w0.356: JSIM1.13 240.8,170.64 v2(241.6,171.44) ; JSIM1.12 240.8,162.57 240.55,162.83 240.27,162.83 240,162.56 v2(240,161.95) ; JSIM1.16 226.47,169.51 226.2,169.79 v2(225.45,169.79) ; JSIM1.17 226.47,161.82 226.07,161.42 224.12,161.42 v2(223.87,161.66) ; v2(172.17,24.25) JDIMM2.54
  BOTTOM w0.381: RC115.2 100.04,25.51 v2(100.24,25.3) ; UC3.3 135.53,80.84 135.17,81.21 v2(135.17,83.3) ; v2(51.04,21.52) 51.15,21.64 51.15,22.77 PC317.2 ; US1.1 26.16,67.73 v2(26.45,67.43) ; QV2806.1 v2(25.61,100.18) ; PC319.2 54.65,22.6 v2(54.2,22.15) ; v2(141.43,82.34) 141.25,82.52 140.27,82.52 CC9.2 ; UC7.3 137.83,76.45 137.43,76.05 v2(135.93,76.05) 135.52,76.05 CC82.2 ; RC76.2 103.42,81.18 UC2.3 ; RC241.2 117.18,20.5 v2(116.68,20.5) ; v2(74.08,106.8) 74.08,107.12 74.41,107.45 Q140.1 ; RC306.1 115.06,76.2 114.4,76.86 v2(114.4,77.14) ; v2(155.64,156.96) 156.12,156.96 156.33,157.17 C310.2
  BOTTOM w0.4: UV1.P23 54.47,84.47 v4(54.87,84.87)
  BOTTOM w0.406: v2(101.5,7.57) 101.7,7.37 U93.2
  BOTTOM w0.457: v2(134.72,77.42) 134.72,77.17 134.34,76.79 RC78.1 ; SW6.5 38.85,23.92 v2(38.35,24.41) ; SW6.6 v2(38.71,18.87)
  BOTTOM w0.508: RV2447.2 v2(28.77,87.13) ; R167.2 v2(259.13,163.9) ; CC41.2 109.83,12.93 v2(109.83,12.37) ; PR635.2 v2(57.7,41.46) ; v2(98.22,65.27) 98.35,65.14 RC155.1 ; v2(195.65,28.36) 196.27,28.97 JSATA2.4 ; RC258.2 110.91,23.64 v2(110.96,23.69) ; C239.2 34.85,49.39 v2(33.95,49.39) ; RC76.2 103.22,82.35 v2(103.61,82.73) ; v2(19.34,65.71) 19.16,65.89 C246.2 ; JMINI1.15 279.86,158.38 v2(279.56,158.68) ; PR308.2 54.58,12.31 v2(54.14,11.87) 53.69,12.31 PR307.2 ; JMINI2.26 220.77,142.3 v2(220.89,142.19) ; RC152.1 RC156.1 98.79,67.17 v2(98.27,67.17) ; C410.2 247.56,156.33 v2(247.56,156.9) ; v4(64.45,73.02) v4(63.84,73.02) 63.71,73.14 v4(61.76,73.14) 61.75,73.13 v4(59.49,73.13) 59.44,73.18 v4(57.01,73.18) ; v2(31.28,29.52) 31.47,29.33 PR702.1 ; CV2961.2 CV2964.2 v2(28.41,70.48) ; C130.2 249.48,159.76 v2(249.21,159.76) ; C163.2 C152.2 74.21,86.73 v2(73.63,86.16) ; CC6.1 99.1,51.63 v2(98.91,51.44) ; v2(39.98,11.99) 39.6,11.99 39.6,11.99 U1.4 ; v2(202.28,120.45) 202.22,120.38 JSPK1.5 ; CC35.2 CC38.2 133.97,68.27 134.27,68.57 v2(134.71,68.57) 135.11,68.16 135.11,67.31 134.28,66.48 RC2.2 ; CV2951.2 CV2955.2 32.94,70.11 v2(33.37,70.54) ; CV2948.2 32.73,98.67 RV2906.1 v2(32.74,99.37) 32.74,100.01 v5(33.17,100.45) CV2901.2 ; JMINI2.53 213.8,126.25 v2(213.97,126.42) ; D20.1 134,171.91 v2(133.64,172.27) ; v2(108.62,79.18) 108.82,79.38 CC8.2 ; v2(29.68,55.43) 30.25,55.99 JSD1.6 ; C139.2 246.67,157.6 246.93,157.34 v2(246.93,156.9) ; CC76.2 CC42.2 99.48,59.21 100.01,58.68 v2(100.94,58.68) ; CC5.2 135.04,64.63 135.29,64.89 v2(135.29,65.24) ; YV2401.2 64.35,99.1 v2(64.35,98.88) 64.69,98.54 CV105.2 ; JMINI1.27 287.86,155.76 v2(287.6,155.5) ; C1188.2 v2(284.14,164.51) ; v2(70.65,29.26) PC303.2 ; JSD1.25 v2(12.97,65.63) ; v2(33.45,55.85) 33.68,56.07 C273.2 R299.2 ; C259.2 C258.2 v2(272.31,148.25) ; C213.2 v2(12.86,18.91) ; v2(209.21,133.15) 209.21,132.67 209.57,132.3 JMINI2.9 ; JSPK1.6 201.16,128.39 v2(202.22,128.39) ; v2(193.08,42.98) C3005.2 C3004.2 ; v2(52.79,32.62) PC624.2 PR624.2 PR625.2 ; 77.63,95.37 77.7,95.3 77.7,94.77 77.41,94.48 RV2650.2 ; 77.63,95.37 v2(77.7,95.43) ; 77.63,95.37 RV93.1 ; v2(7.72,34.99) 7.33,34.59 C220.1 ; JMINI2.34 220.6,145.5 v2(221.14,146.04) ; PC102.2 192.14,75.57 192.36,75.8 v2(193.14,75.8) ; PC623.1 52.28,30.84 v2(52.81,31.36) ; v2(8.25,32.31) 7.83,32.73 C216.1 ; RV90.1 RV92.1 RV89.1 v2(60.62,100.32) ; v2(42.58,70.51) CV2920.2 ; PC206.2 272.33,164.71 v2(272.77,165.15) 272.33,165.6 PR205.2 ; JSATA2.12 195.59,42.99 v2(195.41,43.17) ; v2(98.91,48.89) 98.96,48.94 CC7.1 99.67,48.93 RC47.2 RC46.2 ; v2(229.56,161.29) 228.94,160.67 JSIM1.18 ; v2(37.77,97.15) 37.81,97.18 CV2940.2 ; PC300.2 v2(50.9,11.99) ; C432.2 188.82,26.72 v2(188.38,27.17) ; U29.1 188.89,25.01 v2(188.38,25.52) ; v2(102.59,11.87) 102.73,12.01 RC22.2 102.72,12.58 RC127.1 ; RC288.2 102.32,71.77 v2(102.68,72.13) ; v2(33.88,54.41) 34.71,54.41 C240.2 ; JMINI1.9 v2(277.46,155.69) ; v2(74.91,100) 74.86,99.96 C456.2 ; RV2703.2 49.2,72.58 v2(49.3,72.69) ; JMINI2.15 209.83,134.7 209.73,134.6 v2(209.73,134.56) ; PC205.2 v2(261.28,169.59) ; v2(18.04,15.95) 17.88,15.8 U2.4 ; PC309.2 47.09,23.36 v2(47.22,23.23) ; JSIM1.15 v2(226.84,173.12) ; C231.1 v2(16.67,22.98) ; JSATA1.13 v2(83.48,127.65) ; v2(251.24,159.76) 251.24,159.44 250.92,159.12 C118.2 ; v2(62.76,32.5) PR602.2 ; JMINI1.21 285.46,158.35 v2(285.85,158.74) ; PC207.2 v2(274.36,171.44) ; JMINI1.34 290.66,150.28 v2(290.93,150.55) ; CC2.1 132.34,74.18 v2(131.64,74.18) 131.64,73.45 CC1.1 ; JBT1.3 v2(33.88,57.78) ; v2(10.71,36) C215.2 10.51,35.37 R211.2 ; C210.2 17.89,28.83 18.13,29.07 v2(18.33,29.07) 18.52,29.07 18.83,28.76 C255.2 ; RV2436.2 RV2654.2 77.27,91.75 77.48,91.55 v2(77.75,91.55) ; JSIM1.8 234.99,157.83 v2(234.83,157.67) ; JIO1.62 314.25,151.78 314.81,152.33 v2(314.81,154.74) ; C148.2 250.28,166.35 250.61,166.68 ; v2(84.56,106.23) 84.3,106.48 84.3,107.12 84.51,107.33 JSATA1.1 ; PR305.2 48.55,12.06 v2(48.55,12.06) ; JSATA1.4 84.28,111.14 v2(83.79,111.62) ; JMINI2.43 v2(209.84,149.1) ; v2(27.72,31.8) 28.49,31.8 28.78,31.51 JTAA1.26 ; RV2439.2 RV2437.2 35.09,68.68 v2(35.09,68.06) ; v2(32.29,97.08) 31.8,97.58 CV2946.2 ; RC324.1 98.92,70.02 v2(99.39,70.48) 100.1,69.77 RC158.2 ; JSATA2.13 195.6,43.99 v2(195.41,43.81) ; C234.1 17.89,31.05 v2(17.88,31.04) 17.42,31.04 C217.1 ; v2(38.65,58.54) 38.65,59.11 37.95,59.81 37.95,60.95 38.57,61.58 JBT1.2 ; JMINI2.54 v2(214.03,155.55) ; CV104.2 67.74,97.86 v2(67.73,97.84) ; C214.2 8.99,22.52 v2(8.99,21.84) ; C214.2 C218.1 ; C214.2 8.9,22.58 C219.1 ; C221.2 v2(3.91,24.69) ; C120.2 253.07,159.33 v2(252.64,159.76) ; JMINI2.50 220.62,151.9 220.95,151.57 v2(220.95,151.06) ; v2(49.38,31.36) 49.63,31.36 50.02,31.75 PR622.1 ; v2(19.47,30.81) C223.1 ; RC169.2 v2(121.07,74.86) ; v2(236.65,160.64) 238.14,159.15 JSIM1.11 ; JMINI1.26 v2(287.46,150.36) ; CV2947.2 29.11,99.1 v2(29.31,99.3) ; v2(208.06,140.14) 208.33,140.4 210.01,140.4 210.11,140.3 JMINI2.21 ; JMINI1.50 297.06,150.26 296.84,150.49 v2(296.84,151.18) ; C85.1 23.34,17.44 v2(23.9,17.44) ; v2(14.51,21.96) R205.1 ; PR310.2 46.77,12.5 v2(47.22,12.06) 47.66,12.5 PC301.2 ; v2(133.06,60.4) 133.33,60.12 RC237.2 ; v2(96.49,63.87) 96.56,63.81 CC77.2 CC49.2 99.73,63.81 99.8,63.87 v2(100.94,63.87) ; JSATA2.1 v2(195.58,25.16) ; v2(156.33,161.38) R268.2 ; JSATA1.11 85.03,125.11 84.03,125.11 v2(83.48,125.66) ; PC621.1 v2(56.81,41.84) ; v2(69.44,68.83) 70.12,69.5 RV88.1 ; v2(248.77,155.38) 248.69,155.3 C129.2 ; JMINI1.29 v2(288.66,158.54) ; JSATA1.7 86.37,114.95 v2(86.71,114.6) ; D27.1 v2(278.48,163.06) ; v2(247.31,150.23) 246.91,150.63 C144.2 ; JMINI2.4 220.71,130.3 221.14,130.74 v2(221.14,131.18) ; C226.1 7.52,25.12 v2(7.78,25.39) ; v2(8.23,38.01) 8.25,37.99 JSD1.10 ; RV2438.2 34.58,99.18 v2(34.39,99.37) 34.01,99.37 33.63,98.99 RV2440.2 ; v2(303.38,157.85) 302.93,157.41 C142.2 ; v2(13.59,37.42) JSD1.26 ; C154.2 v2(78.9,82.92) ; JMINI1.4 v2(275.46,150.42) ; RC131.1 113.91,14.66 v2(114.12,14.86) ; v2(4.23,34.54) 4.05,34.36 R27.2 ; PR708.2 31.65,32.88 v2(31.22,32.45) 31.67,31.99 PC708.2 ; v2(44.11,62.67) 44.11,64.44 43.6,64.95 C50.2 ; JBT1.4 34.29,64.13 v2(34.16,64.25) ; C232.1 11.59,35.23 v2(12.04,35.68) 12.48,35.24 C233.1 ; v2(56.6,23.09) 56.49,22.98 PC306.2 ; v2(30.26,52.12) 30.64,51.75 JSD1.21 ; v2(250.61,167.25) 250.61,166.68 ; 250.61,166.68 250.94,166.35 C147.2 ; C230.1 17.75,23.1 v2(17.32,22.67) ; C414.2 v2(101.32,2.48) ; JSD1.17 v2(8.25,65.04) ; JMINI2.35 v2(209.84,145.9) ; v2(26.77,64.51) 25.66,65.62 JSD1.23 ; v2(3.72,32.63) 3.78,32.69 C228.2 ; PC613.2 55.6,28.58 PC619.2 v2(55.61,27.8) ; JIO1.61 v2(311,168.53) ; JSD1.20 31.82,62.44 v2(32.49,61.78) ; C1189.2 282.74,164.51 v2(282.75,164.52) ; CV2956.2 40.1,69.84 v2(40.48,69.46) 40.48,69.27 40.17,68.95 CV2928.2 ; v2(35.72,68.06) 36.41,68.75 CV2953.2 CV2957.2 ; PR306.2 v2(51.91,11.99) ; v2(49.63,23.23) 49.63,23.23 PC310.2 ; v2(32.8,48.9) 31.11,48.9 31.17,48.9 ; v2(29.5,97.15) 29.11,97.54 CV2945.2 ; JMINI1.54 v2(300.71,158.74) ; JSIM1.14 241.15,174.37 v2(241.46,174.05) ; JTAA1.25 v2(28.78,20.18) ; JMINI1.43 v2(294.26,155.6) ; JMINI2.18 220.55,139.1 v2(220.95,139.5) ; C225.1 v2(3.91,25.96) ; v2(25.56,88.45) 26.14,87.88 RV2908.1 ; JTAA1.24 v2(25.88,31.74) ; v2(4.95,38.04) JSD1.13 ; v2(31.1,68.25) CV2968.2 ; C227.2 v2(5.37,28.93) ; RC233.2 RC232.2 v2(120.32,20.23) ; CV2966.2 v2(31.1,70.48) ; v3(172.34,77.14) 172.13,77.35 JDIMM1.206 ; C460.2 v2(190.51,21.01) ; R214.2 v2(5.31,28.06) ; PC614.2 62.84,36.06 v2(62.84,36.06) ; PC625.2 PC626.2 v2(50.52,36.38) ; PR616.1 v2(52.93,27.8) ; JTAA1.22 22.98,31.25 v2(23.66,31.93) ; JTAA1.21 v2(22.98,20.14) ; JMINI1.35 v2(291.06,155.76) ; C111.2 v2(82.33,131.63) ; PH302.2 49.45,51.43 v2(48.87,51.43) ; v2(66.81,102.82) 67.03,102.82 67.37,102.48 YV2401.4 ; v2(25.85,36.19) JSD1.24 ; JMINI1.53 v2(271.41,153.98) ; C123.2 v2(247.94,150.74) ; JMINI2.29 v2(209.84,143.5) ; JSD1.22 31.82,39.32 v2(32.68,38.47) ; CC3.1 146.75,73.04 ME1.1 146.75,71.39 v2(146.21,70.86) ; CV2919.2 39.85,97.59 39.34,97.08 v2(39.09,97.08) ; C112.2 v2(81.52,127.99) ; v2(4.93,22.53) C224.1 ; C206.2 185.65,156.91 v2(184.77,157.79) ; C247.2 v2(15.21,66.92) ; v2(57.25,11.87) PR309.2 ; v2(267.88,152.96) 267.77,152.85 C141.2 ; v2(94.26,67.01) 94.32,67.07 94.98,67.07 RC153.1 ; PR204.2 v2(267.3,162.87) ; JMINI1.18 v2(284.26,150.36) ; C121.2 v2(249.47,156.96) ; SW6.4 v2(38.24,19.54) ; JSATA1.19 86.04,135.27 v2(86.59,135.82) ; v2(61.51,100.32) RV2441.1 RV2442.2 ; JSATA2.7 v2(195.81,32.78) ; JMINI2.27 v2(209.84,142.7) ; C5.2 v2(28.68,17.58) ; JSATA1.17 86.31,132.73 86.84,132.2 v2(86.84,130.99) ; v2(145.52,70.86) 145.43,70.95 CMOS1.1 145.66,72.17 CC4.1 ; RV46.1 61.51,102.67 v2(61.06,103.12) 60.62,102.67 RV45.1 ; v2(25.95,13.45) C6.2 ; C76.1 v2(28.04,13.28) ; RC236.1 101.19,59.67 v2(101.7,60.18) ; JTAA1.23 v2(25.88,20.12)
  vias: v2(0.74,105.34) v2(2.08,37.49) v2(2.21,63.43) v2(2.21,58.27) v2(2.21,53.11) v2(2.21,47.95) v2(2.21,42.79) v2(2.21,32.47) v2(2.21,27.31) v2(2.21,22.14) v2(2.21,16.98) v2(2.21,11.82) v2(3.41,7.42) v2(3.72,31.93) v2(3.72,31.3) v2(3.76,68.6) v2(3.77,2.45) v2(4.16,83.11) v2(5.45,105.73) v2(5.64,103.06) v2(6.64,86.48) v2(6.58,0.5) v2(7.64,103.06) v2(9.24,83.11) v2(10.37,68.6) v2(10.45,30.23) v2(10.45,26.84) v2(10.49,28.53) v2(10.92,105.73) v2(11.21,0.5) v2(12.18,30.22) v2(12.16,28.51) v2(12.18,26.8) v2(13.5,70.6) v2(13.73,81.11) v2(13.81,30.22) v2(13.81,28.49) v2(13.84,26.8) v2(14.3,83.08) v2(14.71,68.95) v2(14.77,8.44) v2(14.77,3.36) v2(15.85,101.65) v2(16.04,82.22) v2(16.04,81.59) v2(16.39,105.73) v2(16.48,101.65) v2(16.48,94.86) v2(16.86,99.37) v2(17.63,10.41) v2(21.87,105.73) v2(22.45,94.71) v2(22.61,99.33) v2(22.71,10.41) v2(22.9,99.91) v2(23.39,96.05) v2(24.36,82.41) v2(24.36,81.78) v2(24.36,81.14) v2(24.99,82.41) v2(24.99,81.78) v2(24.99,81.14) v2(26.45,66.79) v2(26.83,71.75) v2(27.34,105.73) v2(27.46,85.59) v2(27.79,10.41) v2(30.9,83.15) v2(31.7,84.01) v2(32.36,104) v2(32.87,10.41) v2(35.74,105.73) v2(35.79,41.77) v2(35.79,41.14) v2(35.79,40.5) v2(35.79,39.87) v2(36.23,31.87) v2(36.23,31.04) v2(36.23,30.22) v2(37.95,10.41) v2(39.79,33.14) v2(39.79,32.5) v2(40.1,33.65) v2(40.48,33.14) v2(40.48,32.5) v2(40.82,105.73) v2(40.87,33.65) v2(41.18,33.14) v2(41.18,32.5) v2(41.63,33.65) v2(41.69,83.81) v2(41.69,32.82) v2(42.3,83.81) v2(43.03,10.41) v2(44.74,62.67) v2(44.74,62.03) v2(44.74,61.08) v2(45.9,105.73) v2(46.14,62.67) v2(46.14,62.03) v2(47.95,31.31) v2(47.95,30.67) v2(48.11,10.41) v2(49.25,58.47) v2(49.88,58.47) v2(49.88,19.3) v2(49.88,17.39) v2(50.01,42.85) v2(50.01,42.24) v2(50.01,41.66) v2(50.33,41.13) v2(50.52,58.47) v2(50.65,42.85) v2(50.65,42.24) v2(50.65,41.66) v2(50.84,18.34) v2(50.98,105.73) v2(50.96,41.13) v2(51.15,58.47) v2(51.28,42.85) v2(51.28,42.24) v2(51.28,41.66) v2(51.79,19.3) v2(51.79,17.39) v2(52.55,58.79) v2(53.12,22.03) v2(53.19,42.85) v2(53.19,42.22) v2(53.19,10.41) v2(53.82,42.85) v2(53.82,42.22) v2(54.12,74.95) v2(54.12,73.35) v2(54.12,72.71) v2(55.6,42.73) v2(55.66,36.06) v2(55.73,34.54) v2(56.23,42.73) v2(56.49,35.3) v2(56.87,42.73) v2(57.19,34.54) v2(57.25,36.06) v2(57.44,42.85) v2(57.76,106.61) v2(57.76,42.28) v2(58.08,42.85) v2(58.27,10.41) v2(58.39,42.28) v2(58.52,96.38) v2(58.71,42.85) v2(59.03,42.28) v2(59.35,42.85) v2(59.66,42.28) v2(59.85,20.95) v2(59.98,42.85) v2(60.04,14.28) v2(60.3,42.28) v2(60.3,14.91) v2(60.62,42.85) v2(60.61,20.95) v2(60.93,42.28) v2(61.25,42.85) v2(61.31,20.95) v2(61.44,49.65) v2(61.44,49.01) v2(61.44,47.93) v2(61.44,47.3) v2(61.44,46.28) v2(61.44,45.65) v2(61.38,44.76) v2(61.38,44.12) v2(61.38,43.49) v2(61.57,42.28) v2(61.89,42.85) v2(62.01,44.76) v2(62.01,44.12) v2(62.01,43.49) v2(62.01,14.91) v2(62.07,20.95) v2(62.52,42.85) v2(62.65,14.91) v2(62.65,14.28) v2(62.96,20.95) v2(63.08,57.84) v2(63.16,57.02) v2(63.18,56.39) v2(63.22,14.6) v2(63.22,13.96) v2(63.35,10.41) v2(63.59,58.22) v2(63.6,57.53) v2(63.6,20.95) v2(63.73,108.77) v2(63.71,56.71) v2(64.37,56.69) v2(65.69,78.25) v2(66.52,26.53) v2(66.52,25.39) v2(66.52,24.37) v2(66.52,23.23) v2(66.96,71.43) v2(67.15,25.9) v2(67.15,24.88) v2(67.15,23.87) v2(67.28,22.41) v2(67.28,21.77) v2(67.84,26.53) v2(67.84,25.39) v2(67.84,24.37) v2(67.84,23.23) v2(67.92,22.41) v2(67.92,21.77) v2(67.92,21.14) v2(67.92,20.5) v2(68.43,10.41) v2(68.49,21.52) v2(68.49,20.88) v2(68.49,20.25) v2(68.55,72) v2(68.73,111.7) v2(69.07,83.21) v2(69.06,21.14) v2(69.89,40.31) v2(70.01,15.93) v2(70.01,15.17) v2(70.01,14.41) v2(70.2,40.89) v2(70.2,39.74) v2(70.52,40.31) v2(70.65,15.61) v2(70.65,14.85) v2(70.65,14.09) v2(70.84,40.89) v2(70.84,39.74) v2(71.16,40.31) v2(71.47,40.89) v2(71.47,39.74) v2(71.79,40.31) v2(72.11,40.89) v2(72.11,39.74) v2(72.43,40.31) v2(72.74,40.89) v2(72.74,39.74) v2(73.07,115.48) v2(73.06,40.31) v2(73.38,40.89) v2(73.38,39.74) v2(73.53,61.41) v2(73.51,10.41) v2(73.7,40.31) v2(73.94,60.81) v2(74.01,40.89) v2(74.17,61.41) v2(74.57,60.78) v2(74.78,170.43) v2(74.9,61.27) v2(75.25,60.77) v2(75.48,164.52) v2(75.56,61.29) v2(75.6,40.31) v2(75.92,40.89) v2(75.92,39.74) v2(76.24,56.51) v2(76.24,55.87) v2(76.24,55.17) v2(76.24,54.54) v2(76.24,40.31) v2(76.3,174.79) v2(76.55,40.89) v2(76.55,39.74) v2(76.87,40.31) v2(77.11,120.72) v2(77.19,40.89) v2(77.19,39.74) v2(77.51,40.31) v2(77.82,40.89) v2(77.82,39.74) v2(78.14,40.31) v2(78.33,166.81) v2(78.33,166.17) v2(78.33,165.54) v2(78.33,164.9) v2(78.33,164.27) v2(78.46,40.89) v2(78.46,39.74) v2(78.59,10.41) v2(78.85,160.83) v2(78.78,40.31) v2(78.87,86.91) v2(78.87,86.15) v2(78.87,85.39) v2(78.97,166.81) v2(78.97,166.17) v2(78.97,165.54) v2(78.97,164.9) v2(78.97,164.27) v2(79.09,42.22) v2(79.09,41.52) v2(79.09,40.89) v2(79.48,167.89) v2(79.48,167.25) v2(79.48,125.34) v2(80.11,167.89) v2(80.11,167.25) v2(80.62,104.89) v2(80.75,167.89) v2(80.75,167.25) v2(80.71,155.76) v2(80.93,129.85) v2(81.13,148.64) v2(81.2,174.79) v2(81.79,140.71) v2(81.76,135.69) v2(82.02,159.76) v2(82.02,159.12) v2(82.02,158.49) v2(82.13,62.63) v2(82.33,103.43) v2(82.33,70.92) v2(82.52,36.44) v2(82.52,35.17) v2(82.52,34.53) v2(82.52,33.26) v2(82.52,28.82) v2(83.36,61.55) v2(83.67,10.41) v2(83.83,51.06) v2(84.43,55.06) v2(84.43,54.47) v2(84.43,53.89) v2(84.76,65.07) v2(84.81,49.2) v2(84.81,48.5) v2(84.81,36.44) v2(84.81,35.17) v2(84.81,34.53) v2(84.81,33.26) v2(84.81,28.82) v2(85.22,62.3) v2(85.18,59.29) v2(85.29,50.69) v2(85.25,13.52) v2(85.44,116.39) v2(85.44,115.75) v2(85.64,18.85) v2(85.89,13.52) v2(86.4,69.9) v2(86.46,18.85) v2(86.52,13.52) v2(86.65,174.79) v2(86.71,113.97) v2(87.03,69.9) v2(87.03,68.7) v2(87.1,49.14) v2(87.09,48.5) v2(87.09,44.06) v2(87.09,42.79) v2(87.09,42.15) v2(87.09,40.88) v2(87.09,36.44) v2(87.09,35.17) v2(87.09,34.53) v2(87.09,33.26) v2(87.09,28.82) v2(87.18,61.92) v2(87.29,18.85) v2(87.9,154.8) v2(88.01,82.4) v2(88.43,109.27) v2(88.43,108.64) v2(88.53,154.8) v2(88.75,10.41) v2(89.28,81.33) v2(89.27,49.78) v2(89.32,42.79) v2(89.34,42.17) v2(89.34,40.89) v2(89.36,44.09) v2(89.38,36.44) v2(89.38,35.17) v2(89.38,34.53) v2(89.38,33.26) v2(89.45,29.07) v2(90.46,73.03) v2(90.46,72.38) v2(90.46,71.66) v2(91.34,162.17) v2(91.34,161.54) v2(91.34,160.9) v2(91.34,160.27) v2(91.62,49.65) v2(91.62,48.43) v2(91.67,42.98) v2(91.67,42.4) v2(91.67,40.88) v2(91.67,36.44) v2(91.67,35.17) v2(91.67,34.53) v2(91.67,33.26) v2(91.67,28.82) v2(91.78,81.68) v2(91.78,79.87) v2(92.49,145.98) v2(92.49,145.34) v2(92.62,27.36) v2(92.87,80.66) v2(93.32,27.36) v2(93.89,40.88) v2(93.93,36.44) v2(93.93,35.17) v2(93.93,34.53) v2(93.93,33.26) v2(93.95,28.82) v2(94.08,49.71) v2(94.08,48.82) v2(94.21,71.3) v2(94.27,43.64) v2(94.53,145.98) v2(94.53,145.34) v2(95.48,96.38) v2(96.07,96.38) v2(96.18,145.34) v2(96.24,36.44) v2(96.24,35.17) v2(96.24,34.53) v2(96.24,33.26) v2(96.24,28.82) v2(96.3,38.39) v2(96.81,41.33) v2(96.87,53.66) v2(96.87,53.08) v2(97.26,167.31) v2(97.78,161.54) v2(97.89,167.31) v2(98.41,161.54) v2(98.53,167.31) v2(99.05,161.54) v2(98.97,10.09) v2(99.16,167.31) v2(99.16,166.68) v2(99.66,161.54) v2(99.92,7.67) v2(99.92,2.59) v2(100.25,161.54) v2(101.24,38.65) v2(101.31,36.27) v2(101.31,32.69) v2(101.37,35) v2(101.37,30.86) v2(101.82,67.21) v2(101.8,1.51) v2(101.89,113.91) v2(101.95,156.9) v2(101.95,156.26) v2(101.95,155.63) v2(101.95,154.99) v2(101.95,111.37) v2(102.59,156.9) v2(102.59,156.26) v2(102.59,155.63) v2(102.59,154.99) v2(102.77,38.05) v2(102.95,39.45) v2(103.22,156.26) v2(103.22,155.63) v2(103.22,154.99) v2(103.16,112.77) v2(103.33,50.5) v2(103.26,36.27) v2(103.26,35) v2(103.26,32.69) v2(103.26,30.86) v2(103.43,47.59) v2(103.46,65.73) v2(103.86,156.26) v2(103.86,155.63) v2(103.86,154.99) v2(104.04,36.96) v2(104.43,113.85) v2(104.49,156.26) v2(104.49,155.63) v2(104.49,154.99) v2(104.49,111.31) v2(104.75,45.9) v2(105.28,47.59) v2(106.27,174.79) v2(106.88,1.51) v2(107.29,118.55) v2(108.02,53.39) v2(108.02,50.89) v2(108.02,48.38) v2(108.02,45.87) v2(108.02,43.36) v2(108.02,40.86) v2(108.02,38.35) v2(108,35.46) v2(108.02,33.34) v2(107.96,15.94) v2(110.02,102.54) v2(110.63,102.54) v2(111.23,102.54) v2(111.8,174.79) v2(111.96,1.51) v2(112.37,96.57) v2(113,96.57) v2(113.64,96.57) v2(114.91,150.3) v2(114.91,149.66) v2(115.54,172.99) v2(116.12,155.5) v2(116.12,154.89) v2(116.12,154.3) v2(116.29,25.72) v2(117.04,1.51) v2(117.13,69.09) v2(117.83,25.84) v2(117.84,23.24) v2(119.04,113.78) v2(120.23,131.44) v2(120.31,113.78) v2(120.39,69.64) v2(120.62,172.99) v2(120.83,131.44) v2(121.13,113.78) v2(121.58,140.07) v2(122.12,1.51) v2(122.4,165.6) v2(122.4,164.96) v2(122.4,164.33) v2(122.4,163.7) v2(122.78,25.9) v2(122.81,23.52) v2(123.04,164.96) v2(123.04,164.33) v2(123.04,163.7) v2(124.24,113.78) v2(124.37,137.41) v2(124.5,140.14) v2(125.51,69.26) v2(125.51,25.26) v2(125.91,92.31) v2(126.14,69.79) v2(126.4,113.78) v2(126.52,92.31) v2(126.56,26.16) v2(126.97,23.8) v2(127.13,92.31) v2(127.44,172.99) v2(127.41,1.51) v2(127.7,24.77) v2(128.91,25.95) v2(129.13,105.59) v2(129.49,40.49) v2(130.02,41.96) v2(130.73,46.79) v2(130.83,38.91) v2(130.97,45.27) v2(131.16,172.97) v2(131.42,168.33) v2(131.42,167.69) v2(131.42,167.06) v2(131.48,102.92) v2(131.53,34.23) v2(131.46,31.5) v2(131.73,41.96) v2(131.98,52.54) v2(132.37,101.34) v2(132.37,100.7) v2(132.36,54.38) v2(132.75,30.19) v2(132.7,1.51) v2(132.79,36.02) v2(132.94,172.27) v2(132.91,32.85) v2(133.07,50.33) v2(133.41,48.83) v2(133.74,52.54) v2(134.11,58.05) v2(134.07,28.88) v2(134.29,31.47) v2(135.02,54.38) v2(135.27,48.83) v2(135.42,174.11) v2(135.46,52.46) v2(135.61,50.33) v2(135.67,30.09) v2(137.3,41.72) v2(137.28,39.57) v2(137.39,33.9) v2(137.73,37.5) v2(137.88,41.72) v2(137.87,39.57) v2(137.99,1.51) v2(138.31,37.5) v2(139.23,33.9) v2(140.7,174.14) v2(141.89,33.91) v2(143.28,1.51) v2(143.37,105.59) v2(143.37,103.81) v2(143.37,102.04) v2(144.07,79.43) v2(144.07,78.82) v2(144.07,77.82) v2(144.07,77.21) v2(144.07,76.55) v2(144.07,75.94) v2(145.14,105.59) v2(145.14,103.81) v2(145.14,102.04) v2(146.1,174.14) v2(146.92,105.59) v2(146.92,103.81) v2(146.92,102.04) v2(148.16,156.84) v2(148.57,1.51) v2(148.69,53.47) v2(149.28,53.47) v2(149.83,156.86) v2(149.81,61.2) v2(149.88,53.47) v2(150.42,61.2) v2(150.52,136.63) v2(150.49,53.47) v2(151.01,61.2) v2(151.51,174.14) v2(151.61,61.2) v2(151.8,80) v2(151.8,79.37) v2(151.8,78.41) v2(151.8,77.78) v2(151.81,53.47) v2(152.42,53.47) v2(152.69,79.43) v2(152.69,78.41) v2(152.69,77.78) v2(152.95,80) v2(153.01,53.47) v2(153.52,155.49) v2(153.62,53.47) v2(153.86,1.51) v2(156.77,135.32) v2(156.91,174.14) v2(157.9,152.33) v2(159.17,152.33) v2(159.15,1.51) v2(159.49,82.1) v2(160.12,82.1) v2(160.5,152.33) v2(160.5,49.14) v2(160.72,12.31) v2(160.88,68.75) v2(161.01,54.42) v2(161.01,15.69) v2(161.1,59.59) v2(161.13,57.01) v2(161.07,24.4) v2(161.18,29.14) v2(161.2,20.82) v2(161.21,17.51) v2(161.16,14.13) v2(161.26,19.42) v2(162.32,174.14) v2(162.28,135.31) v2(162.28,134.29) v2(163.11,123.69) v2(163.11,123.05) v2(163.97,69.08) v2(163.97,65.65) v2(163.97,63.11) v2(163.97,60.06) v2(163.97,57.78) v2(163.97,54.73) v2(163.97,52.44) v2(164.41,41.89) v2(164.44,1.51) v2(164.56,15.98) v2(164.79,45.51) v2(164.79,43.41) v2(164.79,39.98) v2(164.89,38.35) v2(164.89,35.94) v2(164.89,32.25) v2(164.87,21.56) v2(164.94,17.51) v2(164.94,14.27) v2(164.94,11.99) v2(165.12,61.59) v2(165.12,50.72) v2(165.17,29.39) v2(165.25,25.63) v2(165.25,23.09) v2(165.25,20.05) v2(165.45,48.28) v2(165.5,69.08) v2(165.5,65.65) v2(165.5,63.11) v2(165.5,60.06) v2(165.5,57.78) v2(165.5,54.73) v2(165.5,52.44) v2(165.55,42.73) v2(165.71,99.37) v2(165.71,97.59) v2(165.71,95.81) v2(166.08,10.46) v2(166.32,39.98) v2(166.32,27.18) v2(166.42,38.35) v2(166.42,35.94) v2(166.42,34.27) v2(166.42,32.25) v2(166.46,17.51) v2(166.46,14.27) v2(166.46,11.99) v2(166.46,8.94) v2(166.64,67.18) v2(166.65,56.29) v2(166.7,41.89) v2(166.7,29.39) v2(166.77,25.63) v2(166.77,23.09) v2(166.77,20.05) v2(166.84,15.98) v2(167.02,65.65) v2(167.02,63.11) v2(167.02,60.06) v2(167.02,57.78) v2(167.02,54.73) v2(167.02,52.44) v2(166.97,48.28) v2(167.08,43.41) v2(167.08,39.98) v2(167.15,21.56) v2(167.4,61.59) v2(167.4,50.72) v2(167.48,99.37) v2(167.48,97.59) v2(167.48,95.81) v2(167.72,174.14) v2(167.84,45.51) v2(167.84,42.34) v2(167.94,38.35) v2(167.94,35.94) v2(167.94,34.27) v2(167.94,32.25) v2(167.98,17.51) v2(167.98,14.27) v2(167.98,11.99) v2(167.98,8.94) v2(168.12,158.8) v2(168.12,157.09) v2(168.22,29.39) v2(168.3,25.63) v2(168.3,23.09) v2(168.3,20.05) v2(168.37,10.46) v2(168.55,65.65) v2(168.55,63.11) v2(168.55,60.06) v2(168.55,57.78) v2(168.55,54.73) v2(168.55,52.44) v2(168.5,48.28) v2(168.6,27.17) v2(168.69,39.97) v2(168.93,67.18) v2(168.93,56.29) v2(169.26,99.37) v2(169.26,97.59) v2(169.26,95.81) v2(169.45,8.18) v2(170.91,122.8) v2(170.98,119.94) v2(171.11,138.48) v2(171.61,140.03) v2(172.16,61.2) v2(172.18,59.11) v2(172.25,56.81) v2(172.18,55.23) v2(172.18,22.09) v2(172.23,19.24) v2(172.17,16.14) v2(172.21,14.27) v2(172.32,121.4) v2(172.31,53.59) v2(172.27,26.37) v2(172.42,63.11) v2(172.37,11.87) v2(172.5,67.45) v2(172.5,29.52) v2(172.62,65.64) v2(172.56,48.67) v2(172.74,27.85) v2(172.88,51.98) v2(172.99,45.44) v2(173.13,174.14) v2(173.64,122.8) v2(173.64,119.94) v2(173.75,46.7) v2(173.84,127.56) v2(173.8,11.87) v2(174.03,55.23) v2(174.13,65.64) v2(174.09,61.14) v2(174.09,56.81) v2(174.15,53.59) v2(174.15,27.93) v2(174.09,24.25) v2(174.12,14.21) v2(174.2,67.42) v2(174.22,26.35) v2(174.34,22.3) v2(174.33,19.31) v2(174.34,17.73) v2(174.28,10.44) v2(175.03,1.51) v2(175.61,129.66) v2(176.41,114.74) v2(176.57,116.26) v2(176.8,115.31) v2(177.14,114.74) v2(177.46,115.31) v2(177.71,139.63) v2(177.71,137.66) v2(177.71,117.15) v2(177.97,50.22) v2(177.95,43.93) v2(177.95,39.5) v2(177.95,37.22) v2(177.95,35.44) v2(177.95,33.41) v2(177.97,31.8) v2(178.08,61.14) v2(178.08,22.09) v2(178.08,16.38) v2(178.15,129.79) v2(178.15,129.04) v2(178.21,9.24) v2(178.35,68.31) v2(178.35,65.24) v2(178.35,62.7) v2(178.53,174.14) v2(178.46,59.62) v2(178.46,57.08) v2(178.46,54.03) v2(178.46,51.75) v2(178.46,48.32) v2(178.46,28.96) v2(178.46,25.65) v2(178.46,23.33) v2(178.46,20.31) v2(178.46,18.03) v2(178.46,14.81) v2(178.46,12.39) v2(178.7,138.64) v2(178.71,42.22) v2(179.22,113.28) v2(179.35,10.86) v2(179.49,66.76) v2(179.45,45.49) v2(179.48,43.93) v2(179.48,39.5) v2(179.48,37.22) v2(179.48,35.44) v2(179.48,33.41) v2(179.5,31.8) v2(179.58,55.51) v2(179.6,27.49) v2(179.68,137.6) v2(179.73,9.24) v2(179.8,139.56) v2(179.87,68.31) v2(179.87,65.24) v2(179.87,62.7) v2(179.86,41.7) v2(179.93,28.93) v2(179.98,59.62) v2(179.98,57.08) v2(179.98,54.03) v2(179.98,51.75) v2(179.98,48.32) v2(179.98,25.65) v2(179.99,23.33) v2(179.98,20.31) v2(179.98,18.03) v2(179.98,14.81) v2(179.98,12.39) v2(180.24,43.93) v2(180.24,39.5) v2(180.26,50.22) v2(180.29,16.38) v2(180.32,1.51) v2(180.37,61.14) v2(180.37,22.09) v2(180.54,123.77) v2(180.82,129.28) v2(180.98,45.49) v2(181.01,40.63) v2(181,37.22) v2(181,35.44) v2(181,33.41) v2(181.02,31.8) v2(181.16,123.77) v2(181.25,9.24) v2(181.4,68.31) v2(181.4,65.24) v2(181.4,62.7) v2(181.46,158.36) v2(181.46,157.22) v2(181.51,59.62) v2(181.51,57.08) v2(181.51,54.03) v2(181.51,51.75) v2(181.51,48.32) v2(181.51,28.93) v2(181.51,25.65) v2(181.51,23.33) v2(181.51,20.31) v2(181.51,18.03) v2(181.51,14.81) v2(181.51,12.39) v2(181.64,10.86) v2(181.71,79.62) v2(181.71,78.98) v2(181.71,78.35) v2(181.71,77.71) v2(181.71,77.08) v2(181.78,66.76) v2(181.76,43.93) v2(181.76,39.5) v2(181.89,55.51) v2(181.89,27.49) v2(182.14,41.7) v2(182.22,16.45) v2(182.35,81.53) v2(182.34,80.89) v2(182.34,80.25) v2(182.34,79.62) v2(182.34,78.98) v2(182.34,78.35) v2(182.34,77.71) v2(182.34,77.08) v2(182.39,24.35) v2(182.41,10.85) v2(182.52,37.22) v2(182.52,35.44) v2(182.52,33.41) v2(182.92,7.17) v2(182.98,81.53) v2(182.98,80.89) v2(182.98,80.25) v2(182.98,79.62) v2(182.98,78.98) v2(182.98,78.35) v2(182.98,77.71) v2(182.98,77.08) v2(183.14,74.11) v2(183.75,74.11) v2(183.94,174.14) v2(184.36,74.11) v2(185.35,63.85) v2(185.26,59.05) v2(185.26,53.65) v2(185.31,15.6) v2(185.39,69.27) v2(185.39,67.43) v2(185.44,29.07) v2(185.4,23.17) v2(185.43,18.22) v2(185.46,65.33) v2(185.48,61.78) v2(185.46,52.12) v2(185.52,26.53) v2(185.51,21.25) v2(185.48,11.29) v2(185.86,1.51) v2(187.55,119.43) v2(187.74,30.03) v2(187.74,29.39) v2(187.74,28.76) v2(188,158.36) v2(188,157.22) v2(189.35,174.14) v2(190.41,143.06) v2(190.98,44.31) v2(190.98,43.7) v2(190.98,43.09) v2(190.98,42.49) v2(191.41,1.65) v2(191.89,10.98) v2(191.89,5.9) v2(192.5,26.23) v2(193.08,70.73) v2(193.97,75.18) v2(194.35,78.86) v2(194.35,78.22) v2(194.35,77.59) v2(194.35,76.95) v2(194.75,174.14) v2(194.98,65.78) v2(194.98,62.16) v2(195.36,138.74) v2(195.36,138.1) v2(195.62,65.78) v2(195.62,62.16) v2(195.87,67.94) v2(196,138.74) v2(196,138.1) v2(196.63,138.74) v2(196.63,138.1) v2(196.84,116.6) v2(196.84,111.01) v2(196.84,105.43) v2(196.84,99.84) v2(196.84,94.25) v2(196.84,88.67) v2(196.84,83.08) v2(196.84,77.49) v2(196.82,63.75) v2(197.08,149.15) v2(197.08,148.52) v2(197.08,147.88) v2(197.08,147.25) v2(197.08,146.61) v2(197.08,145.98) v2(197.33,160.39) v2(197.27,138.74) v2(197.27,138.1) v2(197.71,149.15) v2(197.71,148.52) v2(197.71,147.88) v2(197.71,147.25) v2(197.71,146.61) v2(197.71,145.98) v2(197.89,139.42) v2(197.9,138.74) v2(197.9,138.1) v2(197.97,160.39) v2(198.54,160.52) v2(198.54,159.88) v2(198.54,138.74) v2(198.54,138.1) v2(198.85,118.61) v2(199.17,138.74) v2(199.24,14.57) v2(199.36,60.32) v2(199.36,55.33) v2(199.36,50.16) v2(199.36,45.08) v2(199.36,40) v2(199.36,34.92) v2(199.36,29.84) v2(199.36,24.76) v2(199.36,19.68) v2(199.68,173.73) v2(203.3,172.97) v2(203.78,155.9) v2(203.78,155.26) v2(204.42,155.9) v2(204.42,155.26) v2(204.84,118.61) v2(209.78,148.2) v2(209.78,147.57) v2(211.3,137.85) v2(211.3,137.21) v2(212.56,172.99) v2(212.89,145.6) v2(213.78,143.25) v2(213.97,127.69) v2(213.97,127.05) v2(214.54,127.37) v2(214.54,126.74) v2(215.11,127.05) v2(215.65,123) v2(216.38,151.38) v2(216.38,150.61) v2(216.38,149.85) v2(218.44,172.99) v2(219.75,127.11) v2(223.85,131.21) v2(224.46,174.79) v2(227.96,135.31) v2(229.54,174.79) v2(231.3,142.99) v2(231.3,142.36) v2(232.06,139.42) v2(236.16,143.52) v2(237.58,144.11) v2(237.97,174.79) v2(239.43,154.55) v2(239.43,152.39) v2(240.07,154.55) v2(240.07,152.39) v2(242.29,174.79) v2(242.86,144.11) v2(247.37,174.79) v2(248.15,144.11) v2(248.96,170.17) v2(249.78,170.17) v2(250.61,170.17) v2(251.43,170.17) v2(252.26,170.17) v2(252.45,174.79) v2(253.43,144.11) v2(253.78,154.17) v2(253.78,152.52) v2(253.78,150.93) v2(255.5,154.17) v2(255.5,152.45) v2(255.5,150.93) v2(255.94,160.27) v2(256.77,160.27) v2(257.15,152.45) v2(257.21,154.17) v2(257.21,150.93) v2(257.38,160.27) v2(257.53,174.79) v2(258.72,144.11) v2(262.61,174.79) v2(263.12,162.87) v2(263.75,169.73) v2(263.75,162.87) v2(264,144.11) v2(264.34,169.73) v2(264.96,169.73) v2(267.56,166.36) v2(267.69,174.79) v2(268.32,166.36) v2(269.15,166.36) v2(269.28,144.11) v2(272.77,174.79) v2(274.57,144.11) v2(277.85,174.79) v2(279.85,144.11) v2(282.93,174.79) v2(285.13,144.11) v2(287.75,163.25) v2(287.98,176.69) v2(289.72,160.77) v2(290.42,144.11) v2(290.89,158.53) v2(293.03,170.93) v2(293.06,176.69) v2(293.51,169.36) v2(293.47,167.38) v2(295.7,144.11) v2(298.14,176.69) v2(299.06,170.62) v2(299.23,169.17) v2(299.69,151.88) v2(299.69,151.25) v2(299.95,169.78) v2(300.71,169.12) v2(300.83,170.62) v2(300.98,144.11) v2(303.22,176.69) v2(303.88,173.66) v2(303.9,158.32) v2(304.48,158.32) v2(306.02,144.11) v2(308.19,176.68) v2(311.91,144.26) v2(313.38,176.69) v2(313.92,154.68) v2(315.54,175.7) v2(315.54,169.92) v2(315.54,164.14) v2(315.54,158.36) v2(315.54,152.58) v2(315.54,146.8) v3(174.85,82.35) v3(174.85,81.59) v3(175.55,82.35) v3(175.55,81.59) v3(177.16,86.3) v3(177.9,86.29) v4(50.48,84.45) v5(40.87,31.77) v5(42.34,84.65) v5(72.14,89.89) v5(74.1,17.89) v5(78.45,168.25) v5(83.29,160.23) v5(85.67,114.46) v5(92.39,162.08) v5(104.39,153.81) v5(130.62,101.4) v5(193.55,79.2) v5(195.99,147.31) v5(196.2,137.29) v5(211.56,128.53)
