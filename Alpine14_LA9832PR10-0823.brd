# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 39.1
  TOP w0.127: v5(302.77,152.16) 302.49,151.88 v2(301.6,151.88) ; v2(307.82,157.34) v5(308.52,157.34) ; v2(312.27,153.34) v5(311.48,153.34)
  IN3 w0.508: v2(264.64,151.18) 264.64,154.94 v2(265.82,156.12) 264.6,157.34 v2(264.6,157.99)
  BOTTOM w0.254: JIO1.55 v2(307.82,153.9) ; JIO1.45 v2(307.82,156.4) ; U17.26 257.68,148.74 257.97,148.45 v2(257.97,148.33) ; JIO1.51 v2(307.82,154.9) ; v2(252.01,148.43) 252.24,148.43 252.68,148.88 U17.36 ; v2(307.82,157.34) 307.82,157.6 307.52,157.9 JIO1.39 ; JIO1.56 311.58,153.9 312.14,153.34 v2(312.27,153.34) ; C115.2 258.1,146.17 v2(258.61,145.66) 259.05,146.1 C167.1
  BOTTOM w0.381: Q20.3 263,158.67 Q21.1 ; v2(307.76,153.03) 307.57,152.84 JIO1.59 ; Q123.4 v2(245.27,146.68) ; Q123.1 v2(247.88,148.6)
  BOTTOM w0.432: v2(265.82,156.12) 265.61,156.34 Q21.4 ; Q21.1 264.31,158.28 v2(264.6,157.99)
  BOTTOM w0.508: v2(254.29,146.17) 254.48,146.36 C385.2 ; C169.2 260.07,145.98 259.75,145.66 v2(259.43,145.66) ; C142.1 v2(302.93,155.38) ; v2(261.53,148.26) C131.2 ; v2(243.94,145.72) 243.94,146.21 C116.2 243.31,146.21 v2(243.31,145.72) ; C138.2 v2(250.16,146.61) ; C144.1 246.67,149.34 246.42,149.09 v2(246.42,148.64) ; v2(263.31,150.3) 263.12,150.11 R39.2 ; C412.2 v2(249.78,145.98) ; v2(264.26,145.22) 264.26,145.7 C117.2 264.9,145.7 v2(264.9,145.22) ; C141.1 v2(267.12,151.25) ; C150.2 248.69,149.33 v2(248.51,149.15)
  vias: v2(263.94,151.18) v2(301.6,151.25) v2(313.92,153.34)
GNDA_CHG: length 5
  TOP w0.508: PC413.1 115.73,142.74 v2(116.18,143.18) 115.73,143.63 PR424.1 PC424.2 ; v2(111.04,140.01) 111.04,140.31 PC407.1 ; PC438.1 112.31,140.01 v2(111.67,140.01) ; PC409.2 v2(108.69,140.07)
  vias: v1(108.77,150.77) v2(110.27,146.04) v2(110.34,144.77) v2(110.84,145.41) v2(111.48,146.04) v2(111.48,144.77) v2(112.94,150.61) v2(112.94,150)
VCCSENSE: length 91
  TOP w0.102: RC250.2 100.34,28.08 v1(102.53,28.08) 102.74,28.08 102.78,28.12 104.05,28.12 104.24,27.93 107.8,27.93 108.35,27.38 v2(108.61,27.38)
  IN3 w0.102: v2(108.61,27.38) 104.71,27.38 101.87,24.54 101.87,22.51 98.02,18.66 88.18,18.66 86.27,16.76 84.62,16.76 82.78,14.91 76.24,14.91 74.43,16.72 66.24,16.72 64.74,18.22 59.22,18.22 53.76,23.68 49.38,23.68 48.49,22.79 43.6,22.79 v2(43.57,22.75)
  BOTTOM w0.102: UC1.E63 109.01,28.41 109.01,28.04 108.61,27.65 v2(108.61,27.38) ; v2(43.57,22.75) 43.61,22.71 43.61,19.35 44.3,18.66 PR334.1
VCCST_PWRGD: length 7.7
  BOTTOM w0.076: UC1.B59 107,31.31 106.67,30.98 106.16,30.98 104.88,29.7
  BOTTOM w0.102: 104.88,29.7 104.84,29.66 v1(101.6,29.66) 101.34,29.66 100.95,29.28 RC245.2
VDD_1.35V: length 6.6
  TOP w0.102: v1(173.23,76.7) 173.23,77 172.76,77.47 PC111.1
  TOP w0.203: 174.01,79.67 174.37,80.03 PU100.11
  TOP w0.508: PR102.2 174.2,77.59 PR101.1 ; PR102.2 173.83,79.49 174.01,79.67 ; PR102.2 173.82,77.97 PC111.1
VDDA18CR: length 2.3
  TOP w0.102: C3031.1 171.46,128.15 170.47,128.15 v1(170.41,128.21)
VDDA18PLL:
  vias: v1(174.07,116.01)
VSSSENSE: length 88.7
  TOP w0.102: v2(109.51,26.79) 110.15,26.79 v1(110.52,26.41) 111.67,25.26 RC260.1
  IN3 w0.102: v2(109.51,26.79) 104.62,26.79 102.22,24.39 102.22,22.36 98.17,18.3 88.33,18.3 85.83,15.8 84.94,15.8 83.67,14.53 76.11,14.53 74.28,16.36 66.09,16.36 64.62,17.83 59.1,17.83 54.02,22.91 50.14,22.91 49.57,22.34 43.15,22.34 v2(42.77,22.72)
  BOTTOM w0.102: UC1.E62 109.22,29.1 109.68,28.65 109.68,26.96 109.51,26.79 v2(109.51,26.79) ; PR335.1 44.55,17.77 43.25,19.07 43.25,22.24 v2(42.77,22.72)
3301_ACAV_IN_NB: length 2.7
  TOP w0.254: PR545.1 122.53,143.31 PU701.24
3301_DSCHRG_FET_GC: length 30.2
  TOP w0.102: v2(116.69,140.06) 116.83,140.2 PR559.2 ; PR510.2 138.34,145.33 v1(138.2,145.19)
  TOP w0.254: PR510.2 v2(138.34,147.06)
  IN2 w0.254: v2(116.69,140.06) 116.75,140.06 118.08,141.39 118.08,144.96 120.6,147.48 121.14,147.48 121.93,146.69 125.54,146.69 125.86,146.37 137.65,146.37 v2(138.34,147.06)
3301_PWRSRC: length 2.5
  TOP w0.254: PU701.15 v1(127.27,139.17) 127.63,139.17 128.19,138.61 PR558.1
+ALC290_LDO_CAP: length 4.1
  BOTTOM w0.102: v1(260.96,152.96) 261.38,152.54 C140.1
  BOTTOM w0.254: C140.1 261.36,151.46 U17.21
+ALC3226_CPVEE: length 4.5
  BOTTOM w0.127: C138.1 252.32,145.7 v1(251.95,145.33)
  BOTTOM w0.254: U17.34 253.68,148.7 252.32,147.34 C138.1
+ALC3226_VREF: length 5.3
  BOTTOM w0.127: v1(260.43,148.59) 260.26,148.43 C169.1
  BOTTOM w0.254: U17.25 258.18,148.88 258.36,148.71 258.86,148.71 259.18,148.39 259.18,147.32 C167.2
  BOTTOM w0.508: C167.2 260.08,147.2 C169.1
+AUX_LDO:
  vias: v1(7.11,24.08)
+BATT_SUM: length 1.9
  TOP w0.508: PR502.1 126.79,150.56 PQ501.3
  vias: v1(126.87,161.23)
+BL_PWR_SRC: length 22.5
  TOP w0.102: v3(84.78,155.93) 84.61,155.93 84.1,155.43 v5(84.1,155.4)
  IN2 w2.032: 94.21,138.55 90.78,141.98 90.78,155 89.05,156.73 87.77,156.73
  vias: v3(84.81,156.57) v3(85.47,156.58) v3(85.48,155.93) v3(94.59,136.9) v3(94.59,136.26) v3(94.59,135.63) v3(94.59,134.99)
+CAP_LDO: length 6.7
  TOP w0.305: v2(169.12,93.76) 168.98,93.62 U37.B46
  TOP w0.508: v2(168.21,90.35) 168.21,90.35 167.99,90.13 C336.1
  IN1 w0.508: v2(168.21,90.35) 168.35,90.35 169.12,91.12 v2(169.12,93.76)
  BOTTOM w0.102: v2(169.12,93.76) 169.12,94.58 v1(169.25,94.71)
+CHGR_DC_IN: length 23.4
  TOP w0.508: PR530.1 117.37,137.52 v2(116.56,136.71) ; PD400.1 103.79,144.42 PR420.1 103.79,142.09 v5(104.25,141.63) 104.62,141.27 v2(104.62,139.19)
  BOTTOM w0.508: v2(116.56,136.71) 115.42,136.71 113.07,139.06 109.07,139.06 108.62,138.61 105.19,138.61 v2(104.62,139.19)
+COINCELL: length 3.2
  BOTTOM w0.127: RTCR1.1 41.69,60.95 v1(42.1,60.54)
  BOTTOM w0.508: JBT1.1 40.27,60.33 40.89,60.95 RTCR1.1
+DC1_PWR_SRC: length 3.2
  TOP w0.203: PU51.12 192.78,142.66 193.14,142.29 193.14,141.53 PC68.1
  vias: v1(197.09,142.5) v2(195.87,144.2) v2(195.87,141.41) v2(196.51,144.2) v2(196.51,141.41) v2(197.14,144.2) v2(197.14,141.41) v2(197.78,144.2) v2(197.78,141.41) v2(198.41,143.44) v2(198.41,142.04) v2(198.41,141.41) v2(199.05,143.44) v2(199.05,142.04) v2(199.05,141.41)
+DC_IN: length 57.7
  TOP w0.127: v2(118.97,129.28) 118.59,129.66 118.59,129.87 v5(118.62,129.9)
  TOP w0.508: v2(118.97,129.28) PC5.1 ; PC5.1 120.02,130.56 PR14.1 119.23,130.67 118.97,130.93 PR533.1 ; PC5.1 120.02,127.91 120.4,127.53 PQ5.3 ; v2(103.8,126.83) 104.01,126.61 104.29,126.61 PR445.1
  IN1 w0.508: v2(95.73,154.74) 95.73,153.47 94.91,152.65 94.91,150.42 97.45,147.88 97.45,144.96 98.49,143.91 98.49,137.94 100.3,136.14 100.3,131.3 103.8,127.8 v2(103.8,126.83)
  IN3 w0.508: v2(103.8,126.83) 104.01,126.61 104.99,126.61 105.62,125.98 115.67,125.98 v2(118.97,129.28)
  vias: v3(91.6,159.25) v3(91.6,158.61) v3(91.6,157.98) v3(91.6,157.34) v5(95.12,157.65) v5(96.25,156.09)
+DC_IN_SS: length 51.4
  TOP w0.457: PR529.1 117.22,138.42 v2(116.79,138.85)
  TOP w0.508: PD400.3 100.8,147.68 v2(100.49,147.37) ; PR544.2 135.68,128.91 135.26,129.33 PQ520.3 135.26,132.4 135.75,132.89 135.75,134.38 135.08,135.05 v2(134.86,135.05)
  IN3 w0.508: v2(100.49,147.37) 100.49,144.58 103.92,141.15 112.69,141.15 114.78,139.06 116.59,139.06 v2(116.79,138.85)
  BOTTOM w0.508: v2(116.79,138.85) 121.08,138.85 123.54,136.39 128.05,136.39 128.56,135.88 128.56,135.18 129.07,134.67 134.48,134.67 v2(134.86,135.05)
  vias: v5(98.54,147.55)
+DCIN:
  vias: v1(107.99,142.62)
+DCIN_JACK:
  vias: v5(85.88,157) v5(87.13,158.26) v5(89.88,160.57)
+DCPRRTC: length 2.4
  TOP w0.254: CC36.1 120.8,62.17 120.49,62.47 v1(120.49,63.23) 120.27,63.46 v2(120.02,63.46)
  BOTTOM w0.254: v2(120.02,63.46) 120.19,63.28 UC1.AE7
+DIMM1_VREF_DQ: length 5.9
  TOP w0.508: CD2.1 CD1.1 172.32,7.95 RD1.2 172.83,7.94 173.14,7.64 v1(173.62,7.64) 173.86,7.64 174.22,7.99 v2(174.22,8.44)
  BOTTOM w0.356: v2(174.22,8.44) 174.3,8.35 JDIMM1.1
+DIMM2_VREF_DQ: length 6.4
  TOP w0.102: v2(164.31,7.67) 164.31,6.99 v1(164.22,6.9)
  TOP w0.508: CD32.1 CD33.1 RD7.2 164.11,7.88 v2(164.31,7.67)
  BOTTOM w0.356: JDIMM2.1 163.63,8.35 v2(164.31,7.67)
+DOCK_PWR_BAR: length 59.2
  TOP w0.457: v2(115.99,140.3) 115.99,139.88 116.4,139.47 117.21,139.47 PR531.2
  TOP w0.508: PD400.2 v2(102.1,147.71)
  IN3 w0.508: v2(102.1,147.71) 102.1,144.46 104.39,142.17 114.12,142.17 v2(115.99,140.3)
  BOTTOM w0.508: v2(115.99,140.3) 115.99,140.89 116.44,141.34 117.15,141.34 117.56,141.75 117.56,142.89 118.58,143.91 120.35,143.91 121.58,145.13 121.58,148.41 127.29,154.13 127.29,163.44 128.31,164.46 129.51,164.46 130.28,163.69 133.01,163.69 133.67,164.35 CE7.1
  vias: v1(137.48,169.32) v2(139.34,169.93) v2(139.34,169.29) v2(139.34,168.66) v2(139.34,168.02) v2(139.34,167.39) v2(139.34,166.75) v2(140.1,169.93) v2(140.1,169.29) v2(140.1,168.66) v2(140.1,168.02) v2(140.1,167.39) v2(140.1,166.75)
+FB_PLLAVDD: length 4
  TOP w0.102: LV76.1 v1(76.39,87.08)
  TOP w0.508: CV228.1 56.16,84.4 v4(55.71,84.85)
  BOTTOM w0.2: v4(55.71,84.85) UV1.P22
  BOTTOM w0.3: v2(59.9,90.71) 60.3,91.11 UV1.F16 ; v4(55.74,89.81) 55.67,89.74 55.64,89.74 55.31,89.41 UV1.H22
  vias: v2(73.51,89.27) v2(73.51,88.64)
+GPU_CORE: length 1
  TOP w0.508: RZ40.1 59.02,69.79 v2(59.03,69.78)
  vias: v2(50.14,69.78) v2(50.14,68.63) v2(50.46,69.21) v2(50.77,69.78) v2(50.77,68.63) v2(51.09,69.21) v2(51.41,69.78) v2(51.41,68.63) v2(51.73,69.21) v2(52.04,69.78) v2(52.04,68.63) v2(52.36,69.21) v2(52.68,69.78) v2(52.68,68.63) v2(53,69.21) v2(53.31,69.78) v2(53.31,68.63) v2(53.63,69.21) v2(53.95,69.78) v2(53.95,68.63) v2(54.27,69.21) v2(54.58,69.78) v2(54.58,68.63) v2(54.9,69.21) v2(55.22,69.78) v2(55.22,68.63) v2(55.54,69.21) v2(55.85,69.78) v2(55.85,68.63) v2(56.17,69.21) v2(56.49,69.78) v2(56.49,68.63) v2(56.81,69.21) v2(57.12,69.78) v2(57.12,68.63) v2(57.44,69.21) v2(57.76,69.78) v2(57.76,68.63) v2(58.08,69.21) v2(58.39,69.78) v2(58.39,68.63) v2(58.71,69.21) v2(59.03,68.63) v2(59.35,69.21) v2(59.47,85.97) v2(59.66,69.78) v2(59.66,68.63) v2(59.98,69.21) v2(60.3,69.78) v2(60.3,68.63) v2(60.43,86.99) v2(60.62,69.21) v2(60.93,69.78) v2(60.93,68.63) v2(61.25,69.21) v2(61.51,85.97) v2(61.57,69.78) v2(61.57,68.63) v2(61.89,69.21) v2(62.2,69.78) v2(62.2,68.63) v2(62.52,86.92) v2(62.52,69.21) v2(62.84,69.78) v2(62.84,68.63) v2(63.16,69.21) v2(63.47,69.78) v2(63.47,68.63) v2(63.79,69.21) v2(64.11,68.63) v2(66.78,86.61) v4(58.46,86.83) v4(58.46,84.98) v4(58.46,80.15) v4(59.47,82.95) v4(59.6,80.95) v4(60.46,84.98) v4(60.47,82.95) v4(60.59,80.95) v4(61.39,87.88) v4(61.44,82.99) v4(61.48,88.78) v4(62.44,82.94) v4(62.37,80.94) v4(62.51,84.98) v4(63.48,80.17) v4(64.46,86.78) v4(64.46,84.95) v4(64.46,83.05) v4(64.49,81.97) v4(65.59,82) v5(67.13,82.6)
+LCDVDD: length 22.4
  IN3 w2.032: 91.79,102.04 90.72,103.12 90.72,110.42 88.11,113.02 88.11,116.51 92.18,120.58 92.81,120.58
  vias: v2(93.06,101.08) v2(93.06,100.45) v2(93.7,101.08) v2(93.7,100.45) v2(94.21,121.06) v2(94.21,120.45) v2(94.84,121.09) v2(94.84,120.48) v5(93.19,101.63)
+LOM_VCT: length 1.1
  TOP w0.102: C316.1 179.16,171.57 v1(179.37,171.78)
  vias: v2(178.05,170.29) v2(178.43,170.73)
+NBDOCK_DC_IN_SS: length 70.2
  TOP w0.102: v2(157.45,162.64) v1(157.45,161.12)
  TOP w0.508: PQ500.1 134.45,141.26 v2(133.64,140.45) ; PR528.2 131.49,130.14 PQ517.3 130.4,129.55 v2(130.4,129.3) ; PQ522.1 129.09,143.91 v2(129.68,144.49)
  IN2 w0.508: v2(157.45,162.64) 157.45,161.02 156.67,160.24 147.97,160.24 146.91,159.19 146.91,153.09 145.2,151.38 143.61,151.38 142.21,149.98 142.21,143.82 141.32,142.93 137.64,142.93 135.17,140.45 v2(133.64,140.45) 133.64,142.1 131.26,144.49 v2(129.68,144.49)
  IN3 w0.508: v2(133.64,140.45) 132.61,140.45 129.77,137.61 129.77,136.14 130.4,135.5 v2(130.4,129.3)
  BOTTOM w0.254: JDOCK1.41 v2(157.45,162.64)
+PBATT: length 44.9
  TOP w0.457: v2(116.67,140.66) 117.09,141.09 PR534.2
  TOP w0.508: PR565.1 153.69,134.74 PQ526.3 151.74,134.74 v2(151.34,134.34)
  IN2 w0.457: 117.34,142.63 117.34,141.34 v2(116.67,140.66)
  IN2 w0.508: 117.34,142.63 117.29,142.68 117.29,150.27 120.05,153.03 v2(120.56,153.03) ; v2(151.34,134.34) 151.34,140.09 150.55,140.88 150.55,144.03 149.05,145.53 149.05,148.97 148.72,149.31 v2(148.23,149.31)
  BOTTOM w0.508: v2(138.66,148.71) 142.16,148.71 142.54,149.09 145.11,149.09 145.41,149.39 146.67,149.39 146.76,149.31 v2(148.23,149.31)
  vias: v1(116.9,167.35) v2(138.02,151.88) v2(138.02,151.25) v2(138.02,150.61) v2(138.02,149.98) v2(138.02,149.34) v2(138.02,148.71) v2(138.66,151.88) v2(138.66,151.25) v2(138.66,150.61) v2(138.66,149.98) v2(138.66,149.34) v3(115.61,170.74) v3(115.61,169.98) v3(115.61,169.22) v3(115.61,168.46) v3(116.31,170.74) v3(116.31,169.98) v3(116.31,169.22) v3(116.31,168.46) v3(117,170.74) v3(117,169.98) v3(117,169.22) v3(117,168.46)
+PBATT_IN_SS:
  vias: v1(134.9,147.41)
+PCH_ASATA3PLL: length 8.3
  BOTTOM w0.127: v1(98.07,61.18) 97.76,61.48 CC77.1
  BOTTOM w0.203: 106.99,60.99 107.18,60.81 UC1.B11
  BOTTOM w0.381: RC19.2 102.08,63.06 102.35,62.79 104.41,62.79 105.89,61.31 106.72,61.31 106.99,61.03 106.99,60.99
+PCH_AUSB3PLL: length 22.5
  TOP w0.508: v2(103.65,56.52) 104.62,55.56 104.62,52.82 104.22,52.42 v1(101.22,52.42) 100.34,52.42 99.53,51.6 RC163.1 RC161.1
  BOTTOM w0.254: UC1.B18 106.81,56.34 106.68,56.21 105.88,56.21 105.57,56.52
  BOTTOM w0.508: 105.57,56.52 v2(103.65,56.52) 102.91,57.27 99.99,57.27 99.44,57.81 CC42.1 CC76.1 96.39,57.81 LC1.2
+PCH_DCPSUS: length 34.9
  TOP w0.254: v2(122.33,59.53) 122.28,59.48 120.59,59.48 CC66.1 ; 110.92,59.94 107.92,59.94 107.92,59.43 108.37,58.98 110.98,58.98 v2(111.43,59.43) 110.92,59.94
  TOP w0.508: 107.92,59.94 106.78,61.08 103.54,61.08 102.51,62.11 v1(101.29,62.11) CC61.1 CC62.1 RC276.2
  IN2 w0.508: v2(122.33,59.53) 121.35,59.53 120.69,60.19 119.42,60.19 118.91,59.68 118.91,58.79 118.34,58.22 114.27,58.22 113.38,59.11 111.75,59.11 v2(111.43,59.43)
  BOTTOM w0.254: v2(122.33,59.53) 122.01,59.85 UC1.AH13 ; UC1.J13 111.76,59.76 v2(111.43,59.43)
+PCH_DCPSUS1: length 1.4
  BOTTOM w0.254: UC1.AD10 UC1.AD8 119.5,62.63 119.49,62.63 119.25,62.63 v2(119.06,62.82)
  vias: v1(118.64,65.1)
+PCH_DCPSUS4: length 30.2
  TOP w0.508: v2(118.11,62.8) 118.17,62.75 118.17,62.74 118.39,62.52 CC53.1 ; v2(94.21,68.38) v1(94.64,67.95) 94.97,67.62 94.97,66.67 94.59,66.29 94.33,66.29 CC75.1 94.33,65.78 95.1,65.78 95.69,65.18 LC4.2
  IN2 w0.508: v2(118.11,62.8) 118.11,62.45 117.83,62.17 112.6,62.17 112.57,62.2 ; 108.05,62.35 107.42,62.98 99.65,62.98 97.48,65.14 97.48,65.55 94.65,68.38 v2(94.21,68.38)
  BOTTOM w0.254: v2(118.11,62.8) 118.29,62.63 UC1.AB8
+PCH_RTC_VCCSUS3_3: length 19.8
  TOP w0.508: RC264.2 RC261.2 CC30.1 v1(135.1,60.27) 134.94,60.27 134.47,59.8 v2(134.47,59.43)
  IN2 w0.254: v2(122.32,60.33) 122.66,60 122.66,59.88 123.1,59.44
  IN2 w0.508: 123.1,59.44 123.18,59.36 126.94,59.36 127.13,59.55 127.86,59.55 128.31,59.11 129.65,59.11 130.12,59.58 130.66,59.58 132.26,61.18 133.53,61.18 134.47,60.24 v2(134.47,59.43)
  BOTTOM w0.254: v2(122.32,60.33) 122.32,60.44 UC1.AH11
+PCH_VCC1P05: length 12.4
  IN2 w0.508: v2(104.69,57.2) 104.69,56.3 106.45,54.54 111.23,54.54 112.07,55.38 112.07,56.24 111.71,56.6 111.46,56.6 v2(111.43,56.57)
  BOTTOM w0.254: UC1.J18 111.76,56.97 111.43,56.64 v2(111.43,56.57) 111.51,56.49 112.21,56.49 UC1.K19
  vias: v1(101.09,59.53)
+PCH_VCCACLKPLL: length 3.9
  BOTTOM w0.254: UC1.A20 105.63,55.69
  BOTTOM w0.381: 105.63,55.69 105.35,55.97 103.28,55.97 v2(102.89,56.35)
  vias: v1(101.38,54.94)
+PCH_VCCDSW: length 17.4
  TOP w0.241: v2(121.7,56.28) 122.09,55.89 122.59,55.89 122.93,55.55 126.84,55.55 127.36,55.02 129.95,55.02
  TOP w0.508: 129.95,55.02 130.17,55.24 v1(133.83,55.24) 135.32,55.24 135.41,55.32 C413.2 RC275.2
  BOTTOM w0.254: UC1.AG19 121.33,56.65 v2(121.7,56.28) 121.33,55.91 UC1.AG20
+PCH_VCCDSW3_3: length 94.1
  TOP w0.254: 133.63,73.55 133.63,73.35 133.48,73.2 RP12.7 ; 133.63,73.55 133.78,73.7 134.02,73.7 RC206.2 ; 133.63,73.55 133.48,73.7 RP12.8
  TOP w0.305: JAPS1.3 153.19,66.3 153.21,66.28 ; JAPS1.7 155.19,66.43 155.03,66.28 ; RC197.2 134.29,69.08 v2(135.04,69.08)
  TOP w0.381: RC206.2 134.4,73.97 135.03,73.34 v2(135.03,73.21)
  TOP w0.508: v2(130.09,78.35) 129.92,78.35 128.24,80.03 RC265.2 ; v2(144.18,67.48) 144.5,67.16 144.5,57.2 142.62,55.32 C413.1 ; RC265.2 RC267.2 ; RC265.2 CC32.1 ; v2(146.15,67.59) 147.05,66.69 v1(148.5,66.69) 151.21,66.69 151.62,66.28 155.03,66.28
  IN2 w0.381: v2(122.39,62.1) 122.39,61.65 122.7,61.34 128.32,61.34
  IN2 w0.508: 136.63,67.3 139.23,67.3 139.67,66.86 143.56,66.86 v2(144.18,67.48) 144.41,67.25 145.8,67.25 v2(146.15,67.59) ; 136.63,67.3 136.63,65.4 135.07,63.84 132.02,63.84 130.02,61.84 128.82,61.84 128.32,61.34 ; 136.63,67.3 135.93,68 135.93,68.57 135.42,69.08 v2(135.04,69.08) ; v2(135.03,73.21) 135.23,73.4 135.23,76.25 135.67,76.7 v2(135.8,76.7)
  IN3 w0.381: v2(135.04,69.08) 134.28,69.84 134.28,72.45 v2(135.03,73.21)
  IN3 w0.508: v2(135.8,76.7) 135.72,76.62 135.43,76.62 135.33,76.52 134.76,76.52 133.95,77.33 131.14,77.33 130.12,78.35 v2(130.09,78.35)
  BOTTOM w0.254: v2(122.39,62.1) 122.39,61.83 122.12,61.56 UC1.AH10 ; RP13.8 128.93,72.13 129.77,72.97 129.77,78.03 v2(130.09,78.35)
+PCH_VCCDSW_R: length 2.4
  TOP w0.102: RC275.1 138.34,56.29 v1(138.39,56.34)
  TOP w0.508: CC65.1 137.31,56.31 RC275.1
+PECI_VREF: length 6.4
  TOP w0.279: 140.26,108.96 140.75,108.96 141.14,108.56 U38.B51
  TOP w0.508: 140.26,108.96 138.61,110.61 138.26,110.61 v1(138.25,110.6) 138.24,110.61 137.58,110.61 137.39,110.42 C360.1 136.71,110.43 R374.1
+PNVVDD: length 39.3
  TOP w0.127: v2(49.44,62.03) v5(49.44,62.91)
  IN1 w0.254: v2(49.44,62.03) 48.42,61.01 48.42,55.11 47.85,54.54 47.85,47.81 47.48,47.44 47.48,34.93 51.15,31.26 v2(51.15,26.6)
  BOTTOM w0.254: v2(51.15,26.6) PR620.1
+PWR_SRC: length 34.8
  IN3 w1.524: 171.93,79.54 173.45,81.06 173.45,82.72 174.29,83.56 178.03,83.56 179.68,85.21 180.18,85.21 181.67,86.71 185.55,86.71 188.19,84.07 189.01,84.07
  BOTTOM w2.54: 193.78,112.26 193.78,102.1 192,100.32
  vias: v2(43.85,25.71) v2(44.49,25.71) v2(45.12,25.71) v2(45.76,25.71) v2(59.92,31.49) v2(59.92,30.85) v2(60.55,31.49) v2(60.55,30.85) v2(61.19,31.49) v2(61.19,30.85) v2(61.82,31.49) v2(61.82,30.85) v2(67.89,34.98) v2(67.89,34.34) v2(68.53,34.98) v2(68.53,34.34) v2(69.16,34.98) v2(69.16,34.34) v2(69.77,35.02) v2(69.77,34.38) v2(75.48,58.79) v2(75.48,58.16) v2(75.48,57.52) v2(76.11,58.79) v2(76.11,58.16) v2(76.11,57.52) v2(76.75,58.79) v2(76.75,58.16) v2(76.75,57.52) v2(77.38,58.79) v2(77.38,58.16) v2(77.38,57.52) v2(114.91,164.77) v2(114.91,164.08) v2(114.91,163.38) v2(115.54,164.77) v2(115.54,164.07) v2(115.54,163.38) v2(116.18,164.77) v2(116.18,164.07) v2(116.5,165.47) v2(116.81,164.77) v2(116.81,164.07) v2(117.13,165.47) v2(117.45,164.77) v2(117.45,164.07) v2(117.77,165.47) v2(118.08,164.77) v2(118.08,164.07) v2(118.4,165.47) v2(118.72,164.77) v2(118.72,164.07) v2(162.88,77.95) v2(162.91,77.22) v2(163.36,77.61) v3(190.12,83.49) v3(190.5,82.92) v3(190.88,83.49) v5(119.34,157.89)
+PWR_SRC_AC: length 27.7
  TOP w0.508: v2(129.92,139.2) 129.92,139 129.53,138.61 PR558.2
  IN3 w0.508: v2(129.92,139.2) 132.38,141.66 134.72,141.66 139.99,146.93 139.99,158.49 v2(138.78,159.69)
  vias: v1(96.09,159) v2(97.19,159.57) v2(97.19,158.93) v2(97.19,158.3) v2(97.19,157.66) v2(97.19,157.03) v2(97.95,159.57) v2(97.95,158.93) v2(98.59,159.57) v2(98.59,158.93) v2(99.22,159.57) v2(99.22,158.93) v2(99.99,159.57) v2(99.99,158.93) v2(99.99,158.3) v2(99.99,157.66) v2(99.99,157.03) v2(100.62,158.93) v2(100.62,158.3) v2(100.62,157.66) v2(100.62,157.03) v2(101.22,158.31) v2(136.88,161.6) v2(136.88,160.96) v2(136.88,160.33) v2(136.88,159.69) v2(137.51,161.6) v2(137.51,160.96) v2(137.51,160.33) v2(137.51,159.69) v2(138.15,161.61) v2(138.15,160.98) v2(138.15,160.34) v2(138.15,159.71) v2(138.78,161.6) v2(138.78,160.96) v2(138.78,160.33)
+RSVD_VCC3P3_1: length 6.6
  TOP w0.203: U21.1 176.5,135.19 176.36,135.06 v2(175.82,135.06)
  TOP w0.508: R178.2 173.51,132.52 v2(172.82,132.52)
  BOTTOM w0.508: v2(172.82,132.52) 173.27,132.52 v1(174.34,133.6) 174.34,134.48 174.92,135.06 v2(175.82,135.06)
+RTC_CELL: length 321.1
  TOP w0.381: CC39.1 132.57,65.56 v2(132.12,66.02) 132.63,66.52 RC7.1
  TOP w0.508: R332.1 133.37,102.28 v2(133.64,102.54)
  IN2 w0.508: v2(132.12,66.02) 132.12,67.68 v2(132.05,67.75) 134.85,70.54 v2(134.91,70.54) 134.91,70.41 135.36,69.97 140.41,69.97 142.16,71.72 148.4,71.72 148.82,71.3 148.82,71.24 ; v2(148.82,70.86) 148.82,71.24 ; 148.82,71.24 149.3,71.72 153.02,71.72 157.35,76.05 157.35,80.3 158.19,81.14 158.19,82.87 157.35,83.71 156.15,83.71 v2(155.74,84.12) 155.74,85 156.63,85.89 157.62,85.89 158.24,86.51 161.12,86.51 161.46,86.17 163.42,86.17 163.69,85.91 164.75,85.91 165.41,85.26 172.03,85.26 175.14,88.37 175.86,88.37 178.71,91.23 178.71,91.89 179.86,93.03 179.86,94.35 183.87,98.36 183.87,102.04 185.37,103.53 v2(185.37,105.24) ; v2(91.7,66.79) 92.33,66.16 95.22,66.16 98.21,63.17 98.21,63.17 99.23,62.16 102.34,62.16 103.35,61.14 106.95,61.14 107.83,60.25 108.05,60.25 ; 112.31,60.25 112.72,59.84 113.54,59.84 113.77,60.06 115.29,60.06 115.58,59.78 117.04,59.78 119.35,62.09 v2(121.69,62.09) ; v2(42.52,61.14) 43.28,60.38 45.66,60.38 48.92,63.64 70.36,63.64 72.49,65.78 75.28,65.78 76.49,66.98 v2(78.71,66.98)
  IN3 w0.254: v2(121.69,62.09) 121.69,61.84 122.07,61.46 127.61,61.46 128.5,62.35
  IN3 w0.508: v2(245.97,150.17) 245.21,150.17 241.34,146.3 237.34,146.3 215.11,124.07 209.02,124.07 204.7,119.75 198.23,119.75 193.97,115.49 193.97,115.49 192.63,114.15 192.63,110.67 v2(191.43,109.47) ; v2(132.12,66.02) 132.12,64.7 129.77,62.35 128.5,62.35 ; v2(91.7,66.79) 88.26,66.79 87.71,67.34 86.02,67.34 85.66,66.98 v2(78.71,66.98)
  BOTTOM w0.254: v2(121.69,62.09) 121.33,61.73 UC1.AG10
  BOTTOM w0.381: v2(134.91,70.54) 134.91,71.68 135.67,72.44 RC73.2 ; RC1.1 132.44,67.36 v2(132.05,67.75)
  BOTTOM w0.508: v2(191.43,109.47) 188,106.04 187.1,106.04 186.31,105.24 v2(185.37,105.24) ; 136.56,94.29 136.12,94.73 136.12,98.1 133.64,100.58 v2(133.64,102.54) ; 136.56,94.29 137.64,94.29 v2(137.9,94.03) ; 136.56,94.29 135.99,93.72 135.99,91.41 138.44,88.97 147.59,88.97 151.03,85.53 151.43,85.53 151.82,85.14 155.04,85.14 155.74,84.45 v2(155.74,84.12) ; RC6.1 RC8.1 146.71,74.34 147.04,74.67 148.18,74.67 148.44,74.41 148.44,72.57 148.82,72.19 v2(148.82,70.86) ; RC1.1 132.74,68.33 CC38.1 CC35.1 ; v2(42.52,61.14) 43.15,61.78 C50.1 42.24,63.55 RTCD1.1 ; R208.1 245.52,150.63 v2(245.97,150.17)
  vias: v5(138.12,93.44)
+RTC_CELL_VBAT: length 13.1
  TOP w0.305: v2(141.89,101.34) 141.89,101.51 141.58,101.81 U38.B64
  TOP w0.508: v2(135.04,101.91) 134.35,101.91 R332.2 C345.1
  BOTTOM w0.254: v2(135.04,101.91) v1(135.91,101.91) 137.01,101.91 138.12,103.03 139.89,103.03 140.09,102.82 142.32,102.82 142.53,102.61 142.53,101.78 142.09,101.34 v2(141.89,101.34)
+SDC_IN: length 54.6
  TOP w0.406: 117.37,132.28 PU401.3
  TOP w0.508: PC406.1 116.75,132.9 v2(116.37,132.9) ; PR421.1 115.49,141.42 114.97,140.9 113.84,140.9 PR422.1 113.58,140.63 113.58,137.47 v2(112.81,136.71) ; PR542.1 124.79,132.08 v2(124.79,131.89)
  IN1 w0.508: v2(99.48,151.82) 99.86,151.44 99.86,146.36 104.05,142.17 104.05,140.68 105.36,139.37 105.36,137.53 106.18,136.71 v2(112.81,136.71)
  IN3 w0.508: v2(124.79,131.89) 122.53,134.15 122.53,134.8 122.03,135.3 115.49,135.3 114.08,136.71 v2(112.81,136.71)
  BOTTOM w0.508: v2(116.37,132.9) 116.37,133.15 v2(112.81,136.71)
  vias: v1(100.7,153.58)
+SIM_PWR: length 42.5
  TOP w0.508: v2(223.07,133.85) 223.07,135.26 228.36,140.54 228.36,143.49 234.11,149.24 v1(234.11,150.67) 234.11,152.81 231.24,155.68 C263.1 231.65,155.91 v2(233.45,157.71) 233.12,158.04 U28.5
  BOTTOM w0.508: v2(233.45,157.71) 233.45,157.26 233.79,156.92 235.24,156.92 235.69,157.38 JSIM1.9 ; JMINI2.8 219.59,131.82 222.22,131.82 223.07,132.67 v2(223.07,133.85)
+SM_VREF_CA: length 40.4
  TOP w0.508: v2(125.7,37.02) 126.59,37.02 128.18,35.42 131.23,35.42 133.58,33.07 v1(137.07,33.07) 141.2,33.07 149.78,24.49 CC67.1 RC68.2
  BOTTOM w0.254: UC1.AP49 125.7,37.16 v2(125.7,37.02)
+SM_VREF_CA_DIMM: length 51.7
  TOP w0.508: RD12.2 182.23,49.91 181.52,49.2 177.31,49.2 176.92,48.82 175.11,48.82 174.95,48.67 v2(174.14,48.67) 174.14,49.44 174.4,49.7 174.4,49.71 174.6,49.89 RD13.2 ; v2(173.27,24.38) 172.77,24.87 171.74,24.87 171.25,24.38 v1(170.33,24.38) 164.05,24.38 RC67.2 161.29,25.4 RC68.1 RC69.1
  IN2 w0.508: v2(173.27,24.38) 173.27,26.85 173.52,27.11 173.52,31.68 174.98,33.14 174.98,47.83 v2(174.14,48.67)
+SM_VREF_CA_DIMMA: length 5.3
  TOP w0.102: v1(186.26,48.98) 185.79,48.5 v2(185.27,48.5)
  TOP w0.508: RD12.1 CD12.1 CD13.1 184.77,49 v2(185.27,48.5)
  BOTTOM w0.356: v2(185.27,48.5) 185.02,48.25 JDIMM1.126
+SM_VREF_CA_DIMMB: length 9.1
  TOP w0.508: CD43.1 CD44.1 175.93,50.8 RD13.1 174.01,50.8 173.18,49.97 v1(173.18,49.48) v2(173.18,48.69)
  BOTTOM w0.356: JDIMM2.126 172.18,48.25 172.37,48.06 172.88,48.06 173.18,48.36 v2(173.18,48.69)
+SM_VREF_DQ0: length 44.9
  TOP w0.508: CC70.1 RC173.2 158.98,13.86 v1(144.17,28.67) v2(141.75,31.08)
  IN2 w0.508: v2(141.75,31.08) 136.46,31.08 132.05,35.49 130.21,35.49 129.63,36.06 v2(126.38,36.06)
  BOTTOM w0.254: UC1.AR51 126.38,36.13 v2(126.38,36.06)
+SM_VREF_DQ0_DIMM1: length 21.9
  TOP w0.508: RD1.1 171.56,7.03 168.88,9.71 165.9,9.71 165.01,10.6 162.47,10.6 161.84,9.96 161.84,9.07 161,8.23 v1(160.51,8.23) 158.61,8.23 157.96,8.88 RC217.2 RC173.1 RC221.1
+SM_VREF_DQ1: length 46.7
  TOP w0.508: RC126.2 CC69.1 154.04,9.5 152.32,11.22 152.32,19.08 142.01,29.39 v1(138.47,29.39) 134.53,29.39 130.66,33.26 129.33,33.26 128.25,34.34 127.06,34.34 125.73,35.67 v2(125.73,36.06)
  BOTTOM w0.254: v2(125.73,36.06) 125.4,36.39 UC1.AP51
+SM_VREF_DQ1_DIMM2: length 10.9
  TOP w0.508: RC126.1 RC132.1 RC130.2 157.01,8.31 158.36,6.96 v1(159.12,6.96) RD7.1
+SWR_LX:
  vias: v1(107.47,112.3)
+SWR_V12: length 2.6
  TOP w0.203: U52.43 98.35,112.57 v2(98.27,112.64)
  TOP w0.508: C435.1 96.19,109.33 v2(96.18,109.34)
  vias: v1(109.59,110.28) v2(106.74,107.41) v2(107.61,110.99) v2(107.61,110.35)
+V_DDR_REF: length 5.2
  TOP w0.127: PC112.1 175.42,85.5 175.91,85.98 175.91,87.33 v5(175.27,87.96)
  TOP w0.203: PC112.1 175.42,85.03 174.77,84.38 PU100.4
+VCHGR: length 0.9
  TOP w0.127: 115.84,158.82 v5(114.99,158.82)
+VHDMI_VCC:
  vias: v5(13.08,100.46)
+VLDOIN_1.35V: length 4.2
  TOP w0.102: v1(181.71,83.99) 181.46,84.24 178.69,84.24 178.52,84.08 PJP101.1
+VR_CAP: length 9.8
  TOP w0.305: v2(147.29,100.7) 147.1,100.7 146.64,100.25 U38.B12
  TOP w0.508: C366.1 144.5,95.88 v2(144.31,96.07)
  IN2 w0.508: v2(144.31,96.07) 144.31,98 145.11,98.8 145.84,98.8 146.68,99.64 146.68,100.28 147.1,100.7 v2(147.29,100.7)
  BOTTOM w0.102: v2(144.31,96.07) v1(144.31,96.74)
+VREFC_UV5: length 25.7
  TOP w0.102: RV2709.2 33.39,99.55 32.96,99.98 v1(32.42,99.98)
  TOP w0.254: v2(33.5,88) 33.5,88.02 33.26,88.26 33.26,88.91 UV5.M8
  TOP w0.508: v2(33.37,96.96) 33.37,97.6 CV2902.1
  IN1 w0.508: v2(33.37,96.96) 33.37,95.39 v2(32.48,94.5) 32.48,93.89 31.99,93.4 26.83,93.4 25.83,92.4 25.83,91.1 27.28,89.65 32.56,89.65 33.5,88.71 v2(33.5,88)
  BOTTOM w0.254: v2(32.48,94.5) 32.86,94.13 UV4.M8
+VREFC_UV7: length 26.5
  TOP w0.102: RV2713.2 32.75,68.06 v1(31.77,67.09)
  TOP w0.254: UV7.M8 33.27,73.16 33.27,72.32
  TOP w0.508: RV2713.2 RV2714.1 CV2942.1 32.73,70.03 32.73,70.97 33.27,71.52 v2(33.27,71.68) 33.27,72.32
  IN1 w0.508: v2(33.27,71.68) 28.42,71.68 25.87,74.24 25.87,76.75 26.64,77.52 31.29,77.52 32.5,78.73 v2(32.5,78.75)
  BOTTOM w0.254: UV6.M8 32.87,78.38 v2(32.5,78.75)
+VREFD_UV5: length 29.1
  TOP w0.102: v1(36.41,99.74) 36.22,99.55 RV2711.2
  IN2 w0.102: v2(35.02,96.51) 35.02,96.51
  IN2 w0.508: 35.02,96.51 35.02,97.66 34.45,98.23 28.99,98.23 25.56,94.8 25.56,91.11 26.71,89.97 32.55,89.97 34.47,88.05 v3(35.68,88.05)
  BOTTOM w0.254: UV4.H1 36.06,88.43 v3(35.68,88.05)
+VREFD_UV7: length 35.6
  IN2 w0.508: v3(35.79,70.79) 35.79,69.65 35.09,68.95 28.36,68.95 27.53,69.78 27.53,72.13 26.96,72.7 25.69,72.7 24.29,74.1 24.29,76.13 24.99,76.83 24.99,79.24 26.07,80.32 32.49,80.32 33.03,79.77 v2(35.99,79.77)
  BOTTOM w0.254: v3(35.79,70.79) 35.79,72.48 UV6.H1
  vias: v1(34.77,83.62)
+VREFOUT: length 18
  IN2 w0.508: v2(257.82,145.65) 257.82,146.14 258.16,146.49 261.91,146.49 262.48,147.06 v2(262.48,148.26) 262.48,148.58 261.97,149.09 260.39,149.09 259.69,149.79 259.69,150.31 v2(259.84,150.46)
  BOTTOM w0.102: v1(261.09,144.82) 261.53,145.26 C131.1
  BOTTOM w0.254: U17.23 v2(259.84,150.46)
  BOTTOM w0.381: v2(257.82,145.65) 257.53,145.65 257.28,145.9 R187.2
  BOTTOM w0.508: C131.1 262.1,145.98 262.48,146.36 v2(262.48,148.26) ; R187.2 R197.2
-DCIN_JACK:
  vias: v2(85.89,164.65) v2(86.33,164.2) v2(86.46,165.15) v2(86.78,163.76) v2(86.91,164.71) v2(87.03,165.66) v2(87.22,163.31) v2(87.35,164.27) v2(87.54,166.23) v2(87.48,165.22) v2(87.79,163.82) v2(87.92,164.77) v2(87.98,165.79) v2(88.43,165.35) v2(88.37,164.33) v2(88.87,164.9) v5(88.75,167.03)
A_DE_0B: length 2.2
  TOP w0.102: U83.16 v1(299.7,172.94) 299.7,173.6 R2636.2
A_DE_1B: length 2.7
  TOP w0.102: U83.18 298.7,172.49 v1(298.27,172.91) 297.73,173.46 297.66,173.46 R2637.2
A_EQ_0B: length 3
  TOP w0.102: R2638.1 R2634.2 299.05,173.03 299.2,172.88 U83.17
A_EQ_1B: length 2.3
  TOP w0.102: R2635.2 300.2,173.21 U83.15
A_ON: length 266.8
  TOP w0.102: U38.B24 149.03,102.81 v2(148.4,102.19) ; RP18.6 152.84,104.64 v2(152.7,104.78) ; v2(86.91,24.95) 86.91,25.97 R424.1 ; v2(157.75,71.18) 157.34,70.78 v1(156.87,70.78) 155.84,70.78 155.49,71.14 155.49,71.78 154.85,72.42 153.65,72.42 152.25,73.83 PR154.1
  IN1 w0.097: v2(86.91,24.95) 86.03,24.07 86.03,22.29 84.17,20.44 84.17,17.26 82.31,15.39 71.95,15.39 70.65,16.69 53.76,16.69 49.38,21.07 35.22,21.07 30.77,25.52 30.77,30.6 v2(31.28,31.11)
  IN2 w0.102: v2(161.26,85.21) 161.26,81.78 159.56,80.08 159.56,76.33 158.82,75.59 158.82,72.26 v2(157.75,71.18) 156.9,70.33 156.9,64.8 156.64,64.55 156.64,51.36 155.51,50.23 155.51,19.07 151.99,15.55 131.56,15.55 128.32,18.79 120.52,18.79 118.77,17.03 116.06,17.03 114.94,18.15 111.73,18.15 111.04,18.85 110.27,18.85 109.89,18.47 109.89,17.9 109.23,17.23 106.28,17.23 105.25,18.27 103.8,18.27 103.6,18.47 103.09,18.47 102.49,19.07 102.49,20.08 100.69,21.88 97.64,21.88 97.22,21.45 94.22,21.45 91.76,23.92 91.76,24.92 91.35,25.33 87.29,25.33 v2(86.91,24.95) ; v2(148.4,102.19) 149.08,102.86 149.52,102.86 150.66,104 151.65,104 152.42,104.78 v2(152.7,104.78)
  IN3 w0.102: v2(148.4,102.19) 148.89,102.67 149.71,102.67 150.41,101.97 152.82,101.97 153.26,101.52 153.26,98.54 152.56,97.84 152.56,95.84 153.52,94.89 153.52,92.07 154.56,91.02 154.56,88.81 154.59,88.78 154.59,87.48 156.1,85.97 157.4,85.97 158.49,84.88 160.93,84.88 v2(161.26,85.21)
  BOTTOM w0.254: v2(31.28,31.11) PR703.1
AC_DIS: length 113.2
  TOP w0.102: v2(166.38,101.35) 165.98,101.75 U37.B12 ; v1(125.16,124.5) 125.4,124.26 v2(125.7,124.26)
  TOP w0.254: PR525.1 v2(109.55,152.09) ; v2(125.7,124.26) 125.77,124.33 125.77,125.97 125.21,126.53 PQ5.5
  IN2 w0.254: v2(109.55,152.09) 108.6,151.13 108.6,141.59 110.7,139.49 116.86,139.49 118.86,141.49 v2(118.86,141.52)
  IN3 w0.102: v2(167.17,116.89) 167.91,116.16 167.91,107.57 167.59,107.26 167.59,106.14 166.23,104.78 165.48,104.78 165.24,104.54 165.24,102.93 166.38,101.78 v2(166.38,101.35)
  IN3 w0.254: v2(118.86,141.52) 118.91,141.47 118.91,138.39 121.1,136.19 122.39,136.19 123.49,135.1 123.49,134.44 125.7,132.23 125.7,129.91 124.94,129.15 124.94,127.12 125.77,126.29 125.77,124.33 v2(125.7,124.26)
  BOTTOM w0.254: v2(125.7,124.26) 125.83,124.26 126.42,123.68 129.39,123.68 130.35,122.71 132.21,122.71 132.47,122.46 148.65,122.46 148.88,122.23 152.84,122.23 153.22,121.85 155.23,121.85 155.25,121.86 156.8,121.86 157.71,120.96 158.6,120.96 161.75,117.81 163.78,117.81 164.4,117.19 166.88,117.19 v2(167.17,116.89)
AC_PRESENT: length 97
  TOP w0.076: v1(131.95,69.56) 131.79,69.4 v2(131.36,69.4)
  TOP w0.102: v2(139.03,104.83) 139.26,105.06 U38.A54
  IN1 w0.097: v2(134.53,92.13) 134.53,92.59 136.05,94.11 136.05,94.65 137.84,96.44 137.84,101.14 137.68,101.3 137.68,102.39 138.97,103.68 138.97,104.77 v2(139.03,104.83)
  IN2 w0.076: v2(122.99,61.97) 122.85,62.11 122.85,62.6 123.48,63.24 126.85,63.24 128.88,65.27 128.88,65.52 131.36,68 v2(131.36,69.4) 131.36,69.52 131.67,69.84 132.31,69.84
  IN2 w0.102: v2(155.04,84.07) 155.83,83.28 156.21,83.28 156.64,82.85 156.64,82.13 156.91,81.87 156.91,76.27 152.79,72.15 141.86,72.15 140.23,70.53 137.08,70.53 136.52,71.09 133.56,71.09 132.31,69.84
  IN3 w0.102: v2(131.36,69.4) 130.28,69.4 129.75,69.92 v2(128.56,69.92)
  BOTTOM w0.076: UC1.AJ8 122.57,62.63 122.99,62.21 v2(122.99,61.97)
  BOTTOM w0.102: v2(134.53,92.13) 134.53,90.79 137.49,87.82 140.73,87.82 141.41,87.14 142.73,87.14 143.49,87.9 147.09,87.9 150.84,84.15 154.95,84.15 v2(155.04,84.07) ; v2(128.56,69.92) 128.93,70.29 RP13.1
ACAV_DOCK_SRC#: length 70.2
  TOP w0.102: v1(156.44,169.17) 157.03,169.76 v2(157.03,169.9)
  TOP w0.254: PR541.1 PR538.2 123.15,131.3 v2(123.94,130.5)
  IN2 w0.102: v2(123.94,130.5) 123.23,131.22 123.23,132.71 125.01,134.48 125.01,143.06 127.42,145.47 138.79,145.47 140.85,147.53 140.85,152.44 141.09,152.67 143.64,152.67 146.4,155.43 146.4,163.46 147.36,164.42 147.36,165.35 151.15,169.14 156.27,169.14 v2(157.03,169.9)
  BOTTOM w0.102: JDOCK1.42 157.45,170.32 v2(157.03,169.9)
ACAV_IN: length 176.7
  TOP w0.102: v2(75.41,99.31) 75.41,98.35 75.79,97.97 RV73.2 ; U38.A64 139.44,100.06 139.17,99.79 v2(139.17,99.66) ; v5(125.83,116.08) 125.57,116.33 PQ411.2
  TOP w0.254: v2(126.9,131.52) 126.34,132.09 PR548.1 ; PQ411.2 125.88,117.51 126.22,117.86 v2(126.41,117.86) ; PQ521.2 140.36,136.4 v2(140.13,136.17) ; PR427.1 v2(103.88,150.23)
  IN1 w0.254: v2(103.88,150.23) 103.88,143.92 105.07,142.74 105.07,141.5 107.61,138.95 112.27,138.95 115.18,141.86 v2(116.1,141.86)
  IN2 w0.102: v2(83.29,100.7) 83.92,101.34 83.92,104.51 85.76,106.35 89.51,106.35 90.84,107.69 90.84,115.69 91.79,116.64 103.48,116.64 105.76,114.35 109.57,114.35 111.48,112.45 118.34,112.45 119.1,113.21 121.83,113.21 123.99,115.37 125.26,115.37 125.83,115.94 125.83,117.28 v2(126.41,117.86)
  IN2 w0.254: v2(140.13,136.17) 140.13,135.64 137.96,133.47 135.42,133.47 132.88,130.93 127.49,130.93 v2(126.9,131.52)
  IN3 w0.102: v2(139.17,99.66) 136.24,102.58 136.24,106.1 135.36,106.99 131.23,106.99 129.77,108.45 129.77,114.5 v2(126.41,117.86)
  IN3 w0.254: v2(116.1,141.86) 116.52,141.44 116.94,141.44 118.05,142.56 119.72,142.56 120.46,141.82 120.46,139.61 124.5,135.57 124.5,134.84 126.71,132.63 126.71,131.72 v2(126.9,131.52) 126.9,123.26 125.81,122.17 125.81,118.46 v2(126.41,117.86)
  BOTTOM w0.102: v2(83.29,100.7) 81.83,100.7 80.43,99.31 v2(75.41,99.31)
ACAV_IN#: length 21.2
  TOP w0.254: PQ521.1 141.64,138.99 142.26,139.61 v2(142.26,139.77) ; PQ521.1 140.29,138.99 140.09,139.18 139.37,139.18 PR532.2 ; PQ521.1 141.01,139.84 v1(140.75,140.1) 140.43,140.42 PQ516.5 ; v2(147.48,152.01) 147.8,152.33 PR519.2
  IN3 w0.254: v2(142.26,139.77) 142.26,140.44 143.74,141.91 143.74,145.72 146.66,148.64 146.66,149.03 147.48,149.85 v2(147.48,152.01)
ACAV_IN_NB: length 118.1
  TOP w0.102: v2(149.01,100.45) 149.07,100.45 149.44,100.81 U38.B20 ; v2(134.66,124.77) 135.1,124.77 135.84,124.03 v5(135.84,123.16)
  TOP w0.254: v2(103.67,120.39) PR450.2 ; v2(123.23,145.6) PR545.2
  IN1 w0.097: v2(149.01,100.45) 149.01,100.45 149.53,100.97 149.53,107.13 150.62,108.22 150.62,111.9 151.48,112.77 151.48,115.51 155.99,120.02 155.99,121.34 155.74,121.59 154.72,121.59 v2(154.41,121.28)
  IN2 w0.254: v2(103.67,120.39) 104.96,119.03 118.64,119.03 119.32,118.36 122.24,118.36 123.86,119.98 126.6,119.98 127.21,119.37 127.21,118.39 128.09,117.52 130.02,117.52 134.66,122.16 v2(134.66,124.77) 135.08,125.19 139.9,125.19 140.59,125.88 150.09,125.88 154.41,121.57 v2(154.41,121.28)
  IN3 w0.254: v2(123.23,145.6) 124.98,143.84 124.98,139.55 128.56,135.97 128.56,134.67 129.84,133.39 129.84,127.71 131.96,125.59 134.15,125.59 134.66,125.09 v2(134.66,124.77)
ACAVDK_SRC: length 3.7
  TOP w0.254: PR541.2 122.53,132.6 PU701.4
ACAVIN: length 3.4
  TOP w0.254: PR548.2 126.34,134.1 125.93,134.51 v1(125.26,134.51) 125.17,134.51 124.53,135.15 PU701.8
ALW_PWRGD_3V_5V: length 98
  TOP w0.102: PR60.1 v2(189.06,137.6) v1(189.06,135.92) ; v2(141.32,97.66) 141.39,97.73 U38.A1
  IN2 w0.102: v2(141.32,97.66) 141.32,98.29 140.65,98.96 140.65,107.78 141.04,108.16 147.77,108.16 148.06,107.88 152.81,107.88 153.64,108.71 153.64,111.56 152.15,113.06 152.15,114.52 152.79,115.16 154.7,115.16 157.33,117.78 157.33,118.19 158.44,119.31 159.68,119.31 161.96,121.59 163.23,121.59 163.55,121.91 163.55,125.4 162.53,126.42 162.53,127.83 163.28,128.58 164.82,128.58 166.17,129.92 166.17,140.07 168.2,142.1 172,142.1 173.9,144.01 179.23,144.01 180.57,142.68 183.81,142.68 184.19,143.06 185.52,143.06 186.98,141.6 186.98,139.69 189.06,137.61 v2(189.06,137.6)
ALWON: length 90
  TOP w0.102: v2(184.82,143.82) v1(184.82,144.56) 184.82,147.95 185.46,148.58 186.85,148.58 187.35,148.09 PR65.1 ; v2(138.09,102.06) U38.A60
  IN2 w0.102: v2(138.09,102.06) 138.09,103.29 137.13,104.25 137.13,108.84 137.95,109.66 138.1,109.66 140.85,112.41 145.56,112.41 146.51,111.46 148.21,111.46 148.65,111.9 150.75,111.9 151.87,113.02 151.87,114.56 152.76,115.46 154.62,115.46 157.07,117.91 157.07,118.26 158.07,119.26 158.35,119.54 159.57,119.54 162.66,122.62 162.66,125.91 162.28,126.29 162.28,128.01 163.11,128.83 164.69,128.83 165.91,130.05 165.91,140.14 168.13,142.36 171.87,142.36 173.77,144.26 184.38,144.26 v2(184.82,143.82)
AUD_HP_NB_SENSE: length 223.7
  TOP w0.102: U37.A41 167.73,91.37 v2(168.12,90.99)
  IN3 w0.102: v2(313.92,152.58) 314.36,153.03 314.36,156.96 313.35,157.98 311.57,157.98 310.49,159.06 306.62,159.06 306.3,158.74 303.15,158.74 301.92,159.97 287.44,159.97 284.94,162.47 268.59,162.47 266.93,164.14 260.96,164.14 v2(260.77,163.95) 260.13,163.31 254.29,163.31 253.85,163.76 246.35,163.76 245.46,162.87 238.47,162.87 238.3,162.7 230.07,162.7 228.58,161.2 224.97,161.2 220.93,157.17 220.93,154.65 218.99,152.71 218.99,145.41 212.64,139.06 212.64,132.65 208.96,128.97 204.64,128.97 203.2,127.53 203.2,123.09 201.34,121.23 197.86,121.23 192.38,115.75 192.38,115.75 191.11,114.48 191.11,113.47 190.16,112.51 190.16,104.19 189.31,103.34 189.31,96.3 188.82,95.81 188.82,90.92 v2(188.25,90.35)
  BOTTOM w0.102: Q20.2 263.7,159.96 264.13,160.39 R163.1 C137.1 261.92,161.27 C408.1 261.11,161.26 260.4,161.97 v1(260.4,162.55) 260.4,163.58 v2(260.77,163.95) ; v2(188.25,90.35) 186.73,90.35 185.87,89.5 169.42,89.5 168.63,90.29 168.63,90.67 168.31,90.99 v2(168.12,90.99) ; v2(313.92,152.58) 313.66,152.84 JIO1.60
AUD_HP_OUT_L: length 48.1
  TOP w0.102: v2(305.15,154.42) 305.41,154.42 v1(305.87,154.88)
  IN1 w0.381: v2(305.15,154.42) 304.47,153.74 304.47,151.71 298.8,146.04 270.1,146.04 266.48,149.66 v2(266.17,149.66)
  BOTTOM w0.254: v2(305.15,154.42) 305.18,154.4 JIO1.53
  BOTTOM w0.381: v2(266.17,149.66) 265.67,149.66 R162.2
AUD_HP_OUT_R: length 48
  TOP w0.102: v2(305.15,153.41) 305.65,152.91 v1(305.99,152.91)
  IN1 w0.381: v2(266.17,148.96) 266.23,148.96 269.79,145.41 299.12,145.41 305.15,151.44 v2(305.15,153.41)
  BOTTOM w0.254: v2(305.15,153.41) 305.16,153.4 JIO1.57
  BOTTOM w0.381: v2(266.17,148.96) 265.67,148.96 R166.2
AUD_NB_MUTE#: length 141
  TOP w0.102: v2(188.25,89.72) v1(188.25,88.09) ; v2(167.31,90.8) 167.31,90.81 166.73,91.39 U37.A39
  IN3 w0.102: v2(188.25,89.72) 190.98,92.45 190.98,109.99 192.05,111.06 192.05,114.18 198.26,120.39 201.65,120.39 204.01,122.75 204.01,127.19 204.98,128.16 209.29,128.16 214.03,132.9 216.57,132.9 217.52,133.85 217.72,133.85 218.16,134.29 218.16,135.88 220.26,137.98 220.26,140.98 221.7,142.42 224.95,142.42 226.57,144.03 226.57,145.5 227.88,146.8 227.88,154.42 228.47,155.02 243.46,155.02 v2(244.39,155.95)
  BOTTOM w0.102: v2(244.39,155.95) 244.64,155.69 R153.1 244.87,155.36 R150.2 ; v2(167.31,90.8) 167.31,90.15 167.56,89.91 168.5,89.91 169.27,89.14 186.03,89.14 186.6,89.72 v2(188.25,89.72)
  BOTTOM w0.254: R150.2 246.85,154.8 C410.1 248.51,155.88 249.86,155.88 250.69,155.06 251.31,155.06 251.41,154.96 U17.47
AUD_OUT_L: length 14.6
  TOP w0.381: v2(263.88,149.66) 263.82,149.6 261.02,149.6 260.9,149.47 258.99,149.47 258.93,149.53 255.18,149.53 254.04,148.39 v2(254.04,148.33)
  BOTTOM w0.102: v1(266.5,150.63) 265.11,150.63 264.63,150.14 R162.1
  BOTTOM w0.254: v2(254.04,148.33) 254.18,148.47 U17.33
  BOTTOM w0.381: v2(263.88,149.66) 264.5,149.66 R162.1
AUD_OUT_R: length 13.7
  TOP w0.381: v2(254.04,147.74) 254.34,147.74 255.5,148.9 258.61,148.9 258.67,148.84 261.21,148.84 261.34,148.96 v2(263.88,148.96)
  BOTTOM w0.102: v2(263.88,148.96) v1(263.22,148.96)
  BOTTOM w0.254: v2(254.04,147.74) 254.28,147.74 254.68,148.14 U17.32
  BOTTOM w0.381: v2(263.88,148.96) 264.5,148.96 R166.1
AUD_PC_BEEP: length 6.6
  BOTTOM w0.102: U17.12 258.18,156.6 v1(259.45,157.86) 259.45,158.69 259.13,159.01 C143.2 C133.2
AUD_SENSE_A: length 2.9
  BOTTOM w0.254: R152.1 261.07,156.55 v1(260.4,155.88) 259.81,155.88 259.39,155.46 U17.13
AUD_SENSE_B: length 10.6
  TOP w0.254: v2(263.56,155.31) 264.9,156.65 v2(266.36,156.65)
  BOTTOM w0.254: U17.14 259.67,154.96 259.81,155.1 261.15,155.1 v1(261.68,155.63) 262.14,155.63 262.46,155.31 v2(263.56,155.31) 263.56,155.17 263.88,154.85 R156.1 ; R157.1 266.36,157.46 v2(266.36,156.65)
AUX_EN_WOWL: length 76.4
  TOP w0.102: U51.3 209.95,138.44 209.9,138.48 209.02,138.48 v2(208.89,138.36) 208.71,138.54 RC189.1 207.44,138.54 v1(207.14,138.84) ; U37.B67 171.73,101.09 v2(171.46,100.83)
  IN1 w0.097: v2(191.3,116.32) 191.3,113.78 189.46,111.94 189.46,106.67 186.66,103.88 186.66,99.05 v2(186.22,98.61)
  IN3 w0.102: v2(208.89,138.36) 208.11,137.58 208.11,132.92 206.98,131.79 196.54,131.79 191.87,127.12 191.87,122.93 191.3,122.36 v2(191.3,116.32)
  BOTTOM w0.102: v2(186.22,98.61) 183.3,98.61 182.32,97.63 180.24,97.63 177.5,100.37 175.58,100.37 174.53,101.43 172.06,101.43 v2(171.46,100.83)
B-RAMP: length 5.2
  BOTTOM w0.203: PR307.1 53.69,14.09 53.16,14.62 v1(51.94,14.62) 51.44,15.13 PU300.11
  BOTTOM w0.254: PR307.1 PR302.2
B_DE_0B: length 2.5
  TOP w0.102: U83.3 v1(299.7,166.58) 299.7,166.31 R2630.2
B_DE_1B: length 2.4
  TOP w0.102: R2631.2 301.2,166.08 v1(301.2,166.62) U83.6
B_EQ_0B: length 5.5
  TOP w0.102: R2639.1 297.61,163.69 297.61,165.12 R2628.2 298.1,166.07 298.04,166.13 298.04,166.42 v1(298.22,166.6) 298.55,166.6 299.2,167.25 U83.2
B_EQ_1B: length 2.3
  TOP w0.102: U83.4 300.2,165.93 R2629.2
BAT1_LED#: length 78.8
  TOP w0.102: v1(186.13,93.86) 186.4,93.59 v2(187.62,93.59)
  TOP w0.254: R433.1 v2(193.39,46.03) ; v2(170.66,98.94) 170.66,99.15 170.94,99.43 171.68,99.43 171.84,99.59 U37.B64
  IN2 w0.254: v2(193.39,46.03) 193.39,46.47 189.46,50.41 189.46,52.32 187.49,54.28 187.49,57.61 187.01,58.09 184.89,58.09 183.23,59.74 183.23,70.74 186.71,74.22 186.79,74.22 187.55,74.98 187.55,87.24 187.74,87.43 187.74,89.21 187.55,89.4 187.55,93.53 v2(187.62,93.59)
  BOTTOM w0.254: v2(170.66,98.94) 170.66,98.85 171.07,98.44 172.01,98.44 172.99,97.46 177.14,97.46 177.77,96.83 177.77,96.08 178.64,95.22 182.45,95.22 183.54,94.12 186.16,94.12 186.69,93.59 v2(187.62,93.59)
BAT2_LED#: length 104.5
  TOP w0.102: v2(194.03,46.03) 194.03,46.68 v1(193.98,46.73)
  TOP w0.254: R429.1 194.28,45.77 v2(194.03,46.03) ; v2(167.74,104.4) 167.55,104.4 167.23,104.08 U37.A9
  IN2 w0.254: v2(190.28,102.48) 190.28,90.67 188.19,88.57 188.19,87.24 187.93,86.99 187.93,74.83 186.95,73.84 186.87,73.84 183.62,70.59 183.62,59.94 185.08,58.47 187.17,58.47 187.87,57.78 187.87,54.45 189.84,52.49 189.84,50.66 194.03,46.47 v2(194.03,46.03)
  BOTTOM w0.254: v2(190.28,102.48) 190.28,106.61 192,108.32 192,109.85 191.43,110.42 189.9,110.42 188.12,112.2 185.14,112.2 180.89,107.94 178.15,107.94 175.49,105.27 170.36,105.27 169.95,104.87 168.21,104.87 v2(167.74,104.4)
BATDRV#: length 8.4
  TOP w0.254: PR432.2 115.69,148.4 v2(115.69,149.01) 115.69,152.33 116.16,152.8 117.92,152.8 118.78,153.66 PQ504.4
BATT_WHITE_LED#: length 47.7
  TOP w0.254: JLED1.6 188.81,7.35 190.35,8.88 190.35,14.47 189.97,14.85 189.97,17.26 190.63,19.39 194.44,23.19 194.44,27.98 v1(195.99,29.53) 197.84,31.39 197.84,42.85 196,44.7 194.55,44.7 R429.2
BATT_YELLOW_LED#: length 47.7
  TOP w0.254: R433.2 193.39,44.06 193.59,43.87 194.73,43.87 195.17,44.31 195.81,44.31 197.46,42.66 197.46,32 v1(197.05,31.59) 194.06,28.59 194.06,23.38 190.28,19.61 189.58,17.33 189.58,14.37 189.97,13.99 189.97,9.07 188.74,7.85 JLED1.7
BBS_BIT: length 40
  TOP w0.102: v2(103.1,85.14) 103.1,85.59 103.2,85.69 v1(103.43,85.69) 104.51,85.69 RC287.1 RC218.2
  IN2 w0.102: v2(113.38,62.88) 112.83,63.44 112.23,63.44 111.8,63.87 111.8,64.34 111.4,64.74 108.31,64.74 104.28,68.77 100.1,68.77 98.25,70.63 98.25,80.02 98.57,80.35 98.57,81.59 98.93,81.94 98.93,82.31 100.49,83.87 101.83,83.87 v2(103.1,85.14)
  BOTTOM w0.076: v2(113.38,62.88) 113.13,62.63 UC1.L8
BC_CLK_ECE1117: length 55.2
  TOP w0.102: U38.A20 150.86,101.56 151.08,101.34 151.6,101.34 151.85,101.09 152.3,101.09 152.58,100.82 v2(152.58,100.64) ; v2(188.19,108.96) 188.51,109.27 JKB1.2
  BOTTOM w0.102: v2(188.19,108.96) 187.99,109.16 187.99,109.41 187.74,109.66 187.1,109.66 186.63,109.18 186.63,107.27 186.35,106.99 184.69,106.99 183.86,106.16 183.86,100.7 181.67,98.5 180.37,98.5 177.79,101.08 175.87,101.08 174.82,102.14 163.33,102.14 162.15,100.96 162.15,99.05 161.81,98.71 159.84,98.71 159.6,98.47 155.8,98.47 155.39,98.06 154.53,98.06 152.61,99.98 152.25,99.98 152.18,100.04 152.18,100.25 152.37,100.44 152.37,100.49 152.52,100.64 v2(152.58,100.64)
BC_CLK_ECE5048: length 30.6
  TOP w0.102: U38.A43 143.89,109.74 v2(143.61,110.02) ; U37.A30 v2(161.2,94.84)
  BOTTOM w0.102: v2(161.2,94.84) 161.2,94.92 159.92,96.21 159.24,96.21 158.53,95.5 154.8,95.5 153.96,96.33 153.96,96.92 152.17,98.71 150.44,98.71 149.97,99.17 149.97,102.38 149.49,102.86 147.16,102.86 145.81,104.22 145.81,106.06 145.16,106.71 145.16,106.95 145.08,107.02 145.08,108.31 143.61,109.78 v2(143.61,110.02)
BC_DAT_ECE1117: length 64.4
  TOP w0.102: RP18.8 153.1,103.64 v2(152.9,103.43) ; v2(187.55,108.96) 186.74,108.96 186.51,109.19 JKB1.4 ; U38.B21 149.37,101.31 149.14,101.08 v2(149,101.08)
  IN1 w0.097: v2(151.15,99.3) 151.56,98.89 152.45,98.89 152.98,99.41 152.98,103.35 v2(152.9,103.43)
  IN3 w0.102: v2(151.15,99.3) 151.04,99.3 150.4,99.94 150.22,99.94 149.07,101.08 v2(149,101.08)
  BOTTOM w0.102: v2(151.15,99.3) 151.15,99.42 151.56,99.83 151.98,99.83 152.06,99.75 152.51,99.75 154.43,97.83 155.49,97.83 155.89,98.24 159.69,98.24 159.93,98.48 161.9,98.48 162.38,98.96 162.38,100.86 163.43,101.91 174.73,101.91 175.78,100.85 177.7,100.85 180.28,98.28 181.76,98.28 184.09,100.6 184.09,106.06 184.78,106.76 v3(185.86,106.76) 186.44,106.76 186.85,107.17 186.85,109.08 187.2,109.43 187.65,109.43 187.76,109.32 187.76,109.16 v2(187.55,108.96)
BC_DAT_ECE5048: length 32.3
  TOP w0.102: R343.2 153.63,96.21 v2(153.52,96.32) ; v2(163.55,95.05) 163.51,95.09 U37.B31 ; U38.B45 144.14,107.36 144.41,107.1 v2(144.66,107.1)
  BOTTOM w0.102: v2(144.66,107.1) 144.93,106.83 144.93,106.61 145.58,105.97 145.58,104.13 147.07,102.64 149.4,102.64 149.74,102.29 149.74,99.08 150.34,98.48 152.08,98.48 153.52,97.04 v2(153.52,96.32) 154.57,95.27 158.62,95.27 159.33,95.98 159.83,95.98 160.76,95.05 160.76,94.61 160.97,94.39 162.89,94.39 v2(163.55,95.05)
BC_INT#_ECE1117: length 49.8
  TOP w0.102: v2(151.99,100.63) 151.55,101.06 U38.A19 ; JKB1.5 185.51,109.29 v2(185.84,108.96)
  BOTTOM w0.102: v2(185.84,108.96) 183.45,106.57 183.45,100.92 181.88,99.34 179.88,99.34 177.28,101.95 176.34,101.95 174.82,103.47 172.97,103.47 171.87,102.37 162.21,102.37 158.54,98.7 155.7,98.7 155.3,98.29 154.8,98.29 153.07,100.02 153.07,100.72 152.74,101.05 152.21,101.05 151.99,100.83 v2(151.99,100.63)
BC_INT#_ECE5048: length 35.5
  TOP w0.102: U37.A29 161.04,95.34 160.76,95.05 v2(160.06,95.05) ; v2(142.98,110.74) 143.23,110.48 143.74,110.48 144.39,109.82 U38.A42
  BOTTOM w0.102: v2(160.06,95.05) 158.79,95.05 158.14,94.4 157.16,94.4 156.57,94.99 154.22,94.99 153,96.21 153,97.24 152.09,98.15 150.27,98.15 149.52,98.9 149.52,101.4 149.2,101.72 147.61,101.72 147.48,101.59 144.69,101.59 144.18,102.1 144.18,108.07 142.47,109.78 142.47,110.23 v2(142.98,110.74)
BEEP: length 14.8
  TOP w0.102: v2(151.04,111.24) 150.79,111.5 R353.2 v1(151.79,111.87) ; v2(149.07,99.85) 149.53,100.31 U38.B19
  IN1 w0.097: v2(151.04,111.24) 150.98,111.18 150.98,108 149.88,106.91 149.88,100.67 v2(149.07,99.85)
BIA_PWM_CVT: length 7.7
  TOP w0.102: v1(111.25,116.2) 110.69,116.75 D79.2 108.99,116.75 108.37,116.13 108.37,114.79 106.55,112.97 U52.19
BIA_PWM_EC: length 88.2
  TOP w0.102: v2(148.96,103.27) 149.01,103.31 U38.B25 ; v2(106.6,115.46) 106.6,116.65 v1(107.1,117.15) 107.92,117.97 110.23,117.97 D79.3
  IN3 w0.102: v2(148.96,103.27) 148.36,102.67 145.07,102.67 144.5,102.1 144.5,98.6 144.18,98.28 144.18,96.89 143.8,96.51 142.98,96.51 142.91,96.57 141.64,96.57 140.88,95.81 137.9,95.81 136.12,94.03 131.66,94.03 129.38,96.32 125.13,96.32 124.05,95.24 115.53,95.24 114.59,94.3 114.59,93.08 113.84,92.33 113.84,91.41 113.29,90.86 110.65,90.86 106.65,94.86 v2(103.8,94.86)
  BOTTOM w0.102: v2(103.8,94.86) 103.8,98.1 102.15,99.75 102.15,102.29 103.1,103.24 104.37,103.24 106.27,105.15 106.27,107.94 106.46,108.13 106.46,115.32 v2(106.6,115.46)
BIA_PWM_OUT: length 24.8
  TOP w0.102: v2(101.7,131.5) R2585.1 101.3,132.12 LE2.1 ; v1(107.85,115.98) 107.85,116.25 108.03,116.42 108.03,117.36 108.06,117.4 D79.1 108.52,117.34 v2(109.32,117.34)
  IN3 w0.102: v2(109.32,117.34) 108.94,117.72 104.11,117.72 101.7,120.13 v2(101.7,131.5)
BLUE_CRT: length 164.1
  TOP w0.102: v2(159.3,154.8) 159.17,154.68 U39.22
  IN3 w0.102: v2(193.39,160.2) 193.39,160.96 195.08,162.65 218.49,162.65 220.98,165.14 226.41,165.14 228.29,167.02 235.85,167.02 237.31,168.48 274.78,168.48 276.26,167 279.88,167 280.33,167.44 288.84,167.44 292.97,163.31 308.84,163.31 v2(309.54,162.61)
  BOTTOM w0.102: v2(159.3,154.8) 159.93,154.17 170.66,154.17 171.42,153.41 177.98,153.41 178.18,153.61 188.09,153.61 189.79,155.31 189.79,157.8 190.91,158.92 v1(191.15,158.92) 191.41,158.92 192.63,160.14 193.33,160.14 v2(193.39,160.2) ; v2(309.54,162.61) 309.75,162.4 JIO1.22
BLUE_DOCK: length 6.2
  TOP w0.102: U39.21 159.57,154.31 159.74,154.49 159.74,155.44 v2(159.8,155.5)
  BOTTOM w0.102: L71.1 160.44,157.98 159.8,157.34 v1(159.8,156.65) v2(159.8,155.5)
BLUE_DOCK_PI: length 4.9
  BOTTOM w0.102: L71.2 159.37,160.6 v1(158.68,161.29) 158.45,161.52 JDOCK1.45
