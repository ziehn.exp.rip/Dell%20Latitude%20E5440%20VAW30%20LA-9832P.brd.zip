# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_EXT_SCI#: length 110.6
  TOP w0.102: v2(149.07,110.48) 149.07,109.97 148.89,109.8 U38.A33 ; v1(106.45,85.79) 106.53,85.72 v2(106.53,85.14) 106.84,84.83 RC199.1
  IN2 w0.102: v2(106.27,93.27) 106.84,92.7 110.78,92.7 111.29,93.21 113.32,93.21 115.48,95.37 123.01,95.37 124.95,97.31 126.99,97.31 127.81,98.12 128.6,98.12 129.2,97.53 132.18,97.53 133.39,98.73 136.18,98.73 137.07,97.84 139.17,97.84 139.86,98.54 139.86,102.73 139.1,103.5 138.21,103.5 137.36,104.34 137.36,108.74 138.02,109.4 141.64,109.4 142.15,109.91 142.15,110.8 142.53,111.18 144.94,111.18 146.6,109.53 148.56,109.53 149.14,110.1 149.14,110.42 v2(149.07,110.48) ; v2(113.35,64.15) 113.07,64.44 113.07,65.9 112.87,66.1 112.07,66.1 111.81,65.84 110.72,65.84 106.64,69.92 101.76,69.92 99.39,72.29 99.39,74.38 100.22,75.21 100.22,79.22 101.7,80.7 102.91,80.7 106.53,84.32 v2(106.53,85.14)
  BOTTOM w0.076: UC1.N5 113.78,64.58 v2(113.35,64.15)
  BOTTOM w0.102: v2(106.53,85.14) 106.53,93.02 v2(106.27,93.27)
SIO_EXT_SMI#: length 97.1
  TOP w0.102: v2(121.93,64.45) 122.17,64.68 122.83,64.68 123.36,65.21 125.08,65.21 125.5,65.62 125.5,66.49 125.7,66.69 127.23,66.69 129.26,68.72 129.26,70.3 131.16,72.2 RP12.4 ; v2(143.61,96.94) 143.67,96.94 v1(144.09,97.36) 144.09,97.9 143.89,98.09 U38.A6
  IN2 w0.076: v2(121.93,64.45) 121.93,64.54 120.97,65.51 120.97,66.74 119.77,67.94 119.77,69.84
  IN2 w0.102: v2(153.39,89.44) 152.17,89.44 148.47,85.74 148.47,84.97 147.5,83.99 144.42,83.99 142.87,85.54 141.41,85.54 140.42,86.53 135.64,86.53 134.8,85.69 129.25,85.69 128.64,86.3 126.32,86.3 125.24,85.23 v2(125.24,83.91) 124.62,83.91 123.79,84.74 121.19,84.74 120.73,85.2 119.35,85.2 118.19,84.03 118.19,83.02 116.59,81.43 116.59,78.89 116.56,78.86 116.56,75.91 116.98,75.49 117.55,75.49 119.39,73.65 119.39,71.07 119.53,70.93 119.53,70.18 119.77,69.95 119.77,69.84
  BOTTOM w0.076: v2(121.93,64.45) 121.57,64.45 UC1.AG5
  BOTTOM w0.102: v2(153.39,89.44) 152.51,89.44 150.83,91.11 150.36,91.11 149.89,91.58 147.88,91.58 147.39,92.08 144.88,92.08 144.08,92.88 144.08,95.03 143.61,95.5 v2(143.61,96.94)
SIO_EXT_WAKE#: length 64.6
  TOP w0.102: v2(173.2,88.03) 173.2,88.45 173.07,88.57 R316.1 v1(172.14,89.13)
  IN2 w0.102: v2(127.41,69.54) 127.54,69.54 131.6,73.59 132.44,73.59 132.79,73.93 133.75,73.93 134.06,74.25 134.06,76.59 133.83,76.83 133.83,77.52 134.66,78.35 134.66,80.52 137.39,83.25 143.53,83.25 143.97,82.82 148.06,82.82 149.62,84.38 149.62,84.53 152.17,87.08 153.39,87.08 154.3,87.99 154.88,87.99 155.27,88.38 156.34,88.38 156.79,88.83 161.64,88.83 162.05,88.43 166.77,88.43 167.04,88.15 173.07,88.15 v2(173.2,88.03)
  BOTTOM w0.076: 127.43,69.84 127.43,69.56 v2(127.41,69.54) 127.04,69.17 127.04,67.86 126.86,67.68 126.86,66.88 UC1.AU2
  BOTTOM w0.102: RP13.4 127.43,69.84
SIO_PWRBTN#: length 209.1
  TOP w0.076: v2(122.83,63.61) 123.23,64 123.23,64.08 123.4,64.25 126.53,64.25 126.97,64.7 126.97,65.71 130.28,69.02 130.28,69.71 130.4,69.84
  TOP w0.102: 130.4,69.84 130.66,70.09 132.33,70.09 134.59,72.36 135.77,72.36 136.8,73.38 136.8,74.08 137.36,74.64 146.3,74.64 148.69,72.25 150.39,72.25 152.35,70.3 153.31,70.3 v2(154.72,71.71) 154.96,71.47 154.96,70.93 155.68,70.22 156.63,70.22 157.19,69.66 JAPS1.11 ; U38.B58 140.94,104.81 140.99,104.86 141.4,104.86 141.78,104.48 141.78,104.36 v2(141.79,104.36) ; v2(130.48,19.53) 131.1,20.16 v1(132.63,20.16) 136.7,20.16 140.04,16.83 RC107.1
  IN1 w0.097: v2(137.93,92.61) 137.93,92.73 138.53,93.34 138.66,93.34 139.55,94.23 139.55,98.19 139.93,98.57 139.93,101.41 140.61,102.1 140.61,103.48 141.07,103.94 141.36,103.94 v2(141.79,104.36)
  BOTTOM w0.076: UC1.AL7 123.18,63.61 v2(122.83,63.61)
  BOTTOM w0.102: v2(137.93,92.61) 138.09,92.45 138.09,90.98 139.17,89.91 149.2,89.91 151.07,88.03 151.07,87.53 151.53,87.07 154.27,87.07 154.62,86.73 158.79,86.73 159.23,86.29 161.63,86.29 163.41,84.51 164.59,84.51 164.98,84.11 164.98,83.64 165.81,82.81 165.81,81 166.46,80.35 171.64,80.35 172.16,79.83 172.16,78.51 172.88,77.79 172.88,77.08 173.24,76.72 173.24,75.45 172.54,74.75 164.59,74.75 164.27,75.07 163.08,75.07 161.55,73.55 159.86,73.55 158.98,72.66 155.67,72.66 v2(154.72,71.71) 154.6,71.58 154.6,67.41 156.97,65.04 156.97,39.65 136.85,19.53 v2(130.48,19.53)
SIO_RCIN#: length 76.9
  TOP w0.102: U38.A27 150.89,105.06 151.2,105.37 v2(151.39,105.37) ; RP3.6 114.14,84.26 114.34,84.07 114.34,83.56 113.8,83.02 113.8,79.77 v2(114.98,78.6)
  IN1 w0.076: v2(117.16,65.56) 116.69,66.04 116.69,69.84
  IN1 w0.097: v2(132.5,82.28) 132.96,82.28 135.64,84.96 135.64,86.18 140.05,90.6 140.05,90.6 141.85,92.4 147.2,92.4 149.64,94.84 149.64,99.75 150.36,100.47 150.36,104.47 151.26,105.37 v2(151.39,105.37) ; 116.69,69.84 116.69,70.08 116.63,70.14 116.63,71.86 116.3,72.19 116.3,73.06 116.59,73.35 116.59,75.52 115.42,76.68 115.42,78.06 114.98,78.5 v2(114.98,78.6)
  IN3 w0.102: v2(132.5,82.28) 131.95,82.28 130.99,81.32 122.3,81.32 121.61,80.64 117.47,80.64 117.32,80.79 115.72,80.79 114.98,80.05 v2(114.98,78.6)
  BOTTOM w0.089: v2(117.16,65.56) 116.86,65.26 UC1.V4
SIO_SLP_A#: length 287.2
  TOP w0.102: R423.1 84.88,27.11 83.92,27.11 v2(83.86,27.04) ; U37.B63 171.88,99.09 171.73,98.94 v2(171.27,98.94) ; JAPS1.6 154.69,67.81 153.18,69.31 151.94,69.31 150.88,70.37 149.96,70.37 149.55,69.97 v2(149.55,69.97) ; v2(163.36,80.8) 165.66,80.8 v1(166.17,80.29) 166.72,79.73 166.72,76.7 165.43,75.4 163,75.4 162.36,74.76 161.51,74.76 161.33,74.59 159.38,74.59 158.72,75.25 157.59,75.25 157.26,74.92 157.26,72.49 v2(156,71.23) 155.71,71.51 155.71,71.88 154.95,72.65 153.75,72.65 153.13,73.26 153.14,73.27 PR153.1
  IN2 w0.102: v2(83.86,27.04) 83.98,27.17 87.48,27.17 88.49,26.15 93.89,26.15 94.72,25.33 94.72,23.87 95.22,23.36 97.26,23.36 98.05,22.56 100.97,22.56 104.56,18.98 105.57,18.98 106.63,17.92 108.14,17.92 108.43,18.22 108.43,18.91 108.75,19.23 109.51,19.23 109.89,19.61 111.42,19.61 111.99,19.04 119.48,19.04 120.24,19.8 127.95,19.8 129.12,20.97 130.35,20.97 131.25,20.07 131.25,18.17 131.53,17.9 152.18,17.9 154.34,20.06 154.34,50.9 155.42,51.98 155.42,67.17 153.26,69.33 150.19,69.33 v2(149.55,69.97)
  IN3 w0.076: 137.03,66.92 136.58,66.48 135.04,66.48 134.96,66.48 132.83,66.48 132.58,66.72 131.62,66.72 131.32,67.02 130.76,67.02 128.19,64.45 124.07,64.45 v2(123.71,64.81)
  IN3 w0.102: v2(163.36,80.8) 164.21,81.65 168.29,81.65 169.11,82.47 169.11,83.86 171.13,85.88 171.13,87.95 172.29,89.12 174.39,89.12 175.94,90.67 176.85,90.67 177.54,91.35 179.24,91.35 180.55,92.67 180.55,94.36 181.21,95.02 v2(183.4,95.02) ; v2(156,71.23) 155.28,71.23 153.59,69.54 149.82,69.54 149.55,69.81 v2(149.55,69.97) 145.21,69.97 144.25,69 139.93,69 139.31,68.39 138.49,68.39 137.03,66.92
  BOTTOM w0.076: v2(123.71,64.81) 123.31,64.42 UC1.AL5
  BOTTOM w0.102: v2(171.27,98.94) 171.99,98.94 173.14,97.78 177.25,97.78 178.18,96.85 178.18,96.16 178.79,95.55 182.87,95.55 v2(183.4,95.02) ; UC7.1 136.53,77.74 136.18,78.1 136.18,79.18 136.34,79.33 136.34,80.16 136.58,80.39 136.58,81.19 138.85,83.47 139.3,83.47 141.53,85.69 144.03,85.69 144.82,86.48 146.5,86.48 150.25,82.73 153.21,82.73 153.65,82.29 156.51,82.29 157.11,82.88 161.35,82.88 163.36,80.88 v2(163.36,80.8)
SIO_SLP_LAN#: length 195
  TOP w0.102: v2(194.41,158.61) 194.73,158.61 198.16,162.04 v1(198.16,163.07) 198.16,168.27 197.84,168.58 U22.4 ; v2(171.8,109.03) 171.79,109.03 170.89,108.13 170.53,108.13 169.48,107.08 169.48,103.69 169.23,103.44 U37.A5
  IN2 w0.076: v2(121.93,63.09) 122,63.03 122.83,63.03 123.23,63.43 126.78,63.43 128.24,64.89 128.24,65.98 130.6,68.34 130.6,69.84
  IN2 w0.102: v2(187.86,113.48) 187.31,113.48 185.39,111.56 185.39,107.75 184.12,106.48 184.12,103.31 183.04,102.23 183.04,98.47 177.9,93.32 177.9,91.89 173.96,87.95 173.96,87.88 173.48,87.39 171.67,87.39 170.04,85.75 165.52,85.75 164.93,86.34 164.02,86.34 163.75,86.61 161.64,86.61 161.3,86.94 158.05,86.94 157.49,86.39 156.31,86.39 154.53,84.61 154.53,83.38 155.87,82.05 156.4,82.05 156.68,81.77 156.68,76.36 152.7,72.38 141.71,72.38 140.28,70.96 139.45,70.96 138.39,72.01 133.13,72.01 132.2,71.09 131.08,71.09 130.6,70.61 130.6,69.84
  IN3 w0.102: v2(194.41,158.61) 193.97,158.61 192.06,156.71 192.06,154.44 190.1,152.48 190.1,150.85 186.66,147.41 186.66,134.61 189.2,132.07 189.2,124.33 189.86,123.68 189.86,116.85 187.86,114.86 v2(187.86,113.48)
  BOTTOM w0.076: v2(121.93,63.09) 122.12,63.28 UC1.AJ7
  BOTTOM w0.102: v2(171.8,109.03) 173.66,109.03 174.46,109.83 176.35,109.83 180.15,113.63 187.71,113.63 v2(187.86,113.48)
SIO_SLP_S0#: length 114.8
  TOP w0.102: U38.A36 147.39,109.7 v2(147.66,109.96) ; v2(158.85,85.88) 158.85,84.94 159.23,84.56 161.69,84.56 163.01,83.24 165.56,83.24 v1(166.16,82.64) 167.6,81.19 167.6,77.19 165.55,75.15 163.07,75.15 162.46,74.54 161.61,74.54 161.43,74.36 158.07,74.36 v2(157.87,74.16) 157.88,74.16 158.79,73.25 158.79,70.16 159.3,69.65 159.3,68.17 159.19,68.06 JAPS1.15 ; PR157.2 v2(149.2,73.33)
  IN3 w0.102: v2(120.39,69.07) 120.61,69.07 120.85,69.31 121.67,69.31 122.1,68.88 123.28,68.88 123.8,69.4 124.62,69.4 125.12,68.9 125.12,68.02 125.38,67.76 129.14,67.76 130.16,68.77 132.41,68.77 133.9,70.26 133.9,72.89 134.62,73.61 135.2,73.61 136.1,72.71 139,72.71 139.94,73.65 148.88,73.65 v2(149.2,73.33) 149.67,73.8 155.32,73.8 155.77,74.26 157.78,74.26 v2(157.87,74.16) ; v2(158.85,85.88) 158.85,86.4 158.71,86.54 158.71,87.96 155.23,91.44 155.23,94.72 154.18,95.77 154.18,106.61 152.43,108.36 152.43,109.48 151.49,110.42 150.29,110.42 149.83,109.96 v2(147.66,109.96)
  BOTTOM w0.076: v2(120.39,69.07) 120.76,68.69 120.76,68.35 120.73,68.31 120.73,67.54 120.79,67.47 120.79,66.17 UC1.AF3
SIO_SLP_S3#: length 292
  TOP w0.102: v2(167.33,86.3) 167.66,86.3 169.33,84.64 PR111.1 ; R734.1 v2(91.72,27.36) ; v2(212.89,146.23) v1(211.56,146.23) 210.29,146.23 209.27,147.25 209.27,149.41 209.59,149.72 211.42,149.72 R425.1 ; U37.B65 171.81,100.09 171.64,99.92 v2(171.34,99.92) ; v2(85.13,74.49) 85.13,73.91 86.05,72.98 R417.1 ; v2(139.71,71.63) 139.73,71.64 142.67,71.64 143.04,72.01 145.88,72.01 146.66,71.24 146.66,69.33 147.73,68.27 152.22,68.27 152.69,67.8 JAPS1.2
  IN1 w0.097: v2(167.33,86.3) 167.33,86.3 167.33,87.31 167.66,87.64 167.66,90.46 167.72,90.52 167.72,91.47 168.57,92.32 168.57,97.78 170.22,99.43 170.86,99.43 v2(171.34,99.92)
  IN2 w0.076: v2(126.12,65.6) 127.22,65.6 130.14,68.53 130.14,69.84
  IN2 w0.102: v2(171.34,99.92) 172.28,100.85 172.28,102.56 176.59,106.88 176.59,108.53 183.83,115.77 183.83,121.12 191.15,128.44 197.05,128.44 197.65,127.84 210.28,127.84 215.05,132.61 v2(215.05,133.66) ; v2(91.72,27.36) 91.73,27.36 92.75,28.38 92.75,42.28 92.18,42.85 92.18,51.97 89.51,54.64 89.51,63.54 85.98,67.07 85.98,68.55 85.13,69.4 v2(85.13,74.49) ; 130.14,69.84 130.14,70.8 131.08,71.74 v2(131.42,71.74) 131.51,71.74 132.22,72.44 132.92,72.44 132.99,72.52 138.82,72.52 v2(139.71,71.63) 141.02,72.94 141.02,72.97 142.06,74.01 153.68,74.01 156.22,76.55 156.22,81.18 156.08,81.32 155.9,81.32 154.02,83.2 154.02,84.75 154.79,85.52 154.79,86.35 155.05,86.62 157.37,86.62 157.92,87.17 161.39,87.17 161.73,86.83 163.93,86.83 164.11,86.66 166.97,86.66 v2(167.33,86.3)
  IN3 w0.102: v2(131.42,71.74) 131.37,71.78 123.44,71.78 123.1,71.44 121.86,71.44 120.57,72.72 118.83,72.72 118.53,72.43 115.71,72.43 114.8,73.34 110.73,73.34 108.99,71.59 104.15,71.59 101.78,73.96 100.59,73.96 96.67,77.88 93.67,77.88 92.88,77.09 87.17,77.09 85.13,75.05 v2(85.13,74.49)
  BOTTOM w0.076: v2(126.12,65.6) 126.46,65.26 UC1.AT4
  BOTTOM w0.102: v2(215.05,133.66) 215.05,134.36 213.59,135.82 213.59,141.75 214.2,142.36 214.2,145.11 213.08,146.23 v2(212.89,146.23)
SIO_SLP_S4#: length 383.4
  TOP w0.102: U37.A61 173.56,99.84 v2(173.65,99.75) ; v2(83.79,26.46) 83.95,26.61 R421.1 ; JAPS1.5 154.19,67.84 152.95,69.08 151.84,69.08 150.95,69.97 v2(150.14,69.97) ; v2(165.04,72.94) 165.04,74.15 167.98,77.09 167.98,79.82 v1(168.37,80.21) 169.24,81.08 PR107.1
  IN2 w0.102: v2(165.04,72.94) 165.04,73.49 168.53,76.98 168.53,81.25 170.59,83.3 173.43,83.3 176.5,86.37 176.5,86.76 180.06,90.31 180.06,91.29 181.32,92.55 181.32,93.91 183.02,95.6 v2(183.43,95.6) 185.46,97.63 185.46,100.96 189.46,104.96 189.46,112.82 189.97,113.33 189.97,114.29 189.46,114.8 189.46,117.34 195.68,123.56 207.18,123.56 209.31,125.7 215.01,125.7 218.86,129.54 218.86,132.28 223.41,136.83 224.7,136.83 228.98,141.11 228.98,144.1 239.03,154.14 246.52,154.14 247.18,154.8 250,154.8 250.14,154.95 251.71,154.95 252.83,156.07 258.61,156.07 259.24,156.71 265.66,156.71 266.04,157.09 269.15,157.09 v2(269.72,156.52) ; v2(83.79,26.46) 84.22,26.46 84.68,26.92 87.35,26.92 88.37,25.9 91.59,25.9 92.57,24.92 92.57,24.43 93.89,23.11 97.15,23.11 97.92,22.33 100.88,22.33 104.49,18.72 105.5,18.72 106.53,17.69 108.29,17.69 108.69,18.09 108.69,18.79 108.88,18.98 109.64,18.98 110.02,19.36 111.29,19.36 111.86,18.79 119.55,18.79 120.31,19.55 128.05,19.55 129.25,20.74 130.26,20.74 131.02,19.98 131.02,18.03 131.41,17.64 152.35,17.64 154.6,19.89 154.6,50.79 155.68,51.87 155.68,67.36 153.43,69.61 150.49,69.61 v2(150.14,69.97)
  IN3 w0.076: v2(121.93,63.65) 121.93,63.91 122.72,64.7 122.85,64.7 123.33,65.18 128.69,65.18 130.69,67.19 131.39,67.19 131.69,66.88 132.65,66.88 132.83,66.7 135.58,66.7 136.46,67.58 136.46,68.27 136.71,68.53 137.03,68.53
  IN3 w0.102: 137.03,68.53 137.22,68.53 137.72,69.03 139.57,69.03 139.78,69.23 144.14,69.23 145.29,70.37 149.73,70.37 v2(150.14,69.97) 153.69,69.97 155.36,71.63 158.78,71.63 158.9,71.75 163.52,71.75 164.12,72.36 164.52,72.36 165.04,72.87 v2(165.04,72.94)
  BOTTOM w0.076: v2(121.93,63.65) 122.21,63.93 UC1.AJ6
  BOTTOM w0.102: v2(183.43,95.6) 182.26,96.77 179.68,96.77 177.14,99.31 174.09,99.31 v2(173.65,99.75)
  BOTTOM w0.254: PR203.1 272.77,166.49 273.34,165.92 273.34,162.81 269.72,159.19 v2(269.72,156.52)
SIO_SLP_S5#: length 83.1
  TOP w0.102: v2(151.36,100.63) 151.29,100.56 U38.A18 ; JAPS1.4 153.69,67.89 153.09,68.49 147.88,68.49 146.91,69.46 146.91,71.37 145.74,72.53 v1(145.2,72.53) 144.14,72.53 143.84,72.84 v2(143.84,73.02)
  IN2 w0.076: 130.37,69.84 130.37,68.43 127.14,65.21 125.83,65.21 125.51,64.89 v2(125.51,64.82)
  IN2 w0.102: v2(155.24,86.17) 155.24,85.65 154.28,84.68 154.28,83.3 155.78,81.8 156.29,81.8 156.45,81.64 156.45,76.45 152.6,72.61 144.25,72.61 v2(143.84,73.02) 143.43,72.61 141.53,72.61 140.13,71.21 139.52,71.21 138.47,72.27 133.06,72.27 132.11,71.31 130.98,71.31 130.37,70.7 130.37,69.84
  IN3 w0.102: v2(155.24,86.17) 154.34,87.08 154.34,88.65 154.3,88.68 154.3,90.89 153.26,91.93 153.26,94.76 152.31,95.71 152.31,97.97 153,98.67 153,101.02 152.89,101.13 151.86,101.13 v2(151.36,100.63)
  BOTTOM w0.076: v2(125.51,64.82) 125.51,64.82 125.26,64.57 UC1.AP5
SIO_SLP_SUS#: length 90.3
  TOP w0.102: v2(169.72,100.77) 169.26,101.23 169.26,101.55 168.98,101.82 U37.B6 ; v1(180.24,96.28) 179.96,96 v2(179.06,96)
  IN2 w0.076: v2(125.54,68.12) 126.26,68.12 126.74,68.61 126.74,69.66 126.92,69.84
  IN2 w0.102: v2(179.06,96) 179.06,95.14 177.22,93.3 177.22,91.85 173.8,88.43 167.08,88.43 166.86,88.65 162.26,88.65 161.82,89.09 156.41,89.09 156.25,89.26 155.7,89.26 155.01,88.57 152.66,88.57 152.35,88.25 152.35,87.59 149.39,84.63 149.39,84.48 147.96,83.05 144.06,83.05 143.63,83.48 137.3,83.48 134.4,80.59 134.4,79.18 134.09,78.86 131.53,78.86 130.05,77.37 130.05,72.39 127.75,70.1 127.18,70.1 126.92,69.84
  BOTTOM w0.076: v2(125.54,68.12) 125.54,67.69 125.29,67.44 125.29,67.02 125.45,66.86 125.45,66.09 125.4,66.03 125.4,65.57 UC1.AP4
  BOTTOM w0.102: v2(179.06,96) 178.6,96.46 178.6,96.76 177.35,98.01 173.24,98.01 171.82,99.43 170.48,99.43 169.72,100.19 v2(169.72,100.77)
SIO_SLP_WLAN#: length 82
  TOP w0.102: v1(166.13,86.8) 166.13,87.27 166.41,87.54 v2(166.41,87.56) ; v2(165.2,106.8) 165.13,106.73 R318.1
  IN1 w0.097: v2(166.41,87.56) 166.41,87.63 165.7,88.33 165.7,92.41 166.53,93.25 166.53,94.86 166.85,95.18 166.85,99.43 167.08,99.66 167.08,102.19 166.33,102.94 166.33,105.29 165.2,106.42 v2(165.2,106.8)
  IN2 w0.076: 129.62,69.84 129.62,68.75 127.86,66.98 124.89,66.98 124.18,66.27 124.18,65.4 124.36,65.22 v2(124.36,64.81)
  IN2 w0.102: 129.62,69.84 129.62,70.97 131.78,73.13 132.63,73.13 132.97,73.47 133.94,73.47 134.53,74.07 134.53,76.38 135.17,77.02 135.17,80.38 137.58,82.8 143.35,82.8 143.8,82.34 148.22,82.34 150.08,84.19 150.08,84.34 152.35,86.61 153.56,86.61 154.28,87.33 156.25,87.33 157.27,88.35 161.2,88.35 161.61,87.93 161.61,87.61 161.91,87.3 164.18,87.3 164.38,87.11 165.96,87.11 v2(166.41,87.56)
  BOTTOM w0.076: v2(124.36,64.81) 123.96,64.42 UC1.AM5
SKIP#: length 2.3
  BOTTOM w0.203: PU300.7 53.93,17.34 v1(53.96,17.32) 54.46,16.82 PR315.1
SKIP#1: length 23.1
  IN2 w0.254: v2(69.44,26.92) 69.25,27.11 66.2,27.11 65.38,26.28 65.38,21.2 64.06,19.88 58.55,19.88 v2(57.14,18.47)
  BOTTOM w0.102: v1(57.94,18.66) 57.33,18.66 v2(57.14,18.47)
  BOTTOM w0.203: v2(69.44,26.92) 69.44,26.81 69.11,26.48 PU301.1
  BOTTOM w0.254: v2(57.14,18.47) 57.12,18.45 PR314.2 56.48,16.82 PR315.2
SL_BAT_PRES#: length 2.8
  TOP w0.254: PU701.21 124.03,142.53 v1(124.46,142.96) 125,143.5 PR549.1
SLATE_MODE_R: length 19.4
  IN2 w0.076: 125.02,69.84 125.02,67.88 123.48,66.35 123.48,65.71 123.33,65.56 v2(123.12,65.56)
  IN2 w0.102: v2(129.01,78.23) 129.34,77.9 129.34,74.36 128.87,73.89 128.87,72.91 128.97,72.81 128.97,72.32 128.55,71.9 126.23,71.9 125.02,70.69 125.02,69.84
  BOTTOM w0.076: UC1.AL4 123.42,65.26 v2(123.12,65.56)
  BOTTOM w0.102: v1(129.01,77.64) v2(129.01,78.23) 129.2,78.42 129.2,78.79 129.45,79.04 RP14.6
SLEEVE: length 79.8
  TOP w0.102: v2(246.48,147.29) 246.11,147.29 245.06,148.34 241.63,148.34 v1(241.31,148.02)
  TOP w0.254: v2(246.48,147.29) 252.34,147.29 252.58,147.06 254.55,147.06 255.75,148.26 v2(256.18,148.26)
  IN3 w1.016: 306.3,156.86 306.3,151.5 300.2,145.41 266.93,145.41 266.23,146.1 260.32,146.1 259.88,146.55 256.56,146.55
  BOTTOM w0.254: JIO1.43 305.66,156.9 305.49,156.72 v2(305.28,156.72) ; JIO1.41 305.38,157.4 v2(305.28,157.31) ; v2(246.48,147.29) 247.18,147.29 Q123.3 ; R197.1 256.18,146.89 v2(256.18,147.63) v2(256.18,148.26) U17.29
SLEWA: length 14.9
  IN1 w0.254: v2(47.91,14.86) 44.42,18.34 v2(44.42,20.21)
  BOTTOM w0.203: PR310.1 v2(47.91,14.86) 48.16,15.1 v1(48.73,15.1) 49.12,15.1 49.84,15.82 PU300.15
  BOTTOM w0.254: v2(44.42,20.21) 44.42,20.31 44.42,20.31 44.42,23.04 44.74,23.36 PR300.2
SLICE_BAT_ON: length 125.1
  TOP w0.102: U37.A31 160.39,94.34 159.83,93.78 R307.2 158.48,93.27 156.88,93.27 156.18,93.97 156.18,94.68 156.3,94.8 156.3,102.5 156.82,103.02 156.82,106.82 156.22,107.41 156.22,108.72 155.8,109.14 155.8,111.61 157.45,113.26 157.45,114.1 157.05,114.5 156.42,114.5 155.74,115.18 155.74,118.36 156.37,118.99 156.37,129.15 155.68,129.85 152.79,129.85 152.26,129.32 v2(150.28,129.32)
  TOP w0.254: v2(125.01,145.91) 125.25,146.16 v1(125.25,147.22) 125.25,147.64 123.29,149.6 PQ506.5 ; PU505.1 141.94,152.37 141.64,152.07 v2(141.45,152.07) ; PR543.2 120.56,145.15 120.81,145.4 v2(120.81,145.95)
  TOP w0.381: PQ508.2 138.91,126.99 136.37,129.53 v2(136.37,130.29) 136.37,130.42 136.75,130.8 PU500.2
  IN2 w0.102: v2(136.37,130.29) 141.25,130.29 141.32,130.37 149.22,130.37 v2(150.28,129.32)
  IN2 w0.254: v2(125.01,145.91) 124.84,146.08 120.94,146.08 v2(120.81,145.95)
  IN3 w0.254: v2(141.45,152.07) 142.09,151.44 142.09,146.93 v2(140.43,145.28) 140.43,142.86 139.17,141.6 139.17,139.82 136.82,137.47 136.82,133.34 137.32,132.83 137.32,131.31 136.37,130.36 v2(136.37,130.29)
  BOTTOM w0.254: v2(125.01,145.91) 139.8,145.91 v2(140.43,145.28)
SLICE_BAT_PRES#: length 236.6
  TOP w0.102: U37.B33 163.92,94.09 v2(164.12,94.29) ; R285.2 163.04,89.41 163.04,90.22 v2(163.17,90.35)
  TOP w0.254: v2(136.12,138.48) 136.12,139.31 137.82,141.01 PR562.2 ; v2(115.29,152.64) 114.84,152.2 PD514.1 ; PR549.2 125,145.09 v2(124.56,145.53) ; v2(144.7,131.04) 145.76,129.99 PU506.1 ; PQ1.2 127.28,123.34 127.69,122.93 127.69,121.43 PC4.1 129.18,119.02 PR566.1 v1(130.43,120.06) 133.5,120.06 135.1,121.66 136.13,121.66 v2(137.43,122.95) ; v2(144.86,150.34) PU503.1
  TOP w0.381: v2(136.12,138.48) PQ503.5 ; v2(136.12,132.07) 136.12,131.82 136.48,131.45 PU500.1
  IN1 w0.097: v2(163.17,90.35) 163.17,91.81 163.42,92.07 163.42,92.07 163.6,92.25 163.6,93.77 v2(164.12,94.29)
  IN2 w0.102: v2(153.54,121.29) 150.01,121.29 148.82,122.48 146.66,122.48 146.47,122.29 138.09,122.29 137.43,122.95 v2(137.43,122.95)
  IN2 w0.254: v2(144.7,131.04) 143.2,131.04 142.73,131.51 136.68,131.51 v2(136.12,132.07)
  IN3 w0.102: v2(177.33,167.57) 175.56,169.33 170.05,169.33 166.28,165.56 166.28,165.13 164.05,162.9 164.05,159.58 162.98,158.5 162.98,156.96 163.93,156.01 163.93,154.55 163.04,153.66 163.04,146.04 156.95,139.94 156.95,139.01 154.53,136.6 154.53,131.5 154.02,130.99 154.02,124.77 153.54,124.29 v2(153.54,121.29) 153.54,114.72 153.86,114.4 153.86,112.42 154.43,111.85 154.43,108.3 155.17,107.56 155.75,107.56 156.99,106.31 156.99,100.39 158.2,99.19 158.2,98.6 158.41,98.4 158.41,92.71 159.03,92.09 161.67,92.09 163.87,94.29 v2(164.12,94.29)
  IN3 w0.254: v2(137.43,122.95) 137.43,126.25 135.86,127.82 135.86,130.55 136.12,130.8 v2(136.12,132.07) 136.44,132.39 136.44,138.16 v2(136.12,138.48) 136.12,139.44 139.93,143.25 139.93,145.53 141.32,146.93 v2(141.32,150.04) ; v2(124.56,145.53) 124.56,145.68 119.19,151.06 116.88,151.06 v2(115.29,152.64)
  BOTTOM w0.102: JDOCK1.143 184.95,163.09 184.84,162.98 184.59,162.98 184.45,163.12 JDOCK1.141 184.45,165.54 183.5,166.49 178.92,166.49 177.84,167.57 v2(177.33,167.57)
  BOTTOM w0.254: v2(136.12,138.48) 134.66,138.48 132.28,140.86 126.5,140.86 124.56,142.8 v2(124.56,145.53) ; v2(141.32,150.04) 141.69,150.41 144.8,150.41 v2(144.86,150.34)
SLICE_PERF_EN: length 78.5
  TOP w0.102: U38.B37 148.14,108.11 148.47,107.78 v2(148.47,107)
  TOP w0.254: PR561.2 133.96,127.17 v2(133.96,127.75) ; PR563.2 132.45,127.49 132.18,127.75 v2(131.67,127.75) ; PQ523.5 131.23,142.1 v2(131.16,142.17) ; PQ516.2 140.43,143.87 140.25,144.06 v1(139.88,144.06) 139.34,144.06 v2(139.17,143.88)
  IN2 w0.102: v2(152.41,125.47) 151.58,125.47 150.18,126.87 149.27,126.87 147.36,128.78 145.56,128.78 144.29,127.51 139.47,127.51 138.71,128.27 134.48,128.27 v2(133.96,127.75)
  IN2 w0.254: v2(133.96,127.75) v2(131.67,127.75) ; v2(131.16,142.17) v2(131.16,137.98)
  IN3 w0.102: v2(152.41,125.47) 152.41,120.12 151.99,119.7 151.99,116.95 150.21,115.18 147.99,115.18 147.48,114.67 147.48,113.34 148.18,112.64 148.18,110.61 147.94,110.37 147.43,110.37 147.23,110.16 147.23,109.21 148.47,107.97 v2(148.47,107)
  IN3 w0.254: v2(131.67,127.75) 131.67,137.47 v2(131.16,137.98) 131.54,138.36 133.32,138.36 135.93,140.96 136.82,140.96 139.17,143.31 v2(139.17,143.88)
SLP_ME_CSW_DEV#: length 98.7
  TOP w0.102: v2(170.47,96.13) 170.47,96.21 170.85,96.59 U37.B58
  IN2 w0.102: v2(170.47,96.13) 170.24,96.36 166.19,96.36 164.86,97.69 163.16,97.69 162.52,98.33 159.75,98.33 158.22,96.8 158.22,94.24 157.52,93.54 156.39,93.54 155.76,94.17 154.23,94.17 152.48,92.42 150.9,92.42 147.65,89.17 135.26,89.17 134.6,88.51 133.13,88.51 132.22,89.42 131.06,89.42 130.73,89.09 125.02,89.09 124.03,88.1 122.41,88.1 121.51,89.01 118.46,89.01 117.87,88.41 112.62,88.41 111.32,87.11 110.56,87.11 109.52,86.08 109.52,84.7 102.13,77.31 102.13,72.7 v2(102.26,72.57)
  BOTTOM w0.076: 107.92,68.44 108.73,67.64 108.73,67.08 109.24,66.56 UC1.E2
  BOTTOM w0.102: 107.92,68.44 105.84,70.53 RC289.2 104.89,70.53 v1(104.27,71.14) 102.84,72.57 v2(102.26,72.57)
SM_RCOMP0: length 6.3
  TOP w0.305: v2(126.71,30.44) v1(129.46,27.68) 129.97,27.17 RC125.1
  BOTTOM w0.229: v2(126.71,30.44) 126.91,30.65 UC1.AU60
SM_RCOMP1: length 4.2
  TOP w0.305: RC129.1 131.31,30.28 v1(129.4,30.28) 128.15,30.28 v2(128.05,30.17)
  BOTTOM w0.229: v2(128.05,30.17) 127.86,30.36 UC1.AV60
SM_RCOMP2: length 6.4
  TOP w0.305: RC133.1 130.43,25.78 v1(127.68,28.53) v2(126.74,29.46)
  BOTTOM w0.229: UC1.AU61 126.94,29.66 v2(126.74,29.46)
SMART_DET#: length 224.2
  TOP w0.102: v2(91.29,22.22) 90.52,22.22 90.06,22.68 JEXP1.33 ; v2(169.89,110.54) 169.33,109.99 167.38,109.99 v1(166.79,109.41) 166.28,108.89 166.28,108.7 165.71,108.13 165.71,107.62 165.4,107.31 164.92,107.31 164.67,107.05 164.67,105.68 R484.2 164.45,104.93 164.45,103.64 164.23,103.42 U37.A15
  IN2 w0.102: v2(188.51,114.42) 188.51,110.57 186.98,109.04 186.98,103.66 184.7,101.37 184.7,98.25 180.63,94.19 180.63,92.83 179.37,91.57 179.37,90.62 175.79,87.04 175.79,86.71 175.46,86.38 174.45,86.38 172.45,84.38 168.18,84.38 167.68,83.87 166.08,83.87 165.7,84.26 164.35,84.26 162.47,82.38 162.47,81.46 160.69,79.68 160.69,76.45 159.51,75.27 159.51,70.94 159.27,70.7 159.27,65.88 157.57,64.18 157.57,50.98 156.43,49.83 156.43,18.97 151.09,13.63 132.91,13.63 131.85,14.69 130.08,14.69 128.96,15.8 122.19,15.8 121.17,14.79 115.1,14.79 114.5,14.19 113.22,14.19 112.62,14.78 103.63,14.78 102.68,13.83 99.63,13.83 99.1,14.37 99.1,17.96 96.37,20.69 94.01,20.69 92.49,22.22 v2(91.29,22.22)
  BOTTOM w0.102: v2(188.51,114.42) 188.44,114.42 188.38,114.35 186.56,114.35 186.38,114.53 179.17,114.53 175.71,111.08 173.56,111.08 172.55,110.07 170.31,110.07 169.84,110.54 v2(169.89,110.54)
SML1_SMBCLK: length 53.5
  TOP w0.076: v2(127.41,68.95) 127.1,68.95 126.53,69.52 126.53,69.84
  TOP w0.102: U38.B6 143.64,99.79 v2(143.56,99.88) ; v2(122.55,77.52) 122.4,77.37 122.4,75.74 121.7,75.05 121.7,74.58 122.21,74.07 122.21,73.59 122.47,73.33 122.91,73.33 123.89,72.36 124.61,72.36 126.53,70.44 126.53,69.84
  IN1 w0.097: v2(122.55,77.52) 122.42,77.66 122.42,77.77 122.63,77.98 123.74,77.98 124.58,78.83 126.96,78.83 128.44,80.31 129.76,80.31 131.44,81.99 131.44,82.73 132.37,83.66 132.37,85.36 138.06,91.05 138.4,91.05 140.29,92.93 140.29,94.9 141.86,96.48 142.63,96.48 142.88,96.22 143.78,96.22 144.28,96.72 144.28,98.64 143.96,98.96 143.83,98.96 143.56,99.23 v2(143.56,99.88)
  BOTTOM w0.076: v2(127.41,68.95) 127.81,68.55 127.81,67.95 127.52,67.66 127.52,67.08 127.51,67.07 127.51,66.45 127.18,66.12 UC1.AU3
  BOTTOM w0.102: v2(122.55,77.52) 122.36,77.72 122.36,77.77 RC36.1
SML1_SMBDATA: length 54.9
  TOP w0.102: v2(121.97,77.52) 122.17,77.32 122.17,75.84 121.47,75.14 121.47,74.48 121.98,73.98 121.98,73.49 122.37,73.11 122.82,73.11 123.79,72.13 124.51,72.13 125.57,71.07 125.57,70.77 124.71,69.9 v2(123.04,69.9) ; v2(143.61,97.59) 143.39,97.8 U38.A5
  IN1 w0.097: v2(121.97,77.52) 122.19,77.75 122.19,77.86 122.53,78.21 123.64,78.21 124.49,79.05 126.86,79.05 128.35,80.53 129.67,80.53 131.22,82.08 131.22,82.82 132.15,83.75 132.15,85.46 137.96,91.27 138.31,91.27 140.06,93.03 140.06,94.99 141.77,96.7 142.72,96.7 142.98,96.45 143.68,96.45 144.05,96.82 144.05,98.54 143.86,98.73 143.72,98.73 143.61,98.62 v2(143.61,97.59)
  BOTTOM w0.076: 123.04,69.84 123.04,69.37 122.16,68.5 122.16,67.51 122.3,67.37 122.3,66.19 122.04,65.92 UC1.AH3
  BOTTOM w0.102: RC37.1 122.13,77.77 122.13,77.68 v2(121.97,77.52) ; 123.04,69.84 v2(123.04,69.9)
SNUB_1.5VRUN: length 2.9
  BOTTOM w0.102: v1(275.64,168.96) PC207.1
  BOTTOM w0.508: PR201.2 274.08,168.68 PC207.1
SNUB_1.35V: length 2
  TOP w0.102: PR103.1 184.12,82.41 v1(184.48,82.77)
SOFT_START_GC: length 8.8
  TOP w0.102: v2(123.85,129.93) 124.15,129.93 v1(124.71,130.48)
  TOP w0.254: v2(121.67,134.66) 121.53,134.8 PU701.2 ; v2(123.85,129.93) 123.22,129.93 PR20.2
  IN3 w0.254: v2(121.67,134.66) 122.02,134.31 122.02,133.66 123.46,132.22 123.46,130.26 123.8,129.93 v2(123.85,129.93)
SP_TPM_LPC_EN: length 29.7
  TOP w0.102: R304.2 176.94,95.15 176.47,94.68 v2(176.12,94.68) ; R193.1 168.01,110.54 v1(168.76,110.54) v2(169.26,110.54) ; v2(170.62,95.55) 170.69,95.62 171.74,95.62 171.77,95.59 U37.B56
  IN3 w0.102: v2(170.62,95.55) 170.35,95.55 169.98,95.93 169.98,98.9 170.19,99.11 170.19,102.96 169.71,103.43 169.71,105.03 170,105.32 170,109.43 169.26,110.16 v2(169.26,110.54)
  BOTTOM w0.102: v2(176.12,94.68) 176,94.68 174.92,93.59 174.92,92.89 174.47,92.45 172.89,92.45 172.41,92.92 172.41,94.84 171.64,95.62 170.69,95.62 v2(170.62,95.55)
SP_TPM_LPC_EN_R: length 3.9
  TOP w0.102: v1(167.11,111.93) 166.93,111.75 166.93,111.37 166.78,111.22 R193.2 166.59,111.05 165.2,111.05 164.98,110.83 U25.28
SPI_CLK32: length 21.9
  BOTTOM w0.102: U2.6 23.2,14.53 23.09,14.42 23.09,14.15 22.96,14.02 21.5,14.02 21.37,13.9 21.37,12.92 21.5,12.79 21.65,12.79 21.78,12.67 21.78,12.41 21.65,12.29 21.45,12.29 21.37,12.21 21.37,11.9 21.5,11.78 22.07,11.78 22.2,11.65 22.2,11.4 22.07,11.27 20.83,11.27 20.74,11.36 20.74,14.42 20.87,14.54 21.82,14.54 21.94,14.67 21.94,14.92 21.82,15.05 20.29,15.05 20.17,15.18 20.17,15.43 20.29,15.56 21.82,15.56 21.94,15.69 21.94,15.94 21.82,16.07 21.05,16.07 20.93,16.19 20.93,16.45 21.05,16.58 22.07,16.58 22.33,16.83 R45.2 R20.1
SPI_CLK64: length 23.1
  TOP w0.102: v2(30.26,13.77) 30.43,13.61 v5(31.56,13.61)
  IN1 w0.097: v2(20.61,16.96) 20.61,15.04 20.74,14.91 21.03,14.91 21.13,15.01 21.13,16.5 21.26,16.63 21.48,16.63 21.61,16.5 21.61,15.01 21.71,14.91 22,14.91 22.09,15.01 22.09,16.25 22.22,16.37 22.45,16.37 22.58,16.25 22.58,15.01 22.67,14.91 28.99,14.91 29.12,14.79 29.12,13.9 29.25,13.77 v2(30.26,13.77)
  BOTTOM w0.102: U1.6 29.7,13.26 R57.2 29.69,13.54 29.92,13.77 v2(30.26,13.77) ; v2(20.61,16.96) 20.55,17.02 R7.1
SPI_DIN32: length 21.6
  BOTTOM w0.102: U2.2 14.67,13.26 14.54,13.39 14.54,14.63 14.41,14.76 v1(13.56,14.76) 12.81,14.76 12.69,14.88 12.69,15.14 12.81,15.26 14.41,15.26 14.54,15.39 14.54,15.65 14.41,15.77 13.09,15.77 12.96,15.9 12.96,16.15 13.09,16.28 14.41,16.28 14.54,16.41 14.54,16.66 14.41,16.79 13.18,16.79 13.05,16.92 13.05,17.19 13.18,17.31 13.68,17.31 13.78,17.42 13.78,17.73 13.88,17.83 14.19,17.83 14.29,17.73 14.29,17.42 14.39,17.31 14.69,17.31 14.8,17.42 14.8,17.75 14.92,17.88 15.18,17.88 15.3,17.75 15.3,17.01 15.43,16.88 15.69,16.88 15.81,17.01 15.81,17.92 15.94,18.05 16.19,18.05 16.32,17.92 16.32,17.42 16.42,17.31 16.74,17.31 R15.2
SPI_DIN64: length 24.7
  TOP w0.102: v2(37.31,14.15) 37.36,14.2 v5(38.01,14.2)
  IN1 w0.097: v2(37.31,14.15) 35.91,12.75 22.11,12.75 v2(19.06,15.8)
  BOTTOM w0.102: U1.2 37.69,14.53 v2(37.31,14.15) ; v2(19.06,15.8) 18.83,15.8 17.88,16.76 R4.2
SPI_DO32: length 21.6
  BOTTOM w0.102: R21.1 25.88,14.89 25.98,14.79 26.48,14.79 26.61,14.67 26.61,14.41 26.48,14.28 v1(26.26,14.28) 25.98,14.28 25.88,14.18 25.88,14.05 25.75,13.92 25.5,13.92 25.37,14.05 25.37,16.85 25.25,16.98 25.1,16.98 24.98,17.1 24.98,19.8 24.85,19.93 23.98,19.93 23.88,19.83 23.88,19.59 23.77,19.49 23.57,19.49 23.44,19.36 23.44,19.1 23.57,18.98 24.23,18.98 24.36,18.85 24.36,18.61 24.23,18.49 23.94,18.49 23.81,18.36 23.81,18.11 23.94,17.98 24.29,17.98 24.42,17.85 24.42,17.1 24.04,16.72 23.63,16.72 23.47,16.56 22.38,16.56 22.26,16.44 22.26,15.23 22.38,15.1 22.64,15.1 22.77,15.23 22.77,15.68 22.9,15.8 U2.5
SPI_DO64: length 21.6
  BOTTOM w0.102: R9.1 28.07,15.92 28.29,16.15 29.31,16.15 29.44,16.02 29.44,15.03 29.31,14.9 26.96,14.9 26.83,14.77 26.83,14.52 26.96,14.39 29.31,14.39 29.44,14.27 29.44,14.01 29.31,13.89 26.94,13.89 26.81,13.76 26.81,13.3 26.94,13.17 27.34,13.17 27.47,13.05 v5(27.47,12.13) 27.47,11.36 27.6,11.23 27.89,11.23 28.02,11.36 28.02,11.71 28.15,11.84 28.4,11.84 28.53,11.71 28.53,11.36 28.66,11.23 28.91,11.23 29.04,11.36 29.04,11.62 29.16,11.75 29.46,11.75 29.61,11.61 29.61,11.36 29.74,11.23 30.01,11.23 30.14,11.36 30.14,11.93 30.2,11.99 U1.5
SPI_PCH_CS0#_R: length 22.1
  TOP w0.102: v5(36.37,16.26) 36.49,16.37 v2(37.12,16.37)
  IN1 w0.097: v2(19.66,16.96) 20.66,17.96 23.05,17.96 23.56,18.47 35.03,18.47 v2(37.12,16.37)
  BOTTOM w0.102: R3.2 v2(19.66,16.96) ; U1.1 37.69,15.8 v2(37.12,16.37)
SPI_PCH_CS1#_R: length 21.6
  BOTTOM w0.102: U2.1 17.69,11.99 17.82,11.87 17.82,11.61 17.94,11.48 18.2,11.48 18.33,11.61 18.33,11.99 18.45,12.12 18.73,12.12 18.85,12.01 18.85,11.37 18.99,11.23 19.18,11.23 19.3,11.36 19.3,12.06 19.43,12.18 19.66,12.18 19.79,12.06 19.79,11.36 19.91,11.23 20.17,11.23 20.29,11.36 20.29,12.56 20.17,12.69 18.26,12.69 18.13,12.82 18.13,13.1 18.26,13.22 20.1,13.22 20.23,13.35 20.23,13.6 20.1,13.73 18.26,13.73 18.13,13.86 18.13,14.11 18.26,14.24 19.98,14.24 20.1,14.37 20.1,14.62 19.98,14.75 19.66,14.75 19.53,14.87 19.53,16.18 19.4,16.31 18.9,16.31 18.77,16.44 R14.2
SPI_PCH_DO2_32: length 23.5
  IN1 w0.097: v2(35.22,17.01) 33.98,18.25 23.69,18.25 23.18,17.74 20.75,17.74 20.17,17.15 20.17,16.82 19.85,16.5 18.77,16.5 18.58,16.31 18.58,15.41 v2(18.01,14.84)
  BOTTOM w0.102: R19.2 v2(35.22,17.01) ; v2(18.01,14.84) 17.7,14.53 U2.3 15.16,14.53 R23.1
SPI_PCH_DO2_64: length 262.3
  TOP w0.102: R8.1 166.91,106.55 170.3,109.94 v5(171.25,109.94) 173.17,109.94 v2(173.56,109.55)
  IN1 w0.097: v2(157.87,74.76) 158.44,75.33 158.44,78.9 161.74,82.19 167.2,82.19 167.68,81.72 168.28,81.72 169.01,82.45 169.01,83.45 171.14,85.59 171.14,86.36 171.89,87.11 173.2,87.11 174.28,88.19 174.28,90.44 175.29,91.45 175.29,106.62 174.21,107.7 174.21,108.9 v2(173.56,109.55) ; v2(36.93,17.63) 36.93,18.34 30.29,24.98 30.29,40.61 38.83,49.14 40.44,49.14 42.32,51.03 42.32,57.92 44.08,59.68 46.01,59.68 51.15,64.82 69.19,64.82 70.84,66.48 74.97,66.48 75.79,67.3 75.79,67.68 76.87,68.76 v2(76.87,68.98)
  IN3 w0.102: v2(157.87,74.76) 155.57,74.76 155.1,74.29 149.16,74.29 149.01,74.13 139.74,74.13 138.8,73.19 136.3,73.19 135.4,74.1 134.42,74.1 133.02,72.7 133.02,70.25 131.73,68.96 129.97,68.96 129.03,68.02 127.14,68.02 126.85,68.32 126.85,69.97 126.47,70.35 121.77,70.35 120.15,71.96 119.63,71.96 118.16,70.49 117.84,70.49 117.46,70.86 116.93,70.86 116.4,70.33 113.53,70.33 112.15,71.71 111.09,71.71 109.8,70.42 103.66,70.42 103.07,71.01 102.21,71.01 101.19,72.03 99.07,72.03 98.48,72.62 93.42,72.62 92.38,73.66 90.2,73.66 89.83,73.29 89.83,72.84 88.62,71.64 87.34,71.64 86.69,72.29 83.45,72.29 82.74,71.59 79.49,71.59 76.89,68.98 v2(76.87,68.98)
  BOTTOM w0.102: U1.3 36.83,13.26 36.7,13.14 36.7,11.48 36.57,11.36 36.32,11.36 36.19,11.48 36.19,13.45 36.07,13.58 35.81,13.58 35.68,13.45 35.68,11.48 35.56,11.36 35.3,11.36 35.18,11.48 35.18,14.15 35.3,14.28 36.49,14.28 36.61,14.4 36.61,14.66 36.49,14.79 35.25,14.79 35.15,14.89 35.15,15.19 35.25,15.29 36.49,15.29 36.61,15.42 36.61,15.67 36.49,15.8 35.25,15.8 35.15,15.9 35.15,16.21 35.25,16.31 36.07,16.31 36.17,16.41 R6.2 v2(36.93,17.63)
SPI_PCH_DO3_32: length 21.9
  IN1 w0.097: v2(22.83,13.26) 24.93,13.26 25.12,13.45 25.12,14.31 25.25,14.44 28.55,14.44 28.68,14.31 28.68,13.52 28.83,13.37 30.87,13.37 30.96,13.46 30.96,14.18 31.06,14.28 31.35,14.28 31.44,14.18 31.44,13.46 31.54,13.37 31.83,13.37 31.93,13.46 31.93,14.18 32.02,14.28 32.31,14.28 32.41,14.18 32.41,13.46 32.51,13.37 33.52,13.37 33.67,13.52 33.67,15.1 33.54,15.23 v2(33.12,15.23)
  BOTTOM w0.102: R16.1 33.31,16.76 33.12,16.56 v2(33.12,15.23) ; v2(22.83,13.26) U2.7
SPI_PCH_DO3_64: length 22.1
  BOTTOM w0.102: R5.1 34.26,16.95 34.39,16.82 34.63,16.82 34.76,16.69 34.76,16.42 34.63,16.3 33.67,16.3 33.54,16.17 33.54,15.92 33.67,15.79 34.63,15.79 34.76,15.66 34.76,15.41 34.63,15.28 33.96,15.28 33.84,15.15 33.84,14.9 33.96,14.77 34.83,14.77 34.95,14.65 34.95,14.2 34.83,14.07 33.35,14.07 33.25,13.97 33.25,13.67 33.35,13.56 v2(34.23,13.56) 34.82,13.56 34.95,13.44 34.95,13.14 34.82,13.01 33.37,13.01 33.25,12.89 33.25,12.63 33.37,12.51 34.82,12.51 34.95,12.38 34.95,12.06 34.82,11.93 32.55,11.93 32.42,12.06 32.42,14.41 32.3,14.53 U1.7
SPI_WP#_SEL: length 233.7
  TOP w0.102: U37.A12 165.73,103.7 v2(165.65,103.79) v1(166.16,104.3) 166.6,104.74 166.6,104.88 R8.2
  IN2 w0.102: v2(77.63,81.84) 76.05,80.26 76.05,73.46 76.33,73.17 77.79,73.17 78.1,72.86 78.1,69.49 77,68.38 74.84,68.38 74.01,67.56 72.55,67.56 70.24,65.24 42.68,65.24 35.38,57.94 35.38,52.1 32.74,49.46 24.04,49.46 21.44,46.85 21.44,23.49 16.48,18.53 16.48,17.71 v2(15.15,16.12)
  IN3 w0.102: v2(77.63,81.84) 78.21,82.41 79.73,82.41 82.27,84.95 88.68,84.95 90.3,86.57 93.65,86.57 94.24,87.15 94.81,87.15 95.09,86.87 99.49,86.87 100.59,85.78 101.63,85.78 102.34,86.48 105.07,86.48 105.83,87.24 109.29,87.24 109.62,86.91 111.06,86.91 111.39,87.24 116.47,87.24 116.63,87.41 117.47,87.41 117.59,87.28 117.93,87.28 118.17,87.52 118.17,87.64 119.01,88.48 121.03,88.48 121.08,88.44 130.15,88.44 130.9,87.68 135,87.68 135.73,88.41 141.04,88.41 141.66,87.79 150.1,87.79 152.38,85.51 157.19,85.51 158.28,84.42 162.08,84.42 162.77,85.11 162.77,85.64 163.89,86.77 163.89,88.2 165.69,90 165.69,92.02 166.62,92.96 166.62,96.97 166.79,97.14 166.79,101.7 165.65,102.85 v2(165.65,103.79)
  BOTTOM w0.102: R23.2 v2(15.15,16.12)
SPKR: length 240
  IN1 w0.097: v2(118.09,71.79) 119.58,73.29 119.58,75.09 120.06,75.57 120.06,79.29 120.76,79.99 122.82,79.99 123.69,80.86 126.11,80.86 128.18,82.94 128.18,83.63 133.32,88.78 133.32,90.01 133.8,90.49 133.8,92.36 135.7,94.26 135.7,94.8 136.54,95.64 136.54,99.01 137.33,99.81 137.33,102.54 137.74,102.95 137.74,106.09 138.16,106.5 139.03,106.5 139.88,107.35 139.88,109.46 137.83,111.5 137.83,115.22 v2(137.62,115.43)
  IN3 w0.102: v2(256.37,164.39) 255.93,164.84 238.25,164.84 237.41,164 229.63,164 227.8,162.17 222.63,162.17 218.63,158.17 194.03,158.17 192.46,156.6 192.46,154.34 190.46,152.33 190.46,150.7 187.55,147.79 187.55,145.85 187.04,145.34 187.04,134.8 189.65,132.2 189.65,124.39 190.21,123.82 190.21,116.51 189.36,115.65 v2(189.36,114.16)
  BOTTOM w0.076: UC1.V2 116.75,66.8 116.46,67.09 116.46,67.15 116.17,67.44 116.17,68.46 115.99,68.63 115.99,69.21 115.95,69.25 115.95,69.84
  BOTTOM w0.102: RC222.2 119.68,72.95 119.35,72.95 118.19,71.79 v2(118.09,71.79) 117.99,71.79 117.46,71.26 116.83,71.26 115.95,70.38 115.95,69.84 ; R387.2 v2(256.37,164.39) ; v2(137.62,115.43) 138,115.82 v1(138.85,115.82) 146.49,115.82 146.58,115.73 151.03,115.73 151.53,116.22 158.53,116.22 159.49,115.26 159.49,114.5 159.73,114.27 164.15,114.27 165.65,112.77 165.65,111.31 167.3,109.66 169.16,109.66 169.33,109.49 172.82,109.49 173.52,110.19 175.97,110.19 176.31,110.53 176.31,111.18 179.12,113.98 188.9,113.98 189.08,114.16 v2(189.36,114.16)
SRCDET: length 4.8
  TOP w0.102: R69.1 116.43,97.27 v1(117.63,98.47) 117.96,98.8 117.96,99.93 118.15,100.12 118.15,100.54 U6.C2
SRN_B: length 17.9
  TOP w0.254: v2(110.65,150.55) 110.65,150.05 PC426.1 110.54,149.89 PC425.2 110.84,148.72 110.84,147.13 PU402.13 ; PR426.2 116.94,161.22 116.65,160.93 v2(116.65,160.84)
  IN1 w0.254: v2(110.65,150.55) 110.78,150.68 110.78,152.39 116.75,158.36 116.75,160.74 v2(116.65,160.84)
SRP_B: length 17.8
  TOP w0.254: v2(117.25,160.84) 117.25,160.7 116.94,160.39 PR426.3 ; PU402.12 111.35,147.14 111.35,148.91 PC427.1 111.47,149.88 PC426.2 111.29,150.05 v2(111.29,150.55)
  IN1 w0.254: v2(117.25,160.84) 117.13,160.72 117.13,158.17 111.16,152.2 111.16,150.68 v2(111.29,150.55)
SRTCRST#: length 30.7
  TOP w0.102: v2(128.16,63.46) 128.32,63.62 128.32,65.83 131.19,68.7 132.12,68.7 132.63,69.21 133.07,69.21 133.73,69.87 135.49,69.87 136.18,70.56 136.18,71.11 138.66,73.59 v1(141.67,73.59) 145.96,73.59 147.48,72.06 v2(147.48,70.86)
  BOTTOM w0.076: UC1.AV6 127.86,63.76 v2(128.16,63.46)
  BOTTOM w0.102: RC8.2 CC3.2 147.71,72.99 ME1.2 147.48,71.71 v2(147.48,70.86)
STRAP0: length 6
  BOTTOM w0.102: v1(75.04,91.99) 75.29,91.75 RV2654.1 RV2653.2 75.5,93.3 73.47,93.3 72.92,92.75 UV1.D1
STRAP1: length 5.5
  BOTTOM w0.102: RV2650.1 RV2649.2 73.31,93.59 72.87,93.15 72.32,93.15 71.92,92.75 UV1.D2
STRAP2: length 4.9
  TOP w0.102: v2(69.82,93.15) 69.25,93.15 68.99,93.41 RV2647.2 RV2648.1 68.49,94.67 v1(67.97,94.15)
  BOTTOM w0.102: UV1.E4 69.82,92.35 v2(69.82,93.15)
STRAP3: length 6.4
  TOP w0.254: v2(74.57,92.66) 74.57,92.95 v1(74.84,93.22) 74.95,93.34 RV2651.2 RV2652.1
  BOTTOM w0.102: v2(74.57,92.66) 74.17,92.26 72.96,92.26 72.87,92.34 71.51,92.34 UV1.E3
STRAP4: length 8.6
  BOTTOM w0.102: v1(75.83,97.37) 75.83,96.79 76.1,96.53 RV94.1 RV93.2 74.59,95.37 73.17,93.95 71.64,93.95 71.47,93.78 71.47,93.16 UV1.D3
STRAPREF0: length 3.1
  TOP w0.102: v1(67.4,92.17) 68.08,91.48 v4(68.94,91.48) 69.11,91.65 RV2723.1
  BOTTOM w0.127: UV1.F6 68.57,91.11 v4(68.94,91.48)
STSTART_DCBLOCK_GC: length 37.1
  TOP w0.254: v2(127.29,139.95) 127.02,139.67 PU701.16 ; PR513.2 145.07,160.25 v2(145.07,159.88)
  IN3 w0.254: v2(145.07,159.88) 145.07,158.42 144.69,158.04 141.45,158.04 140.63,157.22 140.63,146.8 134.91,141.09 132.53,141.09 130.13,138.69 128.55,138.69 v2(127.29,139.95)
  BOTTOM w0.102: v2(145.07,159.88) 145.07,160.46 145.2,160.58 v1(145.21,160.58)
SUS_ON: length 194.1
  TOP w0.102: v2(174.22,100.97) 174.96,101.72 R308.2 ; v2(166.23,84.34) 167.39,84.34 v5(167.56,84.17) 168.87,82.86 PR108.1 ; v2(83.86,25.84) 83.62,25.84 R422.1 ; U37.B60 171.8,97.59 171.64,97.75 170.97,97.75 v2(170.39,97.17)
  IN2 w0.102: v2(166.23,84.34) 166.05,84.51 164.2,84.51 162.22,82.53 162.22,81.66 160.03,79.48 160.03,76.12 159.28,75.37 159.28,71.53 158.38,70.63 158.38,65.32 157.34,64.28 157.34,51.07 156.2,49.93 156.2,19.07 150.99,13.86 139.97,13.86 138.91,14.91 130.21,14.91 129.07,16.06 122.06,16.06 121.04,15.04 114.97,15.04 114.38,14.44 113.41,14.44 112.81,15.05 103.57,15.05 102.61,14.09 99.7,14.09 99.36,14.43 99.36,18.03 96.44,20.95 94.08,20.95 90.78,24.25 86.71,24.25 85.13,25.84 v2(83.86,25.84)
  IN3 w0.102: v2(170.39,97.17) 170.38,97.17 170.58,97.37 170.58,97.64 172.19,99.24 172.19,99.99 173.17,100.97 v2(174.22,100.97) ; v2(176.12,95.27) 175.97,95.27 175.72,95.01 175.72,93.95 173.93,92.16 170.29,92.16 169.26,91.13 169.26,89.75 168.15,88.64 168.15,86.26 v2(166.23,84.34)
  BOTTOM w0.102: v2(170.39,97.17) 170.8,96.76 172.01,96.76 172.98,95.79 174.5,95.79 175.02,95.27 v2(176.12,95.27)
SUS_STAT#/LPCPD#: length 19.6
  TOP w0.102: RC74.2 117.61,81.13 117.91,80.84 v1(117.91,80.59) 117.91,79.97 v2(117.64,79.71)
  IN2 w0.076: v2(121.62,65.56) 122.04,65.98 122.04,66.92 121.64,67.33 121.64,69.14 121.2,69.58 121.01,69.58 120.81,69.78 120.81,69.84
  IN2 w0.102: 120.81,69.84 120.81,69.84 120.81,71.71 120.45,72.08 120.45,73.24 117.65,76.04 117.65,76.31 117.03,76.93 117.03,78.14 117.64,78.76 v2(117.64,79.71)
  BOTTOM w0.076: UC1.AG4 121.32,65.26 v2(121.62,65.56)
SUSACK#: length 88.4
  TOP w0.102: v1(158.75,76.11) 158.56,76.11 v2(157.97,76.71) ; v2(174.23,98.9) 173.67,98.34 U37.A58
  IN1 w0.097: v2(157.97,76.71) 157.97,79.09 158.7,79.83 158.7,79.86 161.83,82.98 162.59,82.98 163.84,84.23 165.73,84.23 166.08,83.87 167.78,83.87 169.93,86.03 169.93,88.22 170.22,88.51 170.82,88.51 172.67,90.36 172.67,91.32 174.21,92.85 174.21,98.87 v2(174.23,98.9)
  IN3 w0.102: v2(117.66,77.52) 117.31,77.52 115.67,79.16 115.67,79.98 115.98,80.28 116.86,80.28 116.99,80.15 121.82,80.15 122.49,80.83 131.23,80.83 131.95,81.55 132.49,81.55 132.99,82.06 133.43,82.06 134.21,81.27 138.1,81.27 139,82.17 140.55,82.17 141.22,82.85 148.39,82.85 150.6,80.64 153.64,80.64 153.96,80.32 153.96,77.7 154.96,76.71 v2(157.97,76.71)
  BOTTOM w0.102: RC98.2 RC86.1 117.63,77.56 v2(117.66,77.52)
SUSACK#_R: length 30.3
  IN2 w0.076: v2(122.77,68.27) 122.54,68.27 122.02,68.8 122.02,69.84
  IN2 w0.102: v2(118.27,77.52) 117.96,77.21 117.96,76.65 118.1,76.5 118.1,76.23 120.9,73.43 120.9,72.27 122.02,71.15 122.02,69.84
  IN3 w0.102: v2(118.27,77.52) 118.77,78.02 122.07,78.02 123.26,79.21 128.95,79.21 129.64,78.52 129.64,78.02 130.45,77.21 v2(130.45,77.14)
  BOTTOM w0.076: UC1.AK2 123.05,66.87 123.05,67.4 123.18,67.52 123.18,67.87 v2(122.77,68.27)
  BOTTOM w0.102: v2(118.27,77.52) 118.54,77.79 RC86.2 ; v2(130.45,77.14) 130.45,77.51 v1(130.65,77.71) 130.92,77.98 RC82.2
SW1: length 13.5
  IN3 w1.016: 202.03,149.22 199.81,151.44 195.74,151.44 191.3,146.99
  vias: v1(206.44,146.07) v2(190.29,146.09) v2(190.29,145.51) v2(202.54,148.33) v2(202.54,147.69) v2(202.54,147.06) v2(203.17,148.33) v2(203.17,147.69) v2(203.17,147.06) v2(204.7,146.99) v2(204.7,146.36) v2(204.7,144.64) v2(204.7,144.01) v2(204.7,143.37) v2(204.7,142.74)
SW2: length 11.4
  IN3 w1.016: 201.4,137.09 193.14,137.09 190.92,139.31
  vias: v1(205.36,137.48) v2(190.41,140.66) v2(190.41,140.07) v2(202.54,137.41) v2(202.54,136.77) v2(202.54,136.14) v2(202.98,138.68) v2(203.17,137.41) v2(203.17,136.77) v2(203.17,136.14) v2(203.62,138.68) v2(204.25,138.68) v2(204.63,139.88) v2(204.63,139.25) v2(204.89,138.68) v2(205.27,139.88) v2(205.27,139.25)
SW_1.35V: length 4.1
  TOP w1.016: 178.47,76.7 178.98,76.19 182.39,76.19
  vias: v1(184.48,76.11) v2(183.74,76.83) v2(183.74,76.19)
SW_++VDDRP: length 11.7
  TOP w1.016: 44.04,37.27 44.04,32 43.47,31.42 41.06,31.42
  BOTTOM w0.102: v1(40.97,28.78) 39.98,29.77 PC704.2
  BOTTOM w0.254: PU700.8 39.09,31.04 v2(39.15,31.11)
  vias: v2(39.79,31.11) v2(43.6,38.6) v2(44.21,38.6)
SW_+V1.05SP: length 3
  TOP w0.102: v1(145.73,80.2) 147.4,80.2 148.3,79.3 PC164.2
  vias: v2(149.45,79.94)
SW_DPB_AUX: length 53.3
  TOP w0.089: U6.J13 122.53,108.01 122.68,108.15 122.68,108.82 122.58,108.92 122.58,109.12 122.72,109.26 v2(122.92,109.26) 123.56,109.9 v1(123.56,110.79) 123.56,111.56 R47.1 ; v2(144.92,139.75) 144.74,139.57 144.74,139.36 145.7,138.4 145.7,136.95 145.97,136.68 146.66,136.68 146.81,136.83 146.81,136.92 C94.2
  IN1 w0.089: v2(144.92,139.75) 144.73,139.56 144.73,139.2 144.46,138.93 141.48,138.93 140.13,137.58 139.45,137.58 136.09,134.23 135.07,134.23 130.54,129.7 130.24,129.7 123.79,123.26 123.79,113.18 123.99,112.98 123.99,110.11 123.45,109.57 123.22,109.57 v2(122.92,109.26)
SW_DPB_AUX#: length 52.3
  TOP w0.089: R44.1 123.29,111.33 123.01,111.05 123.01,109.99 v2(122.92,109.9) 122.37,109.35 U6.J14 ; C95.2 147.2,137.24 147.2,136.67 146.82,136.29 145.81,136.29 145.31,136.78 145.31,138.23 144.35,139.2 144.35,139.75 v2(144.34,139.75)
  IN1 w0.089: v2(122.92,109.9) 123.32,109.9 123.66,110.24 123.66,112.84 123.46,113.04 123.46,123.39 130.1,130.03 130.41,130.03 134.93,134.56 135.95,134.56 139.31,137.91 139.99,137.91 141.34,139.26 144.32,139.26 144.4,139.34 144.4,139.7 v2(144.34,139.75)
SW_DPB_AUX#_C: length 2.5
  TOP w0.089: C95.1 148.06,138.24 v1(148.22,138.41) 148.26,138.45 U11.5
SW_DPB_AUX_C: length 2.2
  TOP w0.089: U11.2 146.31,138.95 146.41,138.85 146.74,138.85 146.82,138.76 146.82,138.66 C94.1
SW_DPC_AUX: length 65.9
  TOP w0.089: U6.B11 117.46,106.35 117.07,106.35 116.06,107.36 115.92,107.36 v2(115.8,107.23) 114.4,107.23 R92.1 ; v2(144.6,138.1) 144.4,137.91 144.4,137.57 144.69,137.29 144.69,136.52 145.26,135.94 145.6,135.6 150.46,135.6 150.97,136.12 152.02,136.12 152.87,136.97 152.87,137.27 C98.2
  IN1 w0.089: v2(144.6,138.1) 144.42,137.93 144.42,137.58 144.12,137.28 141.17,137.28 140.47,136.57 139.75,136.57 137.77,134.59 137.77,134.25 136.82,133.3 135.45,133.3 126.59,124.44 126.59,122.09 125.13,120.62 125.13,110.73 124.76,110.37 124.76,109.48 123.34,108.06 117.78,108.06 117.08,107.36 115.92,107.36 v2(115.8,107.23)
SW_DPC_AUX#: length 65.8
  TOP w0.089: U6.A11 117.17,106.81 116.23,107.75 115.86,107.75 v2(115.8,107.81) 115.61,107.62 114.03,107.62 R91.1 ; C99.2 153.27,137.34 153.27,136.81 v1(152.96,136.5) 152.18,135.72 151.14,135.72 150.62,135.21 145.44,135.21 144.98,135.67 144.3,136.35 144.3,137.13 144.01,137.41 v2(144.01,138.1)
  IN1 w0.089: v2(115.8,107.81) 115.92,107.69 116.94,107.69 117.64,108.39 123.2,108.39 124.43,109.61 124.43,110.5 124.8,110.87 124.8,120.76 126.26,122.23 126.26,124.58 135.31,133.63 136.68,133.63 137.44,134.39 137.44,134.73 139.61,136.9 140.33,136.9 141.04,137.61 143.98,137.61 144.09,137.72 144.09,138.02 v2(144.01,138.1)
SW_DPC_AUX#_C: length 1.8
  TOP w0.089: U13.5 153.85,139.11 153.95,139.01 153.95,138.75 153.69,138.5 C99.1
SW_DPC_AUX_C: length 1.8
  TOP w0.089: C98.1 151.9,139.16 U13.2
SW_LAN_TX0+: length 139.6
  TOP w0.089: v2(180.73,160.47) 180.77,160.42 U23.38
  IN1 w0.089: v2(180.73,160.47) 180.73,162.99 181.95,164.21 184.62,164.21 185.07,164.66 186.15,164.66 188.06,166.03 212.62,166.03 213.48,166.89 223.32,166.89 229.01,172.58 239.79,172.58 240.37,173.16 265.66,173.16 270.55,168.27 285.72,168.27 288.97,165.02 v2(288.97,163.25)
  BOTTOM w0.089: v2(288.97,163.25) 288.97,163.78 289.25,164.06 291.4,164.06 292.23,163.24 303.3,163.24 303.52,163.45 304.72,163.45 304.77,163.4 JIO1.17
SW_LAN_TX0-: length 139.6
  TOP w0.089: U23.37 181.27,160.02 181.16,160.13 181.16,160.32 v2(181.31,160.47)
  IN1 w0.089: v2(181.31,160.47) 181.06,160.72 181.06,162.85 182.09,163.88 184.76,163.88 185.2,164.33 186.25,164.33 188.16,165.7 212.75,165.7 213.62,166.56 223.46,166.56 229.15,172.25 239.93,172.25 240.5,172.83 265.52,172.83 270.41,167.94 285.59,167.94 288.64,164.88 288.64,163.5 288.63,163.49 v2(288.39,163.25)
  BOTTOM w0.089: JIO1.15 304.77,163.9 304.72,163.85 303.35,163.85 303.14,163.63 292.39,163.63 291.57,164.46 289.09,164.46 288.58,163.95 288.58,163.43 288.4,163.25 v2(288.39,163.25)
SW_LAN_TX1+: length 135.1
  TOP w0.089: U23.34 182.77,160.42 v2(182.73,160.47)
  IN1 w0.089: v2(182.73,160.47) 182.73,161.6 182.84,161.71 182.84,162.62 183.3,163.08 190.42,163.08 192.11,164.77 212.96,164.77 213.8,165.61 225.01,165.61 228.49,169.09 234.71,169.09 235.98,170.36 244.16,170.36 244.93,171.14 264.95,171.14 265.21,170.88 265.79,170.88 269.54,167.14 272.95,167.14 273.72,166.36 279.69,166.36 281.98,164.08 284.71,164.08 285.98,162.81 286.4,162.81 286.5,162.91 v2(286.5,163.25)
  BOTTOM w0.089: v2(286.5,163.25) 286.5,162.62 287.22,161.9 JIO1.23
SW_LAN_TX1-: length 135.1
  TOP w0.089: v2(183.31,160.47) 183.16,160.32 183.16,160.14 183.27,160.03 U23.33
  IN1 w0.089: v2(183.31,160.47) 183.29,160.47 183.06,160.7 183.06,161.46 183.17,161.58 183.17,162.49 183.44,162.75 190.56,162.75 192.25,164.44 213.1,164.44 213.94,165.28 225.14,165.28 228.62,168.76 234.85,168.76 236.12,170.03 244.29,170.03 245.07,170.81 264.82,170.81 265.07,170.55 265.66,170.55 269.4,166.81 272.81,166.81 273.59,166.03 279.55,166.03 281.84,163.74 284.57,163.74 285.84,162.47 286.54,162.47 286.9,162.83 286.9,163.09 287.12,163.31 v2(287.15,163.31)
  BOTTOM w0.089: JIO1.21 305.6,162.4 305.49,162.29 287.38,162.29 286.96,162.72 286.96,163.19 287.09,163.31 v2(287.15,163.31)
SW_LAN_TX2+: length 130.9
  TOP w0.089: v2(185.2,160.96) 185.27,160.9 U23.29
  IN1 w0.089: v2(185.2,160.96) 185.38,161.14 185.38,161.52 185.81,161.95 190.89,161.95 192.58,163.64 225.2,163.64 228.5,166.95 234.17,166.95 236.38,169.16 263.76,169.16 267.69,165.22 272.01,165.22 272.58,164.65 279.18,164.65 281.22,162.61 284.2,162.61 285.33,161.48 288.13,161.48 288.51,161.87 290.6,161.87 290.92,161.55 290.92,160.67 v2(290.94,160.65)
  BOTTOM w0.089: JIO1.29 304.71,160.4 304.67,160.44 303.77,160.44 303.52,160.7 290.99,160.7 v2(290.94,160.65)
SW_LAN_TX2-: length 130.7
  TOP w0.089: v2(185.81,160.97) 185.66,160.83 185.66,160.13 185.77,160.02 U23.28
  IN1 w0.089: v2(290.36,160.65) 290.59,160.87 290.59,161.41 290.46,161.54 288.64,161.54 288.26,161.15 285.19,161.15 284.06,162.28 281.08,162.28 279.05,164.32 272.44,164.32 271.87,164.89 267.56,164.89 263.62,168.82 236.52,168.82 234.31,166.62 228.64,166.62 225.33,163.31 192.72,163.31 191.03,161.62 185.95,161.62 185.71,161.39 185.71,161.07 v2(185.81,160.97)
  BOTTOM w0.089: v2(290.36,160.65) 290.8,161.09 303.68,161.09 303.94,160.84 304.71,160.84 304.77,160.9 JIO1.27
