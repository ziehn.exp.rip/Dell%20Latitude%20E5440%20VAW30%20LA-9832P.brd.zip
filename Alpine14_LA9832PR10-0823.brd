# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD25: length 57.4
  TOP w0.102: UV5.N2 31.66,93.71 31.66,93.2 30.82,92.36 30.82,91.96 30.41,91.55 v2(30.41,91.39) ; UV7.N2 31.67,77.96 31.67,77.45 30.83,76.61 30.83,76.21 30.43,75.8 v2(30.43,75.64)
  IN1 w0.114: v2(30.31,83.11) 30.69,82.73 34.28,82.73 34.91,83.37 36.36,83.37 36.56,83.56 37.63,83.56 37.79,83.4 42.47,83.4 42.84,83.76 42.84,84.4 46.99,88.55 53.51,88.55 53.89,88.17 v4(54.07,88.17)
  IN3 w0.091: v2(30.41,91.39) 30.3,91.28 30.3,87.74 30.17,87.61 30.17,86.12 30.62,85.68 30.62,84.72 30.71,84.62 30.71,83.71 30.31,83.31 v2(30.31,83.11) 30.31,80.89 30.23,80.81 30.23,80.58 29.66,80.01 29.66,78.22 30.81,77.07 30.81,76.02 v2(30.43,75.64)
  BOTTOM w0.102: v2(30.41,91.39) 30.69,91.11 31.03,91.11 31.66,90.48 31.66,89.72 32.06,89.32 UV4.N2 ; UV6.N2 32.07,73.57 31.67,73.97 31.67,74.73 31.04,75.36 30.71,75.36 v2(30.43,75.64)
  BOTTOM w0.122: v4(54.07,88.17) UV1.J23
FBA_CMD26: length 46.9
  TOP w0.102: v2(32.79,75.69) 32.79,75.78 33.2,76.19 33.2,76.76 32.87,77.09 UV7.M3 ; v2(32.78,91.44) 32.78,91.53 33.18,91.94 33.18,92.51 32.86,92.84 UV5.M3
  IN3 w0.091: v2(32.78,91.44) 32.61,91.28 32.61,89.57 32.1,89.06 32.1,87.87 32.29,87.68 32.29,86.87 34.27,84.9 v2(34.27,83.79) 34.27,83.2 33.31,82.25 33.31,80.11 32.1,78.9 32.1,78.19 33.2,77.09 33.2,76.1 v2(32.79,75.69)
  BOTTOM w0.102: v2(32.79,75.69) 32.87,75.61 UV6.M3 ; UV4.M3 32.86,91.36 v2(32.78,91.44)
  BOTTOM w0.122: UV1.J25 52.87,88.59 52.44,89.02 48.92,89.02 44.13,84.23 37.69,84.23 37.03,83.57 36.56,83.57 36.33,83.34 v1(35.79,83.34) 34.73,83.34 v2(34.27,83.79)
FBA_CMD27: length 58.1
  TOP w0.102: UV7.N8 32.43,73.92 32.43,75.17 32.38,75.22 32.38,75.83 32.79,76.23 v2(32.79,76.33) ; v2(32.78,92.08) 32.78,91.98 32.37,91.58 32.37,90.97 32.42,90.92 32.42,89.78 32.06,89.42 UV5.N8
  IN1 w0.114: v2(32.83,81.46) 33.75,82.39 35.19,82.39 35.54,82.74 42.3,82.74 43.18,83.62 43.18,84.26 47.01,88.09 53.19,88.09 v4(53.27,88.17)
  IN3 w0.091: v2(32.78,92.08) 32.4,91.7 32.4,89.69 31.9,89.19 31.9,86.8 33.86,84.83 33.86,83.27 32.83,82.23 v2(32.83,81.46) 32.83,81.26 32.66,81.09 32.66,80.95 32.84,80.76 33.11,80.5 33.11,80.33 32.99,80.21 32.82,80.21 32.37,80.66 32.23,80.66 32.08,80.52 32.08,80.37 32.6,79.85 32.6,79.69 32.48,79.57 32.31,79.57 31.8,80.08 31.65,80.08 31.32,79.75 31.32,78 31.63,77.69 31.78,77.69 31.95,77.86 32.1,77.86 32.24,77.72 32.24,77.58 32.06,77.4 32.06,77.25 32.21,77.11 32.35,77.11 32.53,77.29 32.67,77.29 32.82,77.14 32.82,77 32.64,76.82 32.64,76.68 32.79,76.53 v2(32.79,76.33)
  BOTTOM w0.102: v2(32.79,76.33) 32.43,76.68 32.43,78 UV6.N8 ; v2(32.78,92.08) 32.42,92.43 32.42,93.75 UV4.N8
  BOTTOM w0.122: v4(53.27,88.17) UV1.J24
FBA_CMD28: length 47.2
  TOP w0.102: UV7.N7 32.07,74.84 31.61,75.3 31.61,75.81 32,76.2 v2(32,76.34) ; UV5.N7 32.06,90.59 31.6,91.05 31.6,91.56 31.99,91.95 v2(31.99,92.09)
  IN3 w0.091: v2(31.99,92.09) 31.58,91.68 31.58,90.53 31.49,90.44 31.49,87.85 31.24,87.6 31.24,86.52 32.87,84.89 v2(32.87,84.15) 32.87,83.21 31.48,81.82 31.48,80.68 30.95,80.15 30.69,80.15 30.3,79.76 30.3,78.44 32,76.74 v2(32,76.34)
  BOTTOM w0.102: UV6.N7 32.07,76.41 v2(32,76.34) ; v2(31.99,92.09) 32.06,92.16 UV4.N7
  BOTTOM w0.122: UV1.K27 49.27,87.77 v1(46.42,84.92) 44.14,82.64 38.08,82.64 37.79,82.36 35.06,82.36 33.7,83.71 33.29,83.71 32.87,84.12 v2(32.87,84.15)
FBA_CMD29: length 47.1
  TOP w0.102: v2(34.35,92.06) 34.35,91.92 33.96,91.53 33.96,91.06 33.66,90.76 UV5.L7 ; v2(34.36,76.31) 34.36,76.17 33.97,75.78 33.97,74.66 UV7.L7
  IN3 w0.091: v2(34.35,92.06) 34.23,92.06 33.96,91.79 33.96,91.28 33.32,90.65 33.32,88.72 33.9,88.15 33.9,86.23 35.08,85.05 v2(35.08,82.92) 34.92,82.92 34.59,82.59 34.59,82.45 34.72,82.33 34.88,82.33 35,82.2 35,81.99 34.88,81.87 34.87,81.87 34.27,81.87 34.14,81.74 34.14,81.53 34.27,81.4 34.41,81.4 34.54,81.27 34.54,80.41 33.53,79.4 33.53,77.85 34.36,77.02 v2(34.36,76.31)
  BOTTOM w0.102: v2(34.35,92.06) 33.66,92.76 UV4.L7 ; v2(34.36,76.31) 33.67,77.01 UV6.L7
  BOTTOM w0.122: v2(35.08,82.92) 35.27,82.73 37.63,82.73 37.92,83.02 v1(38.9,83.02) 43.98,83.02 49.14,88.18 52.46,88.18 UV1.K25
FBA_CMD30: length 49.8
  TOP w0.102: v2(36,92.22) 36.17,92.05 36.32,92.05 36.45,92.18 36.45,92.82 36.32,92.95 36.12,92.95 35.99,92.82 35.99,92.74 35.92,92.67 35.68,92.67 35.56,92.79 35.56,93.18 35.43,93.31 UV5.J3 ; UV7.J3 35.44,77.56 35.57,77.43 35.57,77.04 35.7,76.92 35.94,76.92 36.01,76.99 36.01,77.07 36.13,77.2 36.33,77.2 36.46,77.07 36.46,76.43 36.33,76.3 36.18,76.3 v2(36.01,76.47)
  IN3 w0.091: v2(36,92.22) 35.81,92.22 35.63,92.04 35.63,91.36 34.51,90.24 34.51,88.7 35.06,88.14 35.06,87.8 35.46,87.4 35.46,86.61 36.79,85.27 v2(36.79,83.15) 36.79,82.05 36.09,81.35 36.09,80.66 34.49,79.06 34.49,78.08 36.01,76.55 v2(36.01,76.47)
  BOTTOM w0.102: v2(36,92.22) 36.41,91.81 36.41,90.95 36.31,90.85 35.47,90.85 35.26,90.64 UV4.J3 ; v2(36.01,76.47) 36.42,76.06 36.42,75.2 36.32,75.1 35.52,75.1 35.17,74.75 35.17,74.46 UV6.J3
  BOTTOM w0.122: UV1.J27 49,88.57 v1(48.02,87.58) 44.26,83.82 43.95,83.82 43.83,83.7 43.83,83.52 43.7,83.4 43.46,83.4 43.33,83.52 43.33,83.73 43.21,83.85 42.96,83.85 42.84,83.73 42.84,83.52 42.72,83.4 40.68,83.4 40.56,83.52 40.56,83.73 40.44,83.85 40.19,83.85 40.07,83.73 40.07,83.52 39.95,83.4 37.68,83.4 37.44,83.15 v2(36.79,83.15)
FBA_D0: length 31
  IN3 w0.114: v4(59.07,92.36) 59.08,92.37 59.08,95.08 56.27,97.9 51.1,97.9 47.4,94.2 45.78,94.2 45.66,94.32 45.66,94.81 45.54,94.94 45.3,94.94 45.18,94.81 45.18,94.32 45.05,94.2 44.81,94.2 44.69,94.32 44.69,94.81 44.57,94.94 43,94.94 42.19,94.13 40.18,94.13 39.34,94.96 37.74,94.96 v2(37.31,94.53)
  BOTTOM w0.102: v2(37.31,94.53) 37.66,94.18 UV4.F8
  BOTTOM w0.122: v4(59.07,92.36) 59.06,92.36 58.65,91.95 UV1.E18
FBA_D1: length 32.5
  IN3 w0.114: v2(38.01,93.7) 38.43,93.29 39.18,93.29 39.39,93.5 44.21,93.5 44.33,93.38 44.33,92.8 44.45,92.67 44.69,92.67 44.81,92.8 44.81,93.38 44.94,93.5 45.18,93.5 45.3,93.38 45.3,92.8 45.43,92.67 45.66,92.67 45.79,92.8 45.79,93.38 45.91,93.5 46.16,93.5 46.28,93.38 46.28,92.8 46.4,92.67 46.64,92.67 46.77,92.8 46.77,93.38 46.89,93.5 47.69,93.5 51.37,97.18 55.46,97.18 56.55,96.09 56.55,95.56 58.01,94.1 58.01,91.76 v4(59.08,90.69)
  BOTTOM w0.102: UV4.F7 37.66,93.35 v2(38.01,93.7)
  BOTTOM w0.122: UV1.F18 58.65,91.12 v4(59.08,90.69)
FBA_D2: length 32.5
  IN3 w0.114: v2(36.42,94.54) 36.42,95.02 37.28,95.89 48.59,95.89 51.15,98.44 57.71,98.44 60.32,95.83 60.32,91.98 v4(59.91,91.56)
  BOTTOM w0.102: 60.31,91.95 60.3,91.95 v4(59.91,91.56) ; v2(36.42,94.54) 36.42,94.52 36.06,94.16 UV4.H8
  BOTTOM w0.122: UV1.E16 60.31,91.95
FBA_D3: length 32.8
  IN3 w0.114: v2(35.69,93.7) 36.08,94.1 39.44,94.1 39.69,93.85 42.63,93.85 42.75,93.97 42.75,94.37 42.88,94.5 43.11,94.5 43.24,94.37 43.24,93.97 43.36,93.85 43.61,93.85 43.73,93.97 43.73,94.46 43.85,94.59 44.09,94.59 44.22,94.46 44.22,93.97 44.34,93.85 47.54,93.85 51.23,97.54 56.04,97.54 58.42,95.16 58.42,92.17 v4(59.07,91.52)
  BOTTOM w0.102: UV4.H7 36.06,93.33 v2(35.69,93.7)
  BOTTOM w0.122: v4(59.07,91.52) 59.09,91.52 59.49,91.11 UV1.F17
FBA_D4: length 28.8
  IN3 w0.114: v2(38.89,89.7) 39.48,89.7 39.87,90.09 40.49,90.09 40.69,90.3 40.69,91.24 40.82,91.37 41.47,91.37 41.6,91.24 41.6,90.31 41.72,90.19 41.96,90.19 42.08,90.31 42.08,91.28 42.21,91.41 42.44,91.41 42.57,91.28 42.57,90.31 42.7,90.19 42.93,90.19 43.06,90.31 43.06,91.16 43.18,91.28 43.42,91.28 43.55,91.16 43.55,90.36 43.67,90.24 43.91,90.24 44.03,90.36 44.03,91.16 44.16,91.28 47.94,91.28 51.25,94.58 51.25,95 51.43,95.19 54.43,95.19 56.47,93.15 v4(56.51,93.15)
  BOTTOM w0.102: UV4.E3 38.48,90.11 v2(38.89,89.7)
  BOTTOM w0.122: v4(56.51,93.15) 56.61,93.15 UV1.D20
FBA_D5: length 27.8
  IN3 w0.114: v4(56.54,92.4) 56.53,92.4 55.37,93.56 50.92,93.56 48.29,90.93 47.63,90.93 47.5,90.81 47.5,90.08 47.38,89.95 47.14,89.95 47.02,90.08 47.02,90.81 46.89,90.93 46.65,90.93 46.53,90.81 46.53,90 46.4,89.87 46.17,89.87 46.04,90 46.04,90.81 45.92,90.93 45.6,90.93 45.48,90.81 45.48,89.99 45.36,89.87 45.12,89.87 44.99,89.99 44.99,90.81 44.87,90.93 44.63,90.93 44.51,90.81 44.51,89.99 44.38,89.87 39.96,89.87 39.39,89.3 38.48,89.3 v2(38.09,88.9)
  BOTTOM w0.102: 56.19,92.75 v4(56.54,92.4) ; UV4.F2 37.68,89.31 v2(38.09,88.9)
  BOTTOM w0.136: UV1.D21 56.19,92.75
FBA_D6: length 31
  IN3 w0.114: v4(57.43,90.71) 56.99,91.15 56.45,91.15 55.72,91.88 51.15,91.88 47.68,88.42 47.51,88.42 46.94,88.99 46.76,88.99 46.59,88.82 46.59,88.65 47.17,88.07 47.17,87.9 46.88,87.61 46.13,87.61 46.01,87.73 46.01,89.02 45.89,89.15 45.64,89.15 45.52,89.02 45.52,87.73 45.4,87.61 37.83,87.61 37.56,87.87 37.56,88.08 36.83,88.82 36.83,89.17 36.68,89.32 36.1,89.32 v2(35.7,89.72)
  BOTTOM w0.102: UV4.H3 36.06,89.99 35.79,89.72 v2(35.7,89.72)
  BOTTOM w0.122: v4(57.43,90.71) 57.03,91.11 UV1.F20
FBA_D7: length 29.7
  IN3 w0.114: v4(55.77,92.35) 55.39,92.73 50.64,92.73 47.44,89.52 45.17,89.52 45.05,89.4 45.05,88.16 44.93,88.04 44.68,88.04 44.56,88.16 44.56,89.4 44.44,89.52 44.2,89.52 44.07,89.4 44.07,88.16 43.95,88.04 43.71,88.04 43.59,88.16 43.59,89.4 43.46,89.52 43.22,89.52 43.1,89.4 43.1,88.16 42.98,88.04 42.73,88.04 42.61,88.16 42.61,89.4 42.49,89.52 40.82,89.52 39.81,88.51 37.69,88.51 v2(37.3,88.9)
  BOTTOM w0.102: UV4.G2 36.89,89.31 v2(37.3,88.9)
  BOTTOM w0.122: UV1.E21 v4(55.77,92.35)
FBA_D8: length 37.1
  TOP w0.102: v2(38.33,90.64) 37.79,90.11 UV5.F7
  IN1 w0.114: v2(38.33,90.64) 38.33,90.48 38.7,90.11 39.6,90.11 41.65,92.16 41.65,92.9 44.56,95.81 47.61,95.81 47.72,95.92 47.72,96.75 47.84,96.86 48.07,96.86 48.18,96.75 48.18,95.92 48.3,95.81 48.52,95.81 48.64,95.92 48.64,96.75 48.75,96.86 48.98,96.86 49.1,96.75 49.1,95.92 49.21,95.81 49.44,95.81 49.55,95.92 49.55,96.75 49.67,96.86 49.9,96.86 50.02,96.75 50.02,96.04 50.14,95.91 50.35,95.91 50.47,96.04 50.47,96.75 50.59,96.86 56.51,96.86 57.62,95.75 57.62,94.86 59.76,92.73 60.27,92.73 60.71,92.3 60.71,91.78 60.95,91.54 v4(61.55,91.54)
  BOTTOM w0.122: UV1.E15 61.14,91.95 v4(61.55,91.54)
FBA_D9: length 36.8
  TOP w0.102: UV5.H7 36.06,90.1 v2(36.46,89.7)
  IN1 w0.114: v2(36.46,89.7) 36.47,89.7 36.87,90.1 37.63,90.1 37.75,90.22 37.75,90.73 38.14,91.11 39.52,91.11 40.37,91.97 40.37,93.84 40.74,94.2 40.74,95.34 41.81,96.41 42.38,96.41 42.49,96.51 42.49,97.4 42.63,97.55 43.31,97.55 43.42,97.44 43.42,96.68 43.54,96.56 43.77,96.56 43.88,96.68 43.88,97.44 44,97.55 44.22,97.55 44.34,97.44 44.34,97.04 44.47,96.92 44.67,96.92 44.8,97.04 44.8,97.44 44.91,97.55 58.11,97.55 60.27,95.39 60.27,93.85 60.73,93.39 v2(60.73,93.13)
  BOTTOM w0.122: UV1.D15 61.1,92.75 60.73,93.11 v2(60.73,93.13)
FBA_D10: length 38
  TOP w0.102: v2(38.09,89.7) 37.69,89.31 UV5.F8
  IN1 w0.114: v4(60.72,90.71) 60.72,91.36 60.14,91.94 59.66,91.94 59.47,92.13 59.47,92.61 55.94,96.14 51.68,96.14 50.98,95.44 48.55,95.44 48.44,95.33 48.44,94.52 48.33,94.4 48.1,94.4 47.98,94.52 47.98,95.33 47.87,95.44 47.65,95.44 47.54,95.33 47.54,94.49 47.42,94.38 47.19,94.38 47.08,94.49 47.08,95.33 46.97,95.44 46.74,95.44 46.62,95.33 46.62,94.49 46.51,94.38 46.28,94.38 46.17,94.49 46.17,95.33 46.05,95.44 45.82,95.44 45.71,95.33 45.71,94.49 45.59,94.38 45.37,94.38 45.25,94.49 45.25,95.33 45.14,95.44 44.91,95.44 44.79,95.33 44.79,94.49 44.68,94.38 43.61,94.38 41.97,92.74 41.97,92.16 39.11,89.3 38.49,89.3 v2(38.09,89.7)
  BOTTOM w0.122: v4(60.72,90.71) 61.12,91.11 UV1.F15
FBA_D11: length 39.2
  TOP w0.102: v2(36.4,88.92) 36.38,88.92 36.06,89.24 UV5.H8
  IN1 w0.114: v2(36.4,88.92) 36.51,88.92 36.92,88.51 39.81,88.51 40.09,88.79 40.09,89.06 43,91.96 43,92.13 42.58,92.55 42.58,92.72 42.72,92.87 42.9,92.87 43.27,92.51 43.32,92.45 43.49,92.45 43.65,92.61 43.65,92.77 43.27,93.15 43.25,93.17 43.25,93.35 43.4,93.49 43.58,93.49 43.97,93.1 44.13,93.1 44.29,93.26 44.29,93.42 44,93.71 44,93.89 44.14,94.03 44.32,94.03 44.62,93.74 44.78,93.74 45.07,94.03 48.44,94.03 48.78,94.37 48.78,94.97 48.91,95.1 49.25,95.1 49.38,94.97 49.38,94.34 49.51,94.22 49.71,94.22 49.84,94.34 49.84,94.99 49.95,95.1 50.55,95.1 50.57,95.12 55.51,95.12 56.35,94.28 57.49,94.28 58.46,93.32 58.46,92.18 58.69,91.95 59.18,91.95 59.49,91.64 59.49,90.52 59.73,90.29 61.97,90.29 v4(62.39,90.71)
  BOTTOM w0.122: UV1.F13 62.79,91.11 v4(62.39,90.71)
FBA_D12: length 36.9
  TOP w0.102: v2(39.03,92.19) 38.99,92.19 38.46,92.72 UV5.E3
  IN1 w0.114: v4(62.39,93.95) 62.22,93.95 61.54,94.64 61.54,95.02 61.12,95.43 61.12,95.74 60.4,96.46 60.4,96.63 60.76,96.99 60.76,97.17 60.62,97.32 60.44,97.32 60.07,96.95 59.91,96.95 59.75,97.11 59.75,97.27 59.93,97.45 59.93,97.63 59.78,97.77 59.6,97.77 59.43,97.6 59.27,97.6 59.1,97.76 59.1,97.92 59.26,98.07 59.26,98.25 59.11,98.4 58.93,98.4 58.78,98.24 58.62,98.24 58.47,98.4 45.12,98.4 45,98.51 45,98.75 44.87,98.88 44.67,98.88 44.54,98.75 44.54,98.51 44.43,98.4 44.2,98.4 44.09,98.51 44.09,98.75 43.96,98.88 43.76,98.88 43.63,98.75 43.63,98.51 43.52,98.4 43.29,98.4 43.17,98.51 43.17,98.75 43.05,98.88 42.84,98.88 42.72,98.75 42.72,98.51 42.6,98.4 42.28,98.4 40.83,96.95 40.07,96.95 39.32,96.19 39.32,92.49 v2(39.03,92.19)
  BOTTOM w0.122: v4(62.39,93.95) 62.79,93.55 UV1.C13
FBA_D13: length 36.8
  TOP w0.102: v2(38.09,94.5) 37.69,94.11 UV5.F2
  IN1 w0.114: v2(38.09,94.5) 38.51,94.93 38.51,95.87 39.93,97.29 40.69,97.29 42.62,99.22 45.34,99.22 45.46,99.11 45.46,98.85 45.57,98.74 45.8,98.74 45.92,98.85 45.92,99.11 46.03,99.22 46.26,99.22 46.37,99.11 46.37,98.85 46.49,98.74 46.72,98.74 46.83,98.85 46.83,99.11 46.94,99.22 47.17,99.22 47.29,99.11 47.29,98.85 47.4,98.74 47.63,98.74 47.74,98.85 47.74,99.11 47.86,99.22 48.09,99.22 48.2,99.11 48.2,98.85 48.32,98.74 48.54,98.74 48.66,98.85 48.66,99.11 48.77,99.22 49,99.22 49.12,99.11 49.12,98.85 49.23,98.74 49.46,98.74 49.57,98.85 49.57,99.11 49.69,99.22 49.92,99.22 50.03,99.11 50.03,98.87 50.16,98.74 50.41,98.74 50.54,98.87 50.54,99.1 50.67,99.22 50.87,99.22 51,99.1 51,98.87 51.12,98.74 51.33,98.74 51.45,98.87 51.45,99.08 51.59,99.22 51.77,99.22 51.91,99.08 51.91,98.87 52.04,98.74 52.24,98.74 52.37,98.87 52.37,99.1 52.49,99.22 52.7,99.22 52.82,99.1 52.82,98.87 52.95,98.74 60.36,98.74 61.46,97.64 61.46,95.6 61.7,95.36 62.07,95.36 62.49,94.94 v4(62.49,94.74)
  BOTTOM w0.122: UV1.B13 62.79,94.35 62.49,94.65 v4(62.49,94.74)
FBA_D14: length 39.5
  TOP w0.102: v2(36.88,92.78) 36.35,93.31 UV5.H3
  IN1 w0.114: v2(36.88,92.78) 36.88,94.78 36.61,95.05 36.61,95.21 38.23,96.83 38.23,97.29 38.91,97.98 40.41,97.98 42.34,99.91 56.09,99.91 56.34,99.66 60.41,99.66 63.66,96.41 63.66,93.62 v4(62.39,92.35)
  BOTTOM w0.122: UV1.E13 62.79,91.95 v4(62.39,92.35)
FBA_D15: length 37.9
  TOP w0.102: v2(37.29,93.7) 36.88,94.11 UV5.G2
  IN1 w0.102: 37.7,95.51 38.57,96.38 38.57,96.44
  IN1 w0.114: v4(62.39,93.15) 63.18,93.94 63.18,96.4 60.48,99.1 56.14,99.1 56.03,99.22 56.03,99.45 55.91,99.57 55.68,99.57 55.57,99.45 55.57,99.21 55.44,99.08 55.24,99.08 55.11,99.21 55.11,99.45 55,99.57 54.77,99.57 54.65,99.45 54.65,99.21 54.53,99.08 54.32,99.08 54.2,99.21 54.2,99.45 54.08,99.57 53.85,99.57 53.74,99.45 53.74,99.21 53.61,99.08 53.41,99.08 53.28,99.21 53.28,99.45 53.17,99.57 42.48,99.57 40.55,97.63 39.05,97.63 38.57,97.15 38.57,96.44 ; 37.7,95.51 37.7,94.1 37.3,93.7 v2(37.29,93.7)
  BOTTOM w0.122: v4(62.39,93.15) 62.79,92.75 UV1.D13
FBA_D16: length 33.9
  TOP w0.102: 60.84,95.6 61.33,95.11 61.33,94.55 60.72,93.94 v4(60.72,93.94)
  TOP w0.122: UV5.C3 39.99,93.31 39.74,93.06 39.74,92.24 39.97,92.01 40.96,92.01 41.15,92.2 42.49,93.54 43.92,93.54 45.31,94.93 45.31,96.86 v1(47.77,99.32) 48.58,100.13 56.86,100.13 57.48,100.74 58.37,100.74 61.28,97.83 61.28,96.98 60.84,96.54 60.84,95.6
  BOTTOM w0.122: v4(60.72,93.94) 60.72,93.94 61.12,94.35 UV1.B15
FBA_D17: length 32.3
  TOP w0.102: 61.27,96.09 61.27,95.45 61.53,95.2 61.53,94.46 61.12,94.06 61.12,93.78 60.92,93.58 60.33,93.58 v4(59.89,93.14)
  TOP w0.122: UV5.A3 41.73,93.31 42.19,93.77 42.5,93.77 42.81,94.07 43.33,94.07 44.87,95.61 44.87,97.04 48.4,100.56 v1(51.22,100.56) 56.68,100.56 57.29,101.18 58.55,101.18 61.72,98.01 61.72,96.79 61.27,96.35 61.27,96.09
  BOTTOM w0.122: UV1.C16 60.3,93.55 v4(59.89,93.14)
FBA_D18: length 33.3
  TOP w0.122: UV5.A2 41.76,94.21 42.23,94.21 43.92,95.9 43.92,97.33 48.03,101.44 56.15,101.44 v1(56.51,101.8) 56.87,102.16 58.81,102.16 59.35,101.61 59.53,101.61 59.93,102.02 60.1,102.02 60.27,101.84 60.27,101.67 59.87,101.27 59.87,101.1 60.13,100.84 60.34,100.84 60.84,101.34 61.12,101.34 62.59,99.87 62.59,96.27 62.13,95.8 v4(61.99,95.8)
  BOTTOM w0.102: v4(61.99,95.8) 62.16,95.8 UV1.A13
FBA_D19: length 33.1
  TOP w0.122: v4(61.86,96.32) 62.16,96.61 62.16,98.19 61.81,98.54 61.81,98.71 62.16,99.06 62.16,99.24 61.99,99.4 61.81,99.4 61.46,99.06 61.29,99.06 61.12,99.23 61.12,99.4 61.27,99.55 61.27,99.72 61.09,99.89 60.92,99.89 60.77,99.75 60.6,99.75 58.62,101.72 57.13,101.72 56.41,101 v1(54.46,101) 48.21,101 44.36,97.15 44.36,95.71 43.15,94.51 42.93,94.51 42.41,93.99 42.09,93.99 41.88,93.78 40.39,93.78 UV5.C2
  BOTTOM w0.122: v4(61.86,96.32) 61.13,95.59 UV1.A15
FBA_D20: length 33.3
  TOP w0.102: 41.56,90.48 41.25,90.16 41.25,89.91 41.12,89.78 39.59,89.78 UV5.D7
  TOP w0.122: 41.56,90.48 42.91,91.83 44.33,91.83 47.62,95.11 47.62,95.28 47.32,95.58 47.32,95.76 47.49,95.93 47.67,95.93 47.96,95.63 48.13,95.63 48.31,95.8 48.31,95.97 47.75,96.53 47.75,96.71 47.91,96.88 48.09,96.88 48.65,96.32 48.82,96.32 49,96.49 49,96.66 48.39,97.27 48.39,97.45 48.55,97.62 48.73,97.62 49.34,97.01 49.51,97.01 49.69,97.18 49.69,97.35 49.2,97.84 49.2,98.02 49.36,98.19 49.54,98.19 50.03,97.7 50.2,97.7 50.53,98.03 v1(52.36,98.03) 58.05,98.03 59.35,96.73 59.35,95.66 v4(59.25,95.56)
  BOTTOM w0.136: v4(59.25,95.56) 59.06,95.37 59.06,94.76 UV1.B18
FBA_D21: length 31.2
  TOP w0.122: v4(58.87,95.93) 58.91,95.98 58.91,96.55 57.87,97.59 v1(56.55,97.59) 50.72,97.59 50.01,96.89 50.01,96.71 50.33,96.4 50.33,96.22 50.16,96.05 49.99,96.05 49.67,96.37 49.5,96.37 49.32,96.2 49.32,96.02 49.64,95.71 49.64,95.53 49.47,95.36 49.3,95.36 48.98,95.68 48.81,95.68 48.63,95.51 48.63,95.33 48.95,95.02 48.95,94.84 48.78,94.67 48.61,94.67 48.29,94.99 48.12,94.99 47.91,94.79 47.91,94.61 48.23,94.3 48.23,94.12 48.06,93.96 47.88,93.96 47.57,94.27 47.4,94.27 47.22,94.1 47.22,93.93 47.54,93.61 47.54,93.43 47.37,93.27 47.19,93.27 46.88,93.58 46.71,93.58 46.53,93.41 46.53,93.24 46.85,92.92 46.85,92.74 46.68,92.58 46.51,92.58 46.19,92.89 46.02,92.89 45.84,92.72 45.84,92.55 46.16,92.23 46.16,92.05 45.99,91.89 45.82,91.89 45.5,92.2 45.33,92.2 45.15,92.03 45.15,91.86 45.47,91.54 45.47,91.36 45.3,91.2 45.13,91.2 44.81,91.51 44.64,91.51 44.3,91.18 42.73,91.18 UV5.A7
  BOTTOM w0.122: v4(58.87,95.93) 58.48,95.54 58.48,95.32 UV1.A18
FBA_D22: length 31.5
  TOP w0.122: v4(57.68,97.15) 57.16,96.63 56.21,96.63 56.09,96.75 56.09,97.03 55.97,97.15 55.73,97.15 55.6,97.03 55.6,96.75 55.48,96.63 55.24,96.63 55.12,96.75 55.12,97.03 54.99,97.15 54.75,97.15 54.63,97.03 54.63,96.75 54.51,96.63 54.26,96.63 54.14,96.75 54.14,97.03 54.02,97.15 53.78,97.15 53.65,97.03 53.65,96.75 53.53,96.63 53.29,96.63 53.17,96.75 53.17,97.03 53.04,97.15 52.8,97.15 52.68,97.03 52.68,96.75 52.56,96.63 52.31,96.63 52.19,96.75 52.19,97.03 52.07,97.15 51.82,97.15 51.7,97.03 51.7,96.75 51.58,96.63 51.36,96.63 50.96,97.03 50.78,97.03 50.62,96.87 50.62,96.69 50.89,96.42 50.89,96.16 v1(47.52,92.78) 45.23,90.5 45.05,90.5 44.74,90.82 44.56,90.82 44.39,90.65 44.39,90.47 44.71,90.15 44.71,89.98 44.42,89.69 43.93,89.69 43.8,89.82 43.8,90.61 43.68,90.74 43.44,90.74 43.32,90.61 43.32,89.82 43.19,89.69 42.95,89.69 42.83,89.82 42.83,90.47 42.7,90.6 42.47,90.6 42.34,90.47 42.34,89.82 42.22,89.69 41.41,89.69 41.03,89.31 UV5.B8
  BOTTOM w0.122: UV1.A19 57.85,95.78 57.68,95.95 v4(57.68,97.15)
FBA_D23: length 31.3
  TOP w0.122: v4(58.07,96.77) 57.46,96.17 51.52,96.17 48.98,93.63 48.98,93.45 49.37,93.07 49.37,92.9 49.19,92.72 49.02,92.72 48.63,93.11 48.46,93.11 48.29,92.94 48.29,92.77 48.68,92.38 48.68,92.21 48.5,92.03 48.33,92.03 47.94,92.42 47.77,92.42 47.6,92.25 47.6,92.08 47.99,91.69 47.99,91.52 47.81,91.34 47.64,91.34 47.25,91.73 47.08,91.73 v1(44.71,89.36) 44.18,88.82 44,88.82 43.64,89.18 43.47,89.18 43.3,89.01 43.3,88.84 43.66,88.48 43.66,88.31 43.07,87.72 41.1,87.72 40.48,88.33 40.48,88.89 UV5.C8
  BOTTOM w0.122: v4(58.07,96.77) 58.07,96 58.24,95.83 58.24,93.94 UV1.C19
FBA_D24: length 23.1
  BOTTOM w0.122: UV4.A3 41.3,90.11 41.17,89.98 41.17,89.81 41.3,89.68 42.54,89.68 42.7,89.84 42.7,90.01 42.36,90.35 42.36,90.53 42.52,90.7 42.7,90.7 43.05,90.35 43.22,90.35 44,91.13 45,91.13 48.14,94.27 48.14,94.45 47.56,95.03 47.56,95.2 47.73,95.37 47.91,95.37 v1(48.09,95.19) 48.49,94.79 48.66,94.79 48.83,94.96 48.83,95.14 48.25,95.72 48.25,95.89 48.42,96.06 48.6,96.06 49.18,95.48 49.35,95.48 49.55,95.68 49.55,95.83 49.4,95.98 49.4,96.13 49.52,96.24 49.67,96.24 49.77,96.14 50.01,96.14 50.3,96.43 52.47,96.43 53.23,95.67 53.23,94.48 53.36,94.35 UV1.B24
FBA_D25: length 24.7
  BOTTOM w0.122: UV1.C23 54.2,93.55 54.07,93.68 54.07,95.43 52.38,97.12 48.24,97.12 44.76,93.65 44.76,93.48 45.34,92.9 45.34,92.72 45.18,92.55 45,92.55 44.42,93.13 44.25,93.13 44.07,92.96 44.07,92.79 44.51,92.35 44.51,92.18 44.34,92.01 44.16,92.01 v1(43.94,92.23) 43.73,92.44 43.56,92.44 42.48,91.37 40.58,91.37 39.72,90.51 39.72,89.72 40.06,89.38 UV4.C2
FBA_D26: length 21.4
  BOTTOM w0.122: UV1.A25 51.83,96.19 50.69,96.19 49.81,95.31 49.81,95.14 50.49,94.46 50.49,94.28 50.32,94.12 50.14,94.12 49.5,94.75 49.46,94.8 49.29,94.8 49.12,94.62 49.12,94.45 49.44,94.12 49.44,93.94 49.28,93.78 49.1,93.78 48.77,94.11 48.6,94.11 48.43,93.93 48.43,93.76 48.78,93.41 48.78,93.23 48.61,93.07 48.43,93.07 48.08,93.42 47.91,93.42 v1(46.22,91.73) 44.92,90.43 44.68,90.43 44.42,90.69 44.24,90.69 44.05,90.5 44.05,90.32 44.34,90.03 44.34,89.85 44.18,89.69 44,89.69 43.67,90.01 43.5,90.01 43.33,89.84 43.33,89.67 43.65,89.34 43.65,89.16 43.49,89 43.31,89 43.27,89.04 42.98,89.32 42.81,89.32 42.8,89.31 UV4.A2
FBA_D27: length 22.3
  BOTTOM w0.102: UV1.A24 53.67,95.53 52.53,96.67 52.17,96.67
  BOTTOM w0.122: 52.17,96.67 48.41,96.67 46.85,95.11 46.85,94.94 47.44,94.36 47.44,94.19 47.26,94.01 47.09,94.01 46.51,94.6 46.34,94.6 46.16,94.42 46.16,94.25 46.75,93.67 46.75,93.5 46.57,93.32 46.4,93.32 v1(46.01,93.72) 45.82,93.91 45.65,93.91 45.47,93.73 45.47,93.56 46.06,92.98 46.06,92.81 44.82,91.57 43.33,91.57 42.74,90.99 40.92,90.99 40.06,90.12 UV4.C3
FBA_D28: length 24
  BOTTOM w0.122: UV1.A21 56.1,95.22 56.1,95.95 53.43,98.62 v1(52.74,98.62) 47.5,98.62 47.03,98.16 46.86,98.16 46.4,98.62 46.22,98.62 46.05,98.46 46.05,98.28 46.52,97.81 46.52,97.64 46.35,97.47 46.17,97.47 45.63,98.01 45.45,98.01 45.29,97.84 45.29,97.66 45.8,97.15 45.8,96.97 45.63,96.81 45.46,96.81 45.19,97.07 45.02,97.07 44.85,96.9 44.85,96.72 45.14,96.43 45.14,96.26 44.97,96.09 44.79,96.09 44.42,96.46 44.24,96.46 44.08,96.29 44.08,96.11 44.45,95.74 44.45,95.57 42.19,93.31 UV4.A7
FBA_D29: length 24.9
  BOTTOM w0.122: UV1.B21 56.17,94.47 56.56,94.86 56.56,95.32 56.33,95.55 56.33,96.35 54.67,98 53.61,99.06 v1(50.2,99.06) 46.02,99.06 45.86,98.9 45.54,98.9 45.39,99.05 45.21,99.05 45.05,98.89 45.05,98.71 45.21,98.56 45.21,98.39 45.03,98.21 44.86,98.21 44.71,98.37 44.53,98.37 44.36,98.2 44.36,98.02 44.77,97.62 44.77,97.44 44.6,97.27 44.42,97.27 44.02,97.68 43.84,97.68 43.47,97.31 43.47,96.74 43.14,96.41 43.14,96.24 43.66,95.72 43.66,95.54 41.89,93.78 41.43,93.78 41.1,94.11 UV4.B8
FBA_D30: length 25.7
  BOTTOM w0.122: UV1.C20 57.45,93.99 57.45,95.93 57.12,96.26 57.12,96.8 53.93,99.99 44.91,99.99 v1(43.06,98.13) 41.12,96.2 40.38,96.2 39.72,95.54 39.72,94.42 40.03,94.11 UV4.C8
FBA_D31: length 25.5
  BOTTOM w0.122: UV1.C21 56.62,94 56.62,94.53 56.81,94.72 56.81,95.42 56.55,95.68 56.55,95.99 56.65,96.09 56.65,96.64 v1(55.84,97.45) 53.76,99.54 45.08,99.54 41.29,95.75 40.93,95.75 40.68,95.49 40.68,95.24 40.42,94.99 40.42,93.91 40.17,93.65 39.72,93.65 39.38,93.31 UV4.D7
FBA_D32: length 26.5
  IN1 w0.114: v2(37.31,73.15) 37.7,72.76 39.02,72.76 39.28,73.02 39.28,73.48 39.51,73.71 44.92,73.71 49.71,78.51 50.81,78.51 51.19,78.89 51.19,80.07 53.1,81.98 56,81.98 56.23,82.21 56.23,83 55.99,83.24 v4(55.72,83.24)
  BOTTOM w0.102: UV6.G2 36.9,73.56 v2(37.31,73.15) ; UV1.R22 55.35,83.61 v4(55.72,83.24)
FBA_D33: length 23.8
  IN1 w0.114: v2(35.68,74.7) 36.04,74.35 36.04,73.84 36.32,73.55 37.38,73.55 37.69,73.86 37.69,74.16 37.88,74.35 38.24,74.35 38.51,74.62 38.51,74.91 38.52,74.92 38.77,75.17 39.38,75.17 39.79,75.59 45.34,75.59 49.52,79.77 49.82,79.77 v4(53.31,83.25)
  BOTTOM w0.102: v2(35.68,74.7) 36.03,74.36 UV6.H3
  BOTTOM w0.122: v4(53.31,83.25) 53.3,83.25 53.65,83.61 UV1.R24
FBA_D34: length 22.3
  IN1 w0.114: v2(38.1,73.95) 38.5,73.55 39.04,73.55 39.63,74.13 44.85,74.13 50.05,79.33 50.16,79.33 53.02,82.2 54.15,82.2 54.9,82.95 v4(54.9,83.24)
  BOTTOM w0.102: v4(54.9,83.24) 55.31,82.83 UV1.T22 ; UV6.F2 37.7,73.56 v2(38.1,73.95)
FBA_D35: length 27
  IN1 w0.114: v2(38.9,73.95) 38.93,73.95 40.23,75.24 41.52,75.24 41.63,75.13 41.63,74.54 41.76,74.41 41.96,74.41 42.09,74.54 42.09,75.13 42.2,75.24 42.43,75.24 42.55,75.13 42.55,74.59 42.67,74.46 42.88,74.46 43,74.59 43,75.13 43.12,75.24 43.35,75.24 43.46,75.13 43.46,74.6 43.59,74.48 43.79,74.48 43.92,74.6 43.92,75.13 44.03,75.24 44.26,75.24 44.38,75.13 44.38,74.6 44.5,74.48 44.71,74.48 44.83,74.6 44.83,75.13 44.95,75.24 45.48,75.24 49.79,79.55 50.04,79.55 52.95,82.46 54.1,82.46 54.52,82.88 54.52,83.68 v4(54.87,84.03)
  BOTTOM w0.102: v2(38.9,73.95) 38.49,74.36 UV6.E3
  BOTTOM w0.122: UV1.R23 54.47,83.63 v4(54.87,84.03)
FBA_D36: length 26.1
  IN1 w0.114: v4(52.47,84.87) 52.45,84.87 51.42,83.84 51.01,83.84 49.69,82.52 49.69,81.62 47.78,79.72 47.6,79.72 47.18,80.14 47.02,80.14 46.85,79.98 46.85,79.82 47.28,79.39 47.28,79.21 47.14,79.07 46.96,79.07 46.53,79.5 46.37,79.5 46.21,79.33 46.21,79.17 46.63,78.75 46.63,78.57 46.49,78.42 46.31,78.42 45.88,78.85 45.72,78.85 45.56,78.69 45.56,78.53 45.94,78.14 45.94,77.96 45.8,77.82 45.62,77.82 45.24,78.2 45.08,78.2 44.81,77.93 39.75,77.93 39.34,77.52 36.13,77.52 v2(35.7,77.95)
  BOTTOM w0.102: UV6.H7 36.07,77.58 v2(35.7,77.95)
  BOTTOM w0.122: UV1.N25 52.87,85.27 v4(52.47,84.87)
FBA_D37: length 26.9
  IN1 w0.114: v4(51.67,84.87) 50.37,84.87 50.1,84.61 50.1,83.71 48.88,82.49 48.88,82.33 49.28,81.92 49.28,81.76 49.12,81.6 48.96,81.6 48.55,82 48.39,82 48.23,81.84 48.23,81.68 48.63,81.27 48.63,81.11 48.47,80.95 48.31,80.95 47.91,81.36 47.74,81.36 47.58,81.19 47.58,81.03 47.99,80.63 47.99,80.47 47.83,80.3 47.66,80.3 47.26,80.71 47.1,80.71 45.6,79.21 45.06,79.21 44.95,79.1 44.95,78.56 44.82,78.43 44.62,78.43 44.49,78.56 44.49,79.1 44.37,79.21 44.15,79.21 44.03,79.1 44.03,78.4 43.9,78.27 43.7,78.27 43.57,78.4 43.57,79.1 43.46,79.21 43.23,79.21 43.12,79.1 43.12,78.27 42.99,78.15 42.79,78.15 42.66,78.27 42.66,79.1 42.55,79.21 41.18,79.21 40.46,78.49 39.86,78.49 39.72,78.35 38.42,78.35 v2(38.02,77.95)
  BOTTOM w0.102: v2(38.02,77.95) 37.67,77.6 UV6.F7
  BOTTOM w0.122: UV1.N26 52.07,85.27 51.91,85.11 v4(51.67,84.87)
FBA_D38: length 27.2
  IN1 w0.114: v2(36.39,78.75) 36.39,79.37 36.97,79.95 39.23,79.95 39.65,80.38 44.67,80.38 46.99,82.7 47.15,82.7 47.54,82.31 47.72,82.31 47.87,82.45 47.87,82.63 47.47,83.02 47.47,83.18 47.64,83.35 47.8,83.35 48.19,82.95 48.37,82.95 48.51,83.1 48.51,83.28 48.12,83.67 48.12,83.83 48.28,83.99 48.44,83.99 48.84,83.6 49.02,83.6 49.16,83.74 49.16,83.92 48.77,84.32 48.77,84.48 48.93,84.64 49.09,84.64 49.35,84.38 49.53,84.38 49.67,84.52 49.67,84.7 49.41,84.96 49.41,85.12 49.75,85.46 53.48,85.46 v4(54.07,84.87)
  BOTTOM w0.102: v2(36.39,78.75) 36.39,78.72 36.07,78.4 UV6.H8
  BOTTOM w0.122: UV1.N23 54.15,85.29 54.07,85.21 v4(54.07,84.87)
FBA_D39: length 26.9
  IN1 w0.114: v2(37.26,78.8) 37.62,79.15 39.06,79.15 39.95,80.03 42.03,80.03 42.15,79.92 42.15,79.67 42.26,79.55 42.49,79.55 42.61,79.67 42.61,79.92 42.72,80.03 42.95,80.03 43.06,79.92 43.06,79.67 43.18,79.55 43.41,79.55 43.52,79.67 43.52,79.92 43.63,80.03 43.86,80.03 43.98,79.92 43.98,79.67 44.09,79.55 44.32,79.55 44.43,79.67 44.43,79.92 44.55,80.03 44.81,80.03 44.98,80.21 45.14,80.21 45.54,79.8 45.71,79.8 45.87,79.96 45.87,80.13 45.47,80.53 45.47,80.69 45.63,80.85 45.79,80.85 46.19,80.45 46.35,80.45 46.51,80.61 46.51,80.77 46.11,81.18 46.11,81.34 46.27,81.5 46.44,81.5 46.84,81.1 47,81.1 47.16,81.26 47.16,81.42 46.76,81.82 46.76,81.98 46.92,82.15 47.08,82.15 47.48,81.74 47.65,81.74 49.89,83.98 49.89,84.73 50.24,85.09 51.36,85.09 51.51,85.24 52.89,85.24 v4(53.27,84.87)
  BOTTOM w0.102: UV6.F8 37.67,78.43 37.31,78.8 v2(37.26,78.8)
  BOTTOM w0.122: UV1.N24 53.67,85.27 v4(53.27,84.87)
FBA_D40: length 20
  TOP w0.122: UV7.C3 40.07,76.57 40.35,76.29 43.12,76.29 43.37,76.54 43.54,76.54 43.79,76.29 43.97,76.29 44.13,76.46 44.13,76.64 43.88,76.89 43.88,77.06 44.06,77.23 44.23,77.23 v1(44.4,77.06) 44.57,76.89 44.75,76.89 44.92,77.06 44.92,77.24 44.65,77.5 44.65,77.68 44.81,77.85 44.99,77.85 45.26,77.58 45.43,77.58 48.56,80.7 51.73,80.7 52.13,81.11 53.34,81.11 53.76,81.54 v4(54.08,81.54)
  BOTTOM w0.122: UV1.V23 54.47,81.15 v4(54.08,81.54)
FBA_D41: length 20.3
  TOP w0.122: UV7.C2 40.42,78.01 40.42,76.89 40.74,76.57 41.63,76.57 41.79,76.73 42.94,76.73 44.83,78.63 45.01,78.63 45.34,78.29 45.52,78.29 v1(46.62,79.39) 48.37,81.14 51.63,81.14 51.84,81.35 53.26,81.35 53.88,81.97 55.29,81.97 v4(55.71,81.55)
  BOTTOM w0.122: UV1.V22 55.31,81.15 v4(55.71,81.55)
FBA_D42: length 21.6
  TOP w0.122: UV7.A3 41.73,77.61 42.57,77.61 46.39,81.43 ; v2(54.11,83.23) 53.94,83.23 53.08,82.37 52.33,82.37 52.2,82.49 52.2,83.02 52.08,83.14 51.84,83.14 51.72,83.02 51.72,82.49 51.59,82.37 51.35,82.37 51.23,82.49 51.23,83.02 51.11,83.14 50.86,83.14 50.74,83.02 50.74,82.49 50.62,82.37 50.38,82.37 50.25,82.49 50.25,83.02 50.13,83.14 49.89,83.14 49.77,83.02 49.77,82.49 49.64,82.37 49.4,82.37 49.28,82.49 49.28,83.02 49.16,83.14 48.91,83.14 48.79,83.02 48.79,82.49 48.67,82.37 48.42,82.37 48.3,82.49 48.3,83.02 48.18,83.14 47.94,83.14 47.81,83.02 47.81,82.49 47.69,82.37 47.33,82.37 46.39,81.43 ; v1(46.39,81.46) 46.39,81.43
  BOTTOM w0.102: v2(54.11,83.23) 54.47,82.87 UV1.T23
FBA_D43: length 22.9
  TOP w0.122: v4(54.92,82.35) 53.95,82.35 53.18,81.58 v1(48.61,81.58) 48.19,81.58 47.74,81.13 47.42,81.13 47.16,81.4 46.98,81.4 46.82,81.24 46.82,81.06 47.16,80.73 47.16,80.55 46.99,80.38 46.81,80.38 46.47,80.72 46.3,80.72 46.13,80.55 46.13,80.37 46.47,80.04 46.47,79.86 46.3,79.69 46.12,79.69 45.78,80.03 45.61,80.03 45.44,79.86 45.44,79.69 45.78,79.35 45.78,79.17 45.61,79 45.43,79 45.09,79.34 44.92,79.34 42.75,77.17 41.53,77.17 41.31,77.4 41.31,77.77 41.44,77.89 42.4,77.89 42.53,78.02 42.53,78.24 42.41,78.36 UV7.A2
  BOTTOM w0.122: UV1.U22 55.3,81.97 v4(54.92,82.35)
FBA_D44: length 19.1
  TOP w0.122: UV7.D7 39.27,74.45 39.4,74.58 39.57,74.58 39.7,74.45 39.7,74.16 39.95,73.9 40.93,73.9 41.27,74.25 41.27,74.43 41.57,74.73 46.15,74.73 46.35,74.93 46.35,75.1 46.25,75.21 46.25,75.38 46.42,75.55 46.59,75.55 46.69,75.45 46.87,75.45 47.04,75.62 47.04,75.79 46.94,75.9 46.94,76.04 v1(48.48,77.58) 49.82,78.92 49.82,79.26 50.12,79.56 52.78,79.56 v4(53.27,79.07)
  BOTTOM w0.122: UV1.Y24 53.35,79.49 53.27,79.41 v4(53.27,79.07)
FBA_D45: length 19.8
  TOP w0.122: UV7.A7 41.74,74.29 42.36,74.29 42.48,74.17 42.48,73.65 42.6,73.53 42.84,73.53 42.97,73.65 42.97,74.17 43.09,74.29 43.33,74.29 43.45,74.17 43.45,73.69 43.58,73.56 43.81,73.56 43.94,73.69 43.94,74.17 44.06,74.29 44.31,74.29 44.43,74.17 44.43,73.69 44.56,73.56 44.79,73.56 44.92,73.69 44.92,74.17 45.04,74.29 45.28,74.29 45.4,74.17 45.4,73.69 45.53,73.56 45.76,73.56 45.89,73.69 45.89,74.17 46.01,74.29 46.33,74.29 v1(46.65,74.6) 50.71,78.67 53.44,78.67 53.86,79.09 v4(54.07,79.09)
  BOTTOM w0.122: UV1.AA24 54.07,79.05 v4(54.07,79.09)
FBA_D46: length 20.9
  TOP w0.122: UV7.C8 40.45,73.19 40.45,72.63 41.11,71.97 v1(45.12,71.97) 45.85,71.97 50.48,76.6 50.94,76.6 51.36,77.02 52.58,77.02 52.87,77.31 52.87,77.58 53.12,77.83 53.3,77.83 53.85,78.38 54.23,78.38 54.52,78.67 55,78.67 55.31,78.97 UV1.Y22 v4(55.72,79.9)
  BOTTOM w0.122: UV1.Y22 v4(55.72,79.9)
FBA_D47: length 21.4
  TOP w0.122: UV7.B8 41.03,73.56 41.41,73.94 41.87,73.94 42.69,73.12 42.92,73.12 43.04,73 43.04,72.62 43.16,72.5 43.41,72.5 43.53,72.62 43.53,73 43.65,73.12 43.89,73.12 44.02,73 44.02,72.62 44.14,72.5 44.38,72.5 44.5,72.62 44.5,73 44.63,73.12 46.38,73.12 46.54,73.29 46.54,73.46 46.47,73.53 46.47,73.7 46.65,73.87 46.82,73.87 46.89,73.8 47.06,73.8 47.23,73.98 47.23,74.15 47.16,74.22 47.16,74.39 47.34,74.56 47.51,74.56 47.58,74.49 47.75,74.49 47.92,74.67 47.92,74.84 47.85,74.91 47.85,75.08 48.03,75.25 48.2,75.25 48.27,75.18 48.44,75.18 48.61,75.36 48.61,75.53 48.54,75.6 v1(48.54,75.76) 48.54,75.77 49.16,76.39 49.31,76.39 49.31,76.38 49.44,76.25 49.51,76.25 50.28,77.02 51.04,77.02 51.15,77.13 51.15,77.57 51.43,77.85 52.83,77.85 53.03,78.05 53.14,78.05 53.76,78.67 54.19,78.67 54.59,79.07 v4(54.87,79.07)
  BOTTOM w0.122: v4(54.87,79.07) 54.47,78.67 UV1.AA23
FBA_D48: length 17.7
  TOP w0.102: UV7.H8 36.07,73.49 36.4,73.17 v2(36.41,73.17)
  IN3 w0.114: v4(50.17,75.76) 46.88,75.76 42.99,71.87 37.92,71.87 36.63,73.17 v2(36.41,73.17)
  BOTTOM w0.122: v4(50.17,75.76) 50.57,76.15 51.27,76.15 UV1.AD27
FBA_D49: length 20.1
  TOP w0.102: v2(38.1,74.75) 37.7,74.36 UV7.F7
  IN3 w0.114: v2(38.1,74.75) 38.49,74.36 41.54,74.36 41.66,74.48 41.66,74.91 41.78,75.04 42.03,75.04 42.15,74.91 42.15,74.48 42.27,74.36 42.52,74.36 42.64,74.48 42.64,74.91 42.76,75.04 43,75.04 43.13,74.91 43.13,74.48 43.25,74.36 43.99,74.36 46.66,77.03 50.62,77.03 51.43,76.22 51.84,76.22 52.09,76.47 52.09,76.85 52.46,77.22 v4(52.46,77.43)
  BOTTOM w0.122: v4(52.46,77.43) 52.87,77.85 UV1.AB25
FBA_D50: length 17.5
  TOP w0.102: UV7.F8 37.69,73.56 v2(38.1,73.15)
  IN3 w0.114: v2(38.1,73.15) 38.49,72.76 40.06,72.76 40.19,72.88 40.19,73.28 40.31,73.4 40.55,73.4 40.67,73.28 40.67,72.88 40.79,72.76 43.38,72.76 46.78,76.16 50.33,76.16 v4(50.78,75.71)
  BOTTOM w0.122: v4(50.78,75.71) 50.82,75.74 51.67,75.74 52.07,76.14 UV1.AD26
FBA_D51: length 19.2
  TOP w0.102: UV7.H7 36.07,74.35 v2(36.47,73.95)
  IN3 w0.114: v2(36.47,73.95) 36.88,73.55 38.71,73.55 38.71,73.55 39.03,73.55 39.04,73.55 39.57,73.55 39.9,73.88 44.01,73.88 46.72,76.6 50.54,76.6 51.2,75.94 51.94,75.94 v4(52.54,76.54)
  BOTTOM w0.122: v4(52.54,76.54) 52.54,76.65 52.87,76.98 UV1.AC25
FBA_D52: length 19.3
  TOP w0.102: v2(39.04,76.44) 39,76.44 38.47,76.97 UV7.E3
  IN3 w0.114: v2(39.04,76.44) 42.76,76.44 44.61,78.29 47.01,78.29 47.13,78.41 47.13,79.02 47.25,79.14 47.5,79.14 47.62,79.02 47.62,78.41 47.74,78.29 47.98,78.29 48.11,78.41 48.11,79.02 48.23,79.14 48.47,79.14 48.59,79.02 48.59,78.41 48.71,78.29 48.96,78.29 49.08,78.41 49.08,79.02 49.2,79.14 49.45,79.14 49.57,79.02 49.57,78.4 49.7,78.27 49.92,78.27 50.05,78.4 50.05,78.8 v4(50.21,78.96)
  BOTTOM w0.122: UV1.AA27 51.26,78.66 50.51,78.66 v4(50.21,78.96)
FBA_D53: length 19.2
  TOP w0.102: UV7.F2 37.7,78.36 v2(38.1,78.75)
  IN3 w0.114: v2(38.1,78.75) 38.28,78.75 38.68,78.35 38.71,78.35 38.71,78.35 39.03,78.35 39.04,78.35 44.17,78.35 44.46,78.64 44.61,78.64 44.7,78.74 44.7,79.48 44.83,79.61 45.07,79.61 45.19,79.48 45.19,78.76 45.32,78.64 45.56,78.64 45.68,78.76 45.68,79.5 45.81,79.62 46.04,79.62 46.17,79.5 46.17,78.76 46.29,78.64 46.54,78.64 46.66,78.76 46.66,79.37 46.78,79.49 51.22,79.49 v2(51.6,79.11)
  BOTTOM w0.102: UV1.AA26 52.06,78.65 v2(51.6,79.11)
FBA_D54: length 20.3
  TOP w0.102: UV7.H3 36.36,77.56 v2(36.89,77.03)
  IN3 w0.114: v4(52.46,80.73) 52.06,80.33 37.48,80.33 36.87,79.71 36.87,77.05 v2(36.89,77.03)
  BOTTOM w0.122: v4(52.46,80.73) 52.44,80.73 52.07,80.36 UV1.W26
FBA_D55: length 21.6
  TOP w0.102: UV7.G2 36.89,78.36 v2(37.3,77.95)
  IN3 w0.114: v2(37.3,77.95) 37.67,78.32 37.67,79.04 37.79,79.17 41.94,79.17 42.07,79.3 42.07,79.86 42.2,79.99 42.64,79.99 42.77,79.86 42.77,79.13 42.89,79.01 43.13,79.01 43.26,79.13 43.26,79.85 43.38,79.98 43.62,79.98 43.74,79.85 43.74,79.13 43.87,79.01 44.11,79.01 44.23,79.13 44.23,79.85 44.35,79.98 51.58,79.98 v4(52.47,79.09)
  BOTTOM w0.122: v4(52.47,79.09) UV1.Y25
FBA_D56: length 19
  BOTTOM w0.122: UV6.D7 39.5,77.56 39.91,77.97 40.29,77.97 40.48,78.16 40.48,79.3 40.74,79.56 40.74,79.77 40.99,80.02 42.39,80.02 42.52,79.9 42.52,78.95 42.64,78.82 45.36,78.82 45.48,78.95 45.48,80.6 47.34,82.46 ; 47.34,82.46 48.8,83.91 50.77,83.91 50.89,84.03 51.65,84.03 UV1.R26 ; 47.34,82.46 v1(47.34,82.48)
FBA_D57: length 19.4
  BOTTOM w0.122: UV6.A7 41.67,76.95 41.86,76.76 42.11,76.76 42.24,76.88 42.24,77.5 42.36,77.63 42.6,77.63 42.72,77.5 42.72,76.88 42.85,76.76 43.09,76.76 43.21,76.88 43.21,77.5 43.33,77.63 43.58,77.63 43.7,77.5 43.7,76.88 43.82,76.76 45.9,76.76 46.99,77.84 v1(46.99,80) 46.99,80.86 49.16,83.03 50.52,83.03 50.69,83.2 52.48,83.2 UV1.T25
FBA_D58: length 19.3
  BOTTOM w0.122: UV1.N27 51.06,85.08 49.32,85.08 v1(48.84,84.6) 44.75,80.51 44.45,80.51 44.33,80.39 44.33,79.52 44.2,79.39 43.97,79.39 43.84,79.52 43.84,80.39 43.72,80.51 43.47,80.51 43.35,80.39 43.35,79.48 43.22,79.35 42.99,79.35 42.86,79.48 42.86,80.39 42.74,80.51 40.51,80.51 39.74,79.74 39.74,78.69 UV6.C8
FBA_D59: length 19.3
  BOTTOM w0.122: UV1.R27 51.13,83.47 48.98,83.47 46.55,81.04 46.55,80.23 46.42,80.1 46.04,80.1 45.92,79.98 45.92,79.74 46.04,79.61 46.42,79.61 46.55,79.49 46.55,79.25 46.42,79.13 46.04,79.13 45.92,79 45.92,78.76 46.04,78.64 46.41,78.64 46.53,78.51 46.53,78.19 46.41,78.07 45.85,78.07 45.72,77.94 45.72,77.32 45.6,77.2 45.36,77.2 45.24,77.32 45.24,77.94 45.11,78.07 44.87,78.07 44.75,77.94 v1(44.75,77.72) 44.75,77.32 44.62,77.2 44.39,77.2 44.26,77.32 44.26,77.94 44.14,78.07 41.85,78.07 41.81,78.03 41.44,78.03 41.11,78.36 UV6.B8
FBA_D60: length 17.3
  BOTTOM w0.122: UV6.C3 40.07,74.73 40.62,75.28 41.84,75.28 42.31,74.81 46.9,74.81 48.91,76.82 v1(48.91,79.05) 48.91,80.04 49.61,80.74 51.68,80.74 52.07,81.13 UV1.V26
FBA_D61: length 17.8
  BOTTOM w0.122: UV1.V27 51.19,81.21 49.44,81.21 48.47,80.24 48.47,77 v1(47.6,76.13) 46.72,75.25 42.31,75.25 42.01,75.56 40.55,75.56 39.66,74.67 39.66,73.97 40.07,73.56 UV6.C2
FBA_D62: length 16.3
  BOTTOM w0.122: UV6.A3 41.67,74.03 41.8,73.91 42.6,73.91 42.72,74.03 42.72,74.23 42.85,74.36 43.09,74.36 43.22,74.24 43.22,74.13 43.34,74.01 43.58,74.01 43.7,74.13 43.7,74.24 43.83,74.36 44.07,74.36 44.19,74.24 44.19,74.13 44.31,74.01 44.56,74.01 44.68,74.13 44.68,74.24 44.8,74.36 45.04,74.36 45.17,74.24 45.17,74.13 45.29,74.01 45.53,74.01 45.65,74.13 45.65,74.24 45.78,74.36 46.07,74.36 46.2,74.23 46.2,74.13 46.33,74.01 v1(46.52,74.01) 46.71,74.01 46.84,74.13 46.84,74.23 46.96,74.36 47.09,74.36 49.35,76.62 49.35,79.78 49.9,80.33 UV1.W27
FBA_D63: length 15.8
  BOTTOM w0.122: UV1.W25 52.44,79.9 50.13,79.9 49.83,79.6 49.83,76.46 48.27,74.9 48.26,74.9 46.93,73.56 v1(44.55,73.56) UV6.A2
FFS_INT2: length 152.6
  TOP w0.102: v2(157.07,119.5) 156.69,119.88 156.69,126.36 157.37,127.04 U15.9 ; Q19.2 83.73,110.61 83.54,110.42 83.15,110.42 v1(81.94,109.21) 81.76,109.03 81.76,107.81 v2(82.21,107.37)
  IN2 w0.102: v2(100.49,95.43) 101.19,94.73 102.65,94.73 103.35,94.03 107.35,94.03 108.18,93.21 110.82,93.21 v2(111.25,93.64) 112.34,94.73 114.4,94.73 115.29,95.62 122.94,95.62 124.86,97.54 126.9,97.54 127.71,98.35 128.75,98.35 129.32,97.78 132.05,97.78 133.26,98.99 135.74,98.99 136.63,99.88 136.63,110.24 139.37,112.98 146.82,112.98 147.37,112.44 150.52,112.44 151.36,113.28 151.36,114.72 152.55,115.92 153.43,115.92 157.01,119.5 v2(157.07,119.5)
  IN3 w0.102: v2(82.21,107.37) 82.21,105.78 83.6,104.39 83.6,101.85 85.57,99.88 89.64,99.88 94.08,95.43 v2(100.49,95.43)
  BOTTOM w0.076: UC1.G2 110.76,66.82 110.47,67.11 110.47,67.47 110.26,67.67 110.26,68.52 109.83,68.95 109.83,69.84
  BOTTOM w0.102: v2(111.25,93.64) 111.75,93.15 113.89,93.15 114.34,93.59 115.73,93.59 115.99,93.34 115.99,91.77 113.8,89.59 112.58,89.59 110.08,87.09 110.08,83.87 110.97,82.99 110.97,76.99 111.17,76.79 111.17,73.88 RC183.2 111.73,72.83 109.83,70.92 109.83,69.84
FFS_INT2_Q: length 26.7
  TOP w0.102: Q19.3 83.1,110.94 R125.2 83.68,112.58 84.05,112.58 84.81,113.34 84.81,116.71 86.46,118.36 86.46,130.1 86.14,130.42 v1(86.14,132.05) 86.14,133.36 v2(86.78,134)
  BOTTOM w0.102: JSATA1.18 v2(86.78,134)
FMCCLK_REQ#: length 226.9
  IN1 w0.097: v2(194.6,88.51) 192.02,88.51 188.16,84.64 188.16,75.11 186.51,73.47 v2(185.28,73.47)
  IN2 w0.102: v2(121.66,9.84) 120.19,8.37 116.04,8.37 115.71,8.04 115.71,6.21 115.39,5.89 103.94,5.89 101.61,8.22 v2(101.38,8.22)
  BOTTOM w0.102: v2(121.66,9.84) 121.66,11.4 125.07,14.81 129.25,14.81 133,18.55 137.19,18.55 157.69,39.06 157.69,68.05 157.14,68.61 157.14,71.62 157.43,71.91 159.37,71.91 160.27,72.81 163.74,72.81 165.2,74.27 172.88,74.27 173.76,75.15 173.76,76.09 174.18,76.5 177.96,76.5 178.97,75.5 180.64,75.5 182.67,73.47 v2(185.28,73.47) ; JMINI2.7 210.22,131.5 209.84,131.12 197.46,131.12 195.43,129.09 v1(195.43,97.26) 195.43,92.6 194.13,91.3 194.13,88.98 v2(194.6,88.51) ; R168.2 102.22,3.1 R485.1 102.21,2.47 101.74,2 101.07,2 100.34,2.72 100.34,5.78 101.05,6.49 U93.1 101.05,7.89 v2(101.38,8.22)
FPR_DET#: length 40.9
  TOP w0.102: U37.A16 163.73,103.43 163.87,103.56 v2(163.87,103.8) 163.3,104.37 163.3,104.45 163.04,104.7 162.9,104.7 R481.1 ; JBIO1.5 189.38,100.97 189.78,100.58 189.78,96.64 189.24,96.1 185.71,96.1 184.35,97.46 179.25,97.46 v1(178.75,97.96) 177.71,99 177.71,103.31 v2(177.27,103.75)
  BOTTOM w0.102: v2(163.87,103.8) 164.36,103.31 170.86,103.31 172,104.45 176.57,104.45 v2(177.27,103.75)
FWP#: length 17.9
  TOP w0.102: v1(138.3,89.59) 137.91,89.98 R393.2 R399.2 137.91,92.02 138.6,92.71 v2(138.6,92.76) ; U38.B65 141.29,101.31 v2(141.3,101.31)
  BOTTOM w0.102: v2(138.6,92.76) 139.1,92.76 139.28,92.94 139.28,95.51 136.82,97.97 136.82,98.61 137.07,98.86 138.28,98.86 138.56,99.14 138.56,99.97 139.9,101.31 v2(141.3,101.31)
GFB: length 4.4
  BOTTOM w0.203: PU300.23 48.29,19.34 48.14,19.5 47.62,19.5 47.38,19.26 47.38,18.1 v1(47.05,17.77) PR335.2
GPIO8_THERMATRIP#: length 21.1
  BOTTOM w0.102: QC6.1 80.94,91.45 81.04,91.54 81.04,92.49 80.54,92.99 80.54,93.65 80.14,94.06 80.14,97.37 78.98,98.53 v1(72.78,98.53) RV48.1 68.57,96.83 UV1.A6
GPIO09_GPUHOT#: length 13.2
  TOP w0.102: v1(69.1,82.31) 69.16,82.37 v2(69.87,82.37) 70.01,82.23 QC11.1 ; v4(67.35,91.62) 67.35,91.1 RV34.1
  IN2 w0.102: v4(67.35,91.62) 68.36,90.61 68.36,86.73 69.87,85.23 v2(69.87,82.37)
  BOTTOM w0.102: UV1.F8 66.93,91.2 v4(67.35,91.62)
GPIO11_NVVDD_VID: length 188.2
  TOP w0.102: v2(173.74,93.44) 173.33,93.84 U37.A49
  IN2 w0.102: v2(60.49,32.5) 62.52,34.54 62.97,34.54 64.82,36.39 79.49,36.39 82.45,39.35 82.45,59.86 80.56,61.75 80.56,64.95 81.18,65.57 81.18,70.65 82.02,71.49 82.46,71.49 82.83,71.86 82.83,82.55 81.91,83.47 v2(81.91,83.48) 79.93,85.46 79.93,88.48 v2(80.28,88.83)
  IN3 w0.102: v2(173.74,93.44) 172.06,93.44 171.47,92.85 170.08,92.85 168.71,91.48 168.71,90.17 168.25,89.72 167.38,89.72 165.39,87.73 165.39,86.98 163.77,85.35 163.77,84.64 162.47,83.34 157.92,83.34 156.67,84.6 151.94,84.6 149.67,86.87 141.24,86.87 140.61,87.5 136.38,87.5 135.66,86.77 130.49,86.77 129.74,87.52 120.07,87.52 119.37,86.82 117.83,86.82 117.16,86.16 116.62,86.16 116.05,86.73 111.56,86.73 111.27,86.45 109.43,86.45 109.15,86.73 106.21,86.73 105.45,85.97 102.59,85.97 101.94,85.32 100.26,85.32 99.39,86.19 98.19,86.19 97.43,85.42 94.29,85.42 93.52,84.66 90.55,84.66 89.79,83.9 82.33,83.9 v2(81.91,83.48)
  BOTTOM w0.102: v2(80.28,88.83) 80.28,89.95 80.48,90.15 QC6.3
  BOTTOM w0.254: PU600.5 v1(59.96,34.55) 60.19,34.55 60.48,34.26 60.48,33.57 60.65,33.39 PR600.2 PR602.1 v2(60.49,32.5)
GPIO11_NVVDD_VID_R: length 14.9
  BOTTOM w0.102: QC6.4 78.32,90.15 77.89,89.72 v1(76.71,89.72) 75.35,89.72 73.8,88.17 70.1,88.17 69.87,88.4 69.87,90.43 69.65,90.65 68.38,90.65 68.17,90.86 68.17,91.55 UV1.E7
GPIO12_AC_DETECT: length 9.5
  TOP w0.102: QC8.1 71.52,94.81 71.4,94.94 RV35.1 70.84,95.5 70.48,95.85 67.33,95.85 66.74,95.25 v1(66.74,94.87) 66.74,94.68 68.16,93.26 68.16,93.1 v4(68.17,93.1)
  BOTTOM w0.1: UV1.D7 67.82,92.75 v4(68.17,93.1)
GPIO13_NVVDD_PSI: length 84
  TOP w0.254: QC8.3 72.7,93.51 v2(73.51,92.7)
  IN2 w0.102: v2(62.84,35.17) 63.09,35.17 64.72,36.8 78.94,36.8 81.83,39.68 81.83,59.67 80.17,61.32 80.17,65.08 80.87,65.78 80.87,70.79 81.7,71.62 81.7,72.51 82.14,72.95 82.14,80.51 78.33,84.32 78.33,90.29 76.49,92.13 74.08,92.13 v2(73.51,92.7)
  BOTTOM w0.102: v2(62.84,35.17) 62.88,35.17 63.5,34.55 v1(63.51,34.55)
  BOTTOM w0.254: v2(62.84,35.17) PR634.1
GPIO13_NVVDD_PSI_R: length 6.8
  TOP w0.102: QC8.4 74.08,93.26 74.08,92.51 73.76,92.19 73,92.19 v1(72.81,92.38) 72.68,92.51 71.78,92.51 RV2446.1 71.02,92.33 70.69,92.66 v2(70.69,93.15)
  BOTTOM w0.102: UV1.B4 70.67,93.95 70.67,93.16 v2(70.69,93.15)
GPIO_PSID_SELECT: length 61.1
  TOP w0.102: v2(169.01,109.23) 168.87,109.23 v1(168.34,108.69) ; v2(169.01,103.79) 168.73,103.51 U37.A6
  TOP w0.254: v2(126.4,119.5) 125.96,119.5 125.72,119.74 PU1.6
  IN3 w0.102: v2(169.01,103.79) 168.77,103.79 168.62,103.94 168.62,104.96 169.49,105.83 169.49,108.74 v2(169.01,109.23)
  BOTTOM w0.102: v2(126.4,119.5) 126.59,119.31 128.5,119.31 129.5,118.3 131.59,118.3 132.21,118.92 133.12,118.92 134.21,117.84 134.21,115.38 135.43,114.16 142.02,114.16 143.23,115.37 151.18,115.37 151.67,115.87 158.33,115.87 159.14,115.06 159.14,114.36 159.58,113.91 164,113.91 165.26,112.65 165.26,111.18 167.22,109.23 v2(169.01,109.23)
GPIOA6: length 23.7
  TOP w0.102: U37.B55 171.51,95.09 v2(171.42,95.17) ; v2(161.2,93.74) 160.6,93.14 158.84,93.14 158.38,92.68 v1(158.38,92.33) 158.86,91.85 ; R78.2 159.19,90.67 159.19,91.52 158.86,91.85 ; 158.86,91.85 157.74,90.74 R70.2
  BOTTOM w0.102: v2(161.2,93.74) 161.34,93.88 163.07,93.88 163.97,94.78 163.97,95.36 163.75,95.58 163.27,95.58 162.95,95.9 162.95,96.19 163.33,96.57 164.81,96.57 165.12,96.25 168.1,96.25 169.04,95.31 169.63,95.31 169.99,94.96 171.21,94.96 v2(171.42,95.17)
GPIOA7: length 21.7
  TOP w0.102: R72.2 157.74,88.58 R79.2 157.99,89.33 158.24,89.59 158.24,90.63 v2(158.76,91.15) ; v2(173.74,95.24) 173.64,95.34 U37.A52
  IN2 w0.102: v2(158.76,91.15) 158.96,90.95 160.14,90.95 161.03,91.84 162.66,91.84 163.3,92.48 172.02,92.48 173.31,93.78 173.31,95.06 173.5,95.24 v2(173.74,95.24)
GPU_B+: length 28.1
  TOP w0.102: v2(79.86,54.6) v5(79.23,54.6)
  IN1 w0.254: v2(54.7,26.52) 55.57,25.65 63.18,25.65 66.32,28.78 66.32,37.51 67.98,39.17 v2(67.98,39.3)
  BOTTOM w0.254: PR614.1 54.71,28.58 PC619.1 v2(54.7,26.52)
  vias: v2(65.06,50.54) v2(65.06,49.9) v2(65.06,49.27) v2(65.7,50.54) v2(65.7,49.9) v2(65.7,49.27) v2(79.86,55.87) v2(79.86,55.24) v2(80.49,55.87) v2(80.49,55.24) v2(80.49,54.6)
GPU_COMP: length 5
  BOTTOM w0.254: PU600.12 55.24,32.9 55.09,32.76 54.2,32.76 v1(53.64,32.2) 53.31,31.87 52.16,31.87 PC623.2 PC622.2
GPU_DSBL/ISEN1: length 6
  BOTTOM w0.254: PR636.1 49.83,36.11 50.11,35.84 51.58,35.84 PC626.1 v1(53.26,35.24) 53.45,35.05 PU600.15
GPU_EN: length 6.9
  BOTTOM w0.102: v1(63.36,36.31) 63.36,36.83 62.73,37.46 PD601.2
  BOTTOM w0.254: PU600.3 59.41,35.55 59.48,35.61 60.08,35.61 60.43,35.96 60.43,36.72 PR627.1 62.51,37.47 PD601.2
GPU_FB: length 6.5
  BOTTOM w0.254: PR621.2 51.18,29.91 PC620.2 52.29,30.15 52.42,30.15 v1(53.12,30.85) 54.58,32.31 55.54,32.31 55.74,32.51 PU600.11
GPU_FBRTN: length 13.3
  IN1 w0.254: v2(55.6,31.61) 55.6,30.03 56.49,29.14 v2(56.49,27.74)
  BOTTOM w0.254: PC617.2 57.38,27.69 PC616.2 ; PC616.2 57.33,27.64 PR611.2 ; PC616.2 56.55,27.68 v2(56.49,27.74) ; PR616.2 PR615.2 53.82,30.16 53.82,30.83 54.61,31.61 v1(55.07,31.61) v2(55.6,31.61) 56.24,32.25 PU600.10
GPU_JTAG_TCK: length 5.5
  BOTTOM w0.102: UV1.AE5 69.84,74.93 69.84,73.63 70.08,73.39 70.08,71.84 T186.1
GPU_JTAG_TDI: length 4.2
  BOTTOM w0.102: UV1.AE6 68.96,74.73 68.96,74.41 69.15,74.22 69.15,73.1 69.57,72.68 T188.1
GPU_JTAG_TDO: length 5.4
  BOTTOM w0.102: UV1.AF6 68.57,74.5 68.94,74.13 68.94,72.94 69.25,72.63 69.25,70.55 T189.1
GPU_JTAG_TMS: length 1.6
  TOP w0.102: T187.1 68.65,75.26 v4(68.17,75.74)
  BOTTOM w0.1: v4(68.17,75.74) 68.57,76.15 UV1.AD6
GPU_JTAG_TRST#: length 7.2
  BOTTOM w0.102: RV88.2 72.89,69.63 T190.1 73.01,71.01 UV1.AG4
GPU_PGOOD: length 33.9
  IN2 w0.254: v2(53.06,36.12) 53.06,35.61 51.03,33.58 47.22,33.58 41.76,28.12 33.37,28.12 v2(31.28,30.22)
  BOTTOM w0.102: v1(50.49,39.92) 51.27,39.92 52.12,39.07 PR633.1
  BOTTOM w0.254: PR633.1 PR626.2 PC625.1 52.17,37.27 53.06,36.38 v2(53.06,36.12) 53.64,35.55 PU600.16 ; v2(31.28,30.22) 31.28,30.22 PR704.1
GPU_PLLVDD: length 6.2
  TOP w0.102: v1(67.42,87.84) 67.91,87.35 CV236.1
  TOP w0.508: L73.2 71.85,88.17 CV3064.1 70.24,88.17 69.43,87.36 v2(69.07,87.36) 68.37,87.36 CV236.1
  BOTTOM w0.254: UV1.L6 68.64,86.93 v2(69.07,87.36)
GPU_PVCC: length 14.2
  TOP w0.102: v2(49.31,38.54) 49.31,38.32 v1(48.87,37.87)
  IN1 w0.508: v2(56.81,39.68) 56.49,40 50.33,40 49.31,38.98 v2(49.31,38.54)
  BOTTOM w0.254: v2(49.31,38.54) 49.31,38.15 PR630.1 48.92,36.69 PR636.2 ; 56.24,39.55 PU600.21
GPU_PWR_LEVEL: length 98.4
  TOP w0.102: RV74.2 76.63,94.73 78.1,93.26 78.1,92.76 78.36,92.51 v1(78.36,90.84) 78.36,89.6 79.65,88.3 81.18,88.3 81.56,88.68 84.8,88.68 v2(85.6,89.48) ; R70.1 R79.1 156.83,88.32 R296.2 155.76,88.25 155.61,88.4 152.45,88.4 v2(151.64,87.6)
  IN3 w0.102: v2(85.6,89.48) 86.38,90.27 101.67,90.27 102.06,89.89 103.26,89.89 103.6,90.23 109.07,90.23 109.41,89.89 115.87,89.89 116.85,90.87 123.35,90.87 123.71,91.22 130.22,91.22 130.53,91.53 139.1,91.53 139.83,92.25 143.57,92.25 144.13,92.81 144.13,93.62 145.92,95.42 148.78,95.42 149.3,94.89 149.3,89.59 151.29,87.6 v2(151.64,87.6)
GPU_REFADJ: length 5.3
  BOTTOM w0.254: PU600.6 59.12,34.05 60.02,33.15 v1(60.02,32.86) 60.02,32.66 58.28,30.92 PR608.2
GPU_REFIN: length 11.3
  IN1 w0.254: v2(57.95,26.22) 57.89,26.28 v2(57.89,31.93)
  BOTTOM w0.102: v1(58.56,32.08) 58.41,31.93 v2(57.89,31.93)
  BOTTOM w0.254: PR610.1 57.44,25.71 v2(57.95,26.22) 58.28,26.55 PC616.1 58.26,27.69 PR607.1 ; PU600.7 57.74,32.08 v2(57.89,31.93)
GPU_SMBCLK: length 97.8
  TOP w0.102: U38.B49 142.14,108.13 142.34,107.94 v2(142.34,107.66) ; RP7.4 134.14,106.53 v2(134.2,106.47)
  IN1 w0.097: v2(69.32,106.16) 69.63,106.16 71.61,108.14 79.16,108.14 84.75,113.72 84.75,114.35 90.34,119.95 105.8,119.95 106.11,120.26 106.11,120.64 105.96,120.79 v2(105.96,120.79)
  BOTTOM w0.102: QC9.6 69.6,105.88 v2(69.32,106.16) ; v2(142.34,107.66) 142.34,107.66 142.34,107.92 142.05,108.21 141.15,109.11 137.23,109.11 136.6,108.48 136.6,106.96 135.68,106.04 134.63,106.04 v2(134.2,106.47) 134.39,106.66 134.39,108.51 134.94,109.05 134.94,110.01 133.73,111.21 133.73,112.23 131.58,114.38 125.46,114.38 124.38,115.46 120.15,115.46 119.89,115.71 111.26,115.71 110.43,116.54 108.65,116.54 108.34,116.86 106.24,116.86 105.41,117.69 105.41,118.77 106.13,119.49 106.13,120.61 v2(105.96,120.79)
