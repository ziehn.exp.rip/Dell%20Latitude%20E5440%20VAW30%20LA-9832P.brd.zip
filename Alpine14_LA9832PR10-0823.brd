# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D23: length 67.5
  IN1 w0.076: 136.75,27.98 136.69,27.93 134.25,27.93 132.33,29.86 v2(132.33,30.65)
  IN1 w0.097: 136.75,27.98 138.85,27.98 139.3,27.54 148.5,27.54 148.65,27.69 148.65,27.95 148.78,28.08 149.03,28.08 149.15,27.95 149.15,27.69 149.3,27.54 149.51,27.54 149.66,27.69 149.66,27.95 149.78,28.08 150.03,28.08 150.16,27.95 150.16,27.69 150.31,27.54 150.52,27.54 150.66,27.69 150.66,27.95 150.79,28.08 151.04,28.08 151.17,27.95 151.17,27.69 151.31,27.54 151.52,27.54 151.67,27.69 151.67,27.95 151.8,28.08 152.04,28.08 152.17,27.95 152.17,27.69 152.32,27.54 152.53,27.54 152.67,27.69 152.67,27.95 152.8,28.08 153.05,28.08 153.18,27.95 153.18,27.69 153.33,27.54 153.53,27.54 153.68,27.69 153.68,27.95 153.81,28.08 157.72,28.08 160.56,25.25 161.9,25.25 162.03,25.11 162.03,24.55 162.16,24.42 171.19,24.42 172,23.61 174.02,23.61 174.53,24.12 181.51,24.12 v2(182.27,23.36)
  BOTTOM w0.076: UC1.AU56 127.45,33.02 127.74,33.31 127.98,33.31 127.99,33.31 128.09,33.31 128.37,33.58 129.35,33.58 129.5,33.44 130.49,33.44 132.33,31.59 v2(132.33,30.65)
  BOTTOM w0.102: v2(182.27,23.36) 182.56,23.65 JDIMM1.52
DDR_A_D24: length 61
  IN1 w0.076: v2(134.53,28.48) 134.67,28.62 136.55,28.62 136.75,28.81
  IN1 w0.097: v2(177.7,25.65) 177.28,25.22 164.32,25.22 162.83,26.71 160.23,26.71 158.06,28.88 146.65,28.88 146.51,28.73 146.51,28.5 146.36,28.35 146.15,28.35 146,28.5 146,28.73 145.86,28.88 145.65,28.88 145.5,28.73 145.5,28.5 145.35,28.35 145.15,28.35 145,28.5 145,28.73 144.85,28.88 144.64,28.88 144.5,28.73 144.5,28.5 144.35,28.35 144.14,28.35 143.99,28.5 143.99,28.73 143.85,28.88 143.64,28.88 143.49,28.73 143.49,28.5 143.34,28.35 143.13,28.35 142.99,28.5 142.99,28.73 142.84,28.88 142.63,28.88 142.48,28.73 142.48,28.5 142.34,28.35 142.13,28.35 141.98,28.5 141.98,28.73 141.83,28.88 141.63,28.88 141.48,28.73 141.48,28.5 141.33,28.35 141.12,28.35 140.98,28.5 140.98,28.73 140.83,28.88 140.62,28.88 140.47,28.73 140.47,28.5 140.33,28.35 140.05,28.35 139.93,28.48 139.93,28.68 139.8,28.81 136.75,28.81
  BOTTOM w0.076: UC1.AY54 129.29,34.08 129.56,34.08 129.71,33.93 130.69,33.93 134.78,29.85 134.78,28.73 v2(134.53,28.48)
  BOTTOM w0.102: v2(177.7,25.65) 177.2,25.15 JDIMM1.57
DDR_A_D25: length 61.5
  IN1 w0.076: v2(133.62,29.3) 133.62,28.8 134.3,28.12 134.9,28.12 135.09,28.31 136.55,28.31 136.75,28.51
  IN1 w0.097: 136.75,28.51 139.04,28.51 139.5,28.04 146.89,28.04 147.04,28.19 147.04,28.43 147.18,28.58 147.39,28.58 147.54,28.43 147.54,28.19 147.69,28.04 147.89,28.04 148.04,28.19 148.04,28.43 148.19,28.58 157.93,28.58 160.76,25.75 163.37,25.75 164.2,24.92 178.5,24.92 v2(179.22,25.65)
  BOTTOM w0.076: v2(133.62,29.3) 133.62,30.77 130.63,33.77 129.64,33.77 129.49,33.92 129.04,33.92 128.75,34.21 UC1.AW54
  BOTTOM w0.102: JDIMM1.59 177.17,25.75 177.53,26.11 178.75,26.11 v2(179.22,25.65)
DDR_A_D26: length 60.9
  IN1 w0.076: v2(133.83,31.93) 133.94,31.82 134.8,31.82
  IN1 w0.097: v2(177.7,28.96) 176.46,30.2 171.37,30.2 171.28,30.1 171.28,29.4 171.18,29.3 170.87,29.3 170.77,29.4 170.77,30.1 170.68,30.2 162.86,30.2 161.69,31.37 155.13,31.37 155.09,31.41 155.09,31.68 154.94,31.82 154.73,31.82 154.58,31.68 154.58,31.54 154.44,31.39 154.23,31.39 154.08,31.54 154.08,31.68 153.93,31.82 153.73,31.82 153.58,31.68 153.58,31.54 153.43,31.39 153.22,31.39 153.08,31.54 153.08,31.68 152.93,31.82 152.72,31.82 152.57,31.68 152.57,31.54 152.43,31.39 152.22,31.39 152.07,31.54 152.07,31.68 151.92,31.82 151.71,31.82 151.57,31.68 151.57,31.54 151.42,31.39 151.21,31.39 151.06,31.54 151.06,31.68 150.92,31.82 150.71,31.82 150.56,31.68 150.56,31.54 150.41,31.39 150.21,31.39 150.06,31.54 150.06,31.68 149.91,31.82 149.7,31.82 149.55,31.68 149.55,31.54 149.41,31.39 149.2,31.39 149.05,31.54 149.05,31.68 148.9,31.82 148.7,31.82 148.55,31.68 148.55,31.54 148.4,31.39 148.19,31.39 148.05,31.54 148.05,31.68 147.9,31.82 147.69,31.82 147.54,31.68 147.54,31.54 147.4,31.39 147.16,31.39 147.01,31.54 147.01,31.68 146.87,31.82 146.66,31.82 146.51,31.68 146.51,31.54 146.36,31.39 146.15,31.39 146.01,31.54 146.01,31.68 145.86,31.82 142.69,31.82 142.24,32.27 136.14,32.27 135.69,31.82 134.8,31.82
  BOTTOM w0.076: v2(133.83,31.93) 133.83,32.6 133.54,32.9 133.54,33.13 131.26,35.41 129.79,35.41 129.77,35.43 129.29,35.43 UC1.AY52
  BOTTOM w0.102: JDIMM1.67 177.05,28.15 177.7,28.8 v2(177.7,28.96)
DDR_A_D27: length 62.6
  IN1 w0.076: v2(134.75,31.01) 134.75,31.4 134.88,31.52 137.03,31.52
  IN1 w0.097: v2(179.22,28.96) 178.8,28.54 177.23,28.54 176.78,28.99 170.26,28.99 170.16,29.09 170.16,29.61 170.07,29.71 169.76,29.71 169.66,29.61 169.66,29.09 169.56,28.99 163.64,28.99 161.57,31.07 145.63,31.07 145.56,31.14 145.56,31.4 145.43,31.52 145.18,31.52 145.08,31.42 145.08,31.22 144.96,31.09 144.71,31.09 144.58,31.22 144.58,31.37 144.43,31.52 144.18,31.52 144.08,31.42 144.08,31.22 143.95,31.09 143.7,31.09 143.57,31.22 143.57,31.37 143.42,31.52 143.17,31.52 143.07,31.42 143.07,31.22 142.94,31.09 142.76,31.09 141.96,31.89 139.88,31.89 139.51,31.52 137.03,31.52
  BOTTOM w0.076: UC1.AW52 128.73,35.78 128.94,35.78 128.99,35.8 129,35.8 129.1,35.85 129.29,35.85 129.54,35.6 129.84,35.6 129.86,35.58 131.32,35.58 134.75,32.15 v2(134.75,31.01)
  BOTTOM w0.102: JDIMM1.69 176.7,28.75 177.34,29.39 178.79,29.39 v2(179.22,28.96)
DDR_A_D28: length 62.5
  IN1 w0.076: 136.58,28.97 134.59,28.97 133.8,29.76 v2(133.2,29.76)
  IN1 w0.097: v2(180.75,25.65) 180.34,26.05 175.81,26.05 175.4,25.65 170.81,25.65 170.03,26.42 165.17,26.42 165.07,26.52 165.07,27 164.98,27.09 164.67,27.09 164.57,27 164.57,26.52 164.47,26.42 164.19,26.42 164.07,26.55 164.07,26.89 163.94,27.02 160.63,27.02 158.47,29.18 139.29,29.18 139.29,29.18 136.79,29.18 136.58,28.97
  BOTTOM w0.076: v2(133.2,29.76) 133.2,30.96 130.56,33.6 129.57,33.6 129.42,33.75 128.56,33.75 127.99,34.31 UC1.AV54
  BOTTOM w0.102: v2(180.75,25.65) 181.54,24.85 JDIMM1.56
DDR_A_D29: length 62.6
  IN1 w0.076: 136.47,29.33 135.21,29.33 131.06,33.49 v2(131.06,34.63)
  IN1 w0.097: v2(182.27,25.65) 181.57,26.35 175.67,26.35 175.27,25.95 170.93,25.95 170.16,26.72 166.21,26.72 165.49,27.43 160.64,27.43 158.59,29.48 136.62,29.48 136.47,29.33
  BOTTOM w0.076: UC1.AU54 127.21,34.97 127.42,35.17 128.26,35.17 128.27,35.17 128.36,35.13 128.41,35.1 128.62,35.1 128.77,35.17 128.9,35.17 129.01,35.13 129.06,35.1 129.57,35.1 129.59,35.08 130.6,35.08 v2(131.06,34.63)
  BOTTOM w0.102: v2(182.27,25.65) 182.47,25.45 JDIMM1.58
DDR_A_D30: length 62.3
  IN1 w0.076: v2(133.37,32.39) 133.48,32.28 135.41,32.28
  IN1 w0.097: 135.41,32.28 135.71,32.58 142.47,32.58 142.93,32.12 160.48,32.12 160.76,31.84 161.75,31.84 163.09,30.5 177.5,30.5 177.6,30.4 177.6,29.56 177.72,29.43 177.97,29.43 178.1,29.56 178.1,30.4 178.19,30.5 180.62,30.5 180.75,30.37 v2(180.75,28.96)
  BOTTOM w0.076: UC1.AV52 128.21,35.45 128.34,35.32 128.4,35.29 128.45,35.27 128.58,35.27 128.6,35.28 128.68,35.32 128.74,35.34 128.94,35.34 128.99,35.32 129.1,35.27 129.7,35.27 129.72,35.25 131.19,35.25 133.37,33.06 v2(133.37,32.39)
  BOTTOM w0.102: v2(180.75,28.96) 181.25,28.45 JDIMM1.68
DDR_A_D31: length 63.6
  IN1 w0.076: v2(135.21,30.55) 135.38,30.72 136.56,30.72
  IN1 w0.097: 136.56,30.72 137.22,30.72 137.32,30.81 137.32,31.02 137.47,31.17 137.67,31.17 137.82,31.02 137.82,30.86 137.97,30.72 138.19,30.72 138.34,30.86 138.34,31.02 138.49,31.17 138.7,31.17 138.84,31.02 138.84,30.86 138.99,30.72 139.2,30.72 139.35,30.86 139.35,31.02 139.49,31.17 139.7,31.17 140.04,30.83 140.66,30.83 141.35,31.51 141.91,31.51 142.73,30.69 161.27,30.69 163.27,28.69 176.65,28.69 177.11,28.23 181.54,28.23 v2(182.27,28.96)
  BOTTOM w0.076: v2(135.21,30.55) 135.21,31.93 131.4,35.74 129.93,35.74 129.91,35.76 129.61,35.76 129.36,36.02 129.06,36.02 129.01,35.99 128.9,35.94 127.6,35.94 UC1.AU52
  BOTTOM w0.102: JDIMM1.70 182.36,29.05 v2(182.27,28.96)
DDR_A_D32: length 62.5
  IN1 w0.076: 135.86,48 134.19,48 133.88,48.31 133.19,48.31 133.02,48.48 132.54,48.48 v2(132.18,48.83)
  IN1 w0.097: v2(179.22,48.32) 178.82,47.91 177.39,47.91 176.22,49.09 171.12,49.09 170.72,48.68 163.22,48.68 162.52,49.38 160.87,49.38 160.47,49.78 149.1,49.78 149,49.88 149,50.69 148.9,50.79 148.59,50.79 148.5,50.69 148.5,49.88 148.4,49.78 148.09,49.78 147.99,49.88 147.99,50.69 147.9,50.79 147.59,50.79 147.49,50.69 147.49,49.88 147.39,49.78 147.08,49.78 146.96,49.9 146.96,50.52 146.87,50.61 146.56,50.61 146.46,50.52 146.46,49.85 146.39,49.78 145.54,49.78 143.77,48 135.86,48
  BOTTOM w0.076: UC1.AY31 129.48,48.13 131.48,48.13 v2(132.18,48.83)
  BOTTOM w0.102: JDIMM1.129 176.75,49.15 177.01,48.89 177.01,48.22 177.36,47.87 178.78,47.87 v2(179.22,48.32)
DDR_A_D33: length 63.3
  IN1 w0.076: 136.61,48.3 134.12,48.3 133.95,48.48 133.26,48.48 132.9,48.83 v2(132.79,48.83)
  IN1 w0.097: 136.61,48.3 136.61,48.3 143.64,48.3 146.57,51.23 149.33,51.23 149.43,51.14 149.43,50.17 149.52,50.08 149.83,50.08 149.93,50.17 149.93,51.14 150.03,51.23 150.34,51.23 150.43,51.14 150.43,50.17 150.53,50.08 150.84,50.08 150.94,50.17 150.94,51.14 151.03,51.23 151.34,51.23 151.44,51.14 151.44,50.17 151.54,50.08 151.85,50.08 151.94,50.17 151.94,51.14 152.04,51.23 152.35,51.23 152.44,51.14 152.44,50.17 152.54,50.08 152.85,50.08 152.95,50.17 152.95,50.41 153.07,50.54 153.32,50.54 153.45,50.41 153.45,50.17 153.55,50.08 160.6,50.08 160.99,49.68 162.65,49.68 163.35,48.98 170.59,48.98 171,49.39 176.34,49.39 177.41,48.32 v2(177.7,48.32)
  BOTTOM w0.076: v2(132.79,48.83) 131.92,47.96 129.38,47.96 129.19,48.15 129.09,48.15 128.92,48.24 128.72,48.44 UC1.AW31
  BOTTOM w0.102: v2(177.7,48.32) 177.7,49.23 177.18,49.75 JDIMM1.131
DDR_A_D34: length 63
  IN1 w0.076: v2(135.02,50.32) 135.4,50.7 136.36,50.7 136.63,50.44 136.95,50.44
  IN1 w0.097: 136.95,50.44 142.66,50.44 142.79,50.57 142.79,50.57 142.81,50.59 142.82,50.59 143.66,51.43 143.66,51.44 144.36,52.14 144.36,52.14 145.59,53.37 147.99,53.37 148.52,53.89 154.19,53.89 154.28,53.8 154.28,53.49 154.41,53.37 154.66,53.37 154.78,53.49 154.78,53.8 154.88,53.89 155.19,53.89 155.29,53.8 155.29,53.49 155.41,53.37 155.67,53.37 155.79,53.49 155.79,53.8 155.89,53.89 156.2,53.89 156.29,53.8 156.29,53.49 156.42,53.37 156.67,53.37 156.8,53.49 156.8,53.8 156.89,53.89 157.2,53.89 157.3,53.8 157.3,53.06 157.43,52.94 157.68,52.94 157.8,53.06 157.8,53.8 157.9,53.89 158.21,53.89 158.34,53.77 158.34,52.6 158.47,52.47 158.74,52.47 158.86,52.6 158.86,53.37 158.99,53.49 159.24,53.49 159.37,53.37 159.37,52.6 159.49,52.47 162.95,52.47 163.68,51.74 172.54,51.74 172.77,51.51 175.2,51.51 175.29,51.61 175.29,52.41 175.39,52.51 175.7,52.51 175.8,52.41 175.8,51.66 175.89,51.56 176.2,51.56 176.3,51.66 176.3,51.93 176.43,52.06 176.68,52.06 176.8,51.93 176.8,51.66 176.9,51.56 177.52,51.56 v2(177.7,51.75)
  BOTTOM w0.076: UC1.AY29 130.17,49.79 130.38,49.58 134.29,49.58 v2(135.02,50.32)
  BOTTOM w0.102: JDIMM1.141 176.69,52.75 v2(177.7,51.75)
DDR_A_D35: length 64.1
  IN1 w0.076: v2(134.37,50.32) 134.92,50.86 136.52,50.86 136.64,50.74 136.95,50.74
  IN1 w0.097: v2(179.22,51.75) 179.22,51.92 179.55,52.25 180.24,52.25 180.36,52.38 180.36,52.7 180.24,52.83 179.04,52.83 178.91,52.7 178.91,52.31 178.79,52.19 178.47,52.19 178.34,52.31 178.34,52.7 178.22,52.83 177.88,52.83 177.78,52.73 177.78,52.27 177.65,52.15 177.4,52.15 177.28,52.27 177.28,52.73 177.18,52.83 176.87,52.83 176.77,52.73 176.77,52.47 176.68,52.38 176.37,52.38 176.27,52.47 176.27,52.73 176.17,52.83 175.09,52.83 174.65,52.38 169.82,52.38 169.48,52.04 163.81,52.04 163.07,52.77 160.38,52.77 158.96,54.19 148.39,54.19 147.87,53.67 145.46,53.67 144.06,52.27 144.06,52.27 142.67,50.87 142.66,50.87 142.53,50.74 136.95,50.74
  BOTTOM w0.076: UC1.AW29 128.75,49.79 129.04,50.08 129.29,50.08 129.41,49.96 130.27,49.96 130.48,49.75 133.8,49.75 v2(134.37,50.32)
  BOTTOM w0.102: JDIMM1.143 176.81,53.35 177.98,52.19 178.78,52.19 v2(179.22,51.75)
DDR_A_D36: length 63.6
  IN1 w0.076: 136.23,48.9 135.93,49.2 134.34,49.2 v2(133.97,48.83)
  IN1 w0.097: v2(182.27,48.32) 182.27,48.89 182.14,49.02 177.56,49.02 176.57,50 170.76,50 170.34,49.58 163.6,49.58 162.89,50.28 161.24,50.28 160.85,50.68 157.97,50.68 157.88,50.77 156.91,50.77 156.82,50.68 156.57,50.68 156.48,50.77 156.48,51.61 156.38,51.71 156.07,51.71 155.98,51.61 155.98,50.77 155.88,50.68 155.57,50.68 155.47,50.77 155.47,51.74 155.38,51.83 146.28,51.83 143.35,48.9 136.23,48.9
  BOTTOM w0.076: v2(133.97,48.83) 132.93,47.8 129.24,47.8 129.05,47.98 129.01,48 128.91,48.06 128.25,48.06 UC1.AV31
  BOTTOM w0.102: v2(182.27,48.32) 182.27,48.8 182.92,49.45 JDIMM1.130
DDR_A_D37: length 65.2
  IN1 w0.076: 135.43,48.48 134.97,48.48 v2(134.62,48.83)
  IN1 w0.097: v2(180.75,48.32) 180.34,48.72 177.43,48.72 176.46,49.69 170.87,49.69 170.47,49.28 163.47,49.28 162.77,49.98 161.12,49.98 160.72,50.38 155.13,50.38 155,50.51 155,51.31 154.88,51.44 154.63,51.44 154.5,51.31 154.5,50.51 154.37,50.38 154.12,50.38 154,50.51 154,51.44 153.9,51.53 153.59,51.53 153.49,51.44 153.49,50.93 153.4,50.84 153.09,50.84 152.99,50.93 152.99,51.44 152.89,51.53 146.44,51.53 143.5,48.6 135.55,48.6 135.43,48.48
  BOTTOM w0.076: UC1.AU31 127.21,49.2 127.42,49.41 127.66,49.41 127.67,49.39 128.05,49.39 128.07,49.41 128.26,49.41 128.27,49.4 128.41,49.33 128.62,49.33 128.77,49.41 128.9,49.41 129.01,49.36 129.06,49.33 129.5,49.33 129.6,49.44 130.01,49.44 130.2,49.25 134.2,49.25 v2(134.62,48.83)
  BOTTOM w0.102: v2(180.75,48.32) 182.48,50.05 JDIMM1.132
DDR_A_D38: length 64.1
  IN1 w0.076: 136.95,50.14 136.42,50.14 136.24,50.31 v2(136.24,50.32)
  IN1 w0.097: 136.95,50.14 142.78,50.14 142.91,50.27 142.92,50.27 142.94,50.29 142.94,50.29 145.72,53.07 156.87,53.07 157.77,52.17 162.82,52.17 163.56,51.44 166.01,51.44 166.11,51.34 166.11,51.24 166.24,51.11 166.49,51.11 166.61,51.24 166.61,51.34 166.71,51.44 167.02,51.44 167.12,51.34 167.12,51.28 167.21,51.18 167.52,51.18 167.62,51.28 167.62,51.34 167.72,51.44 168.03,51.44 168.12,51.34 168.12,51.26 168.25,51.14 168.5,51.14 168.62,51.26 168.62,51.34 168.72,51.44 169.2,51.44 169.27,51.37 169.27,50.97 169.4,50.84 169.65,50.84 169.77,50.97 169.77,51.32 169.89,51.44 172.42,51.44 172.65,51.21 178.98,51.21 179.11,51.09 179.11,50.85 179.23,50.72 179.61,50.72 179.71,50.82 179.71,51.2 179.8,51.3 180.11,51.3 180.21,51.2 180.21,50.82 180.31,50.72 180.62,50.72 180.71,50.82 180.71,51.2 180.81,51.3 181.12,51.3 181.22,51.2 181.22,50.82 181.31,50.72 182.14,50.72 182.27,50.85 v2(182.27,51.75)
  BOTTOM w0.076: UC1.AV29 127.95,49.6 128.29,49.6 128.34,49.55 128.45,49.5 128.58,49.5 128.6,49.51 128.68,49.55 128.68,49.55 128.74,49.57 128.94,49.57 129.1,49.5 129.43,49.5 129.53,49.6 130.12,49.6 130.31,49.42 135.42,49.42 135.85,49.85 135.85,49.93 v2(136.24,50.32)
  BOTTOM w0.102: JDIMM1.140 182.97,52.45 v2(182.27,51.75)
DDR_A_D39: length 65.3
  IN1 w0.076: v2(133.72,50.32) 134.44,51.04 136.79,51.04
  IN1 w0.097: v2(180.75,51.75) 180.75,52.18 180.87,52.31 182.47,52.31 182.6,52.44 182.6,53 182.47,53.13 174.97,53.13 174.53,52.68 169.64,52.68 169.25,53.07 160.51,53.07 159.09,54.49 148.27,54.49 147.74,53.97 145.34,53.97 142.41,51.04 136.8,51.04 136.79,51.04
  BOTTOM w0.076: v2(133.72,50.32) 133.32,49.91 130.56,49.91 130.35,50.12 129.48,50.12 129.35,50.25 128.97,50.25 128.81,50.08 128.39,50.08 128.27,49.96 128,49.96 127.98,49.98 127.74,49.98 127.45,49.68 UC1.AU29
  BOTTOM w0.102: JDIMM1.142 182.93,53.05 182.2,52.31 181.32,52.31 v2(180.75,51.75)
DDR_A_D40: length 61
  IN1 w0.076: 136.75,51.49 136.41,51.49 136.14,51.22 133.32,51.22 132.42,50.32 v2(132.42,50.32)
  IN1 w0.097: v2(179.22,54.03) 179.22,53.76 179.1,53.63 174.76,53.63 174.32,53.18 171.99,53.18 171.87,53.31 171.87,53.71 171.74,53.84 171.42,53.84 171.29,53.71 171.29,53.31 171.17,53.18 170.88,53.18 170.75,53.31 170.75,53.71 170.63,53.84 170.35,53.84 170.23,53.71 170.23,53.31 170.1,53.18 169.85,53.18 169.72,53.31 169.72,53.45 169.6,53.58 160.72,53.58 159.3,55 147.8,55 147.67,54.87 147.67,54.61 147.53,54.47 147.3,54.47 147.17,54.6 147.17,54.91 147.08,55 146.76,55 146.67,54.91 146.67,54.6 146.54,54.47 145.13,54.47 142.2,51.54 136.8,51.54 136.75,51.49
  BOTTOM w0.076: v2(132.42,50.32) 131.82,50.92 130.59,50.92 130.3,50.63 129.67,50.63 129.56,50.74 129.29,50.74 UC1.AY27
  BOTTOM w0.102: JDIMM1.147 176.77,54.55 177.04,54.28 177.04,54.12 177.53,53.63 178.82,53.63 v2(179.22,54.03)
DDR_A_D41: length 62.3
  IN1 w0.076: v2(131.77,50.32) 131.78,50.32 132.86,51.4 136.04,51.4 136.43,51.79 136.75,51.79
  IN1 w0.097: 136.75,51.79 136.8,51.84 141.07,51.84 141.42,52.19 141.64,52.19 141.96,51.87 142.11,51.87 142.36,52.13 142.36,52.26 142.05,52.58 142.05,52.72 142.26,52.94 142.4,52.94 142.72,52.62 142.86,52.62 143.08,52.84 143.08,52.98 142.76,53.3 142.76,53.43 142.98,53.65 143.11,53.65 143.43,53.33 143.57,53.33 145.01,54.77 145.28,54.77 145.36,54.86 145.36,55.06 145.49,55.19 145.74,55.19 145.87,55.06 145.87,54.83 145.93,54.77 146.31,54.77 146.37,54.83 146.37,55.17 146.5,55.3 159.58,55.3 160.35,54.53 160.51,54.53 160.6,54.44 160.6,54.11 160.84,53.88 161.41,53.88 161.51,53.97 161.51,54.44 161.61,54.53 161.92,54.53 162.01,54.44 162.01,53.95 162.09,53.88 162.44,53.88 162.52,53.95 162.52,54.44 162.61,54.53 162.92,54.53 163.02,54.44 163.02,53.97 163.12,53.88 169.56,53.88 169.82,54.14 172.67,54.14 172.87,53.94 172.87,53.58 172.97,53.48 173.28,53.48 173.37,53.58 173.37,53.94 173.47,54.03 174.98,54.03 175.07,54.13 175.07,54.33 175.2,54.45 175.45,54.45 175.58,54.33 175.58,54.16 175.7,54.03 v2(177.7,54.03)
  BOTTOM w0.076: UC1.AW27 128.75,50.87 129.04,50.58 129.49,50.58 129.61,50.46 130.37,50.46 130.63,50.73 131.36,50.73 v2(131.77,50.32)
  BOTTOM w0.102: JDIMM1.149 177.21,55.15 177.7,54.66 v2(177.7,54.03)
DDR_A_D42: length 61.1
  IN1 w0.097: v2(134.3,52.51) 134.3,52.85 134.97,53.52 135.98,53.52 136.7,54.25 139.54,54.25 141.77,56.48 143.14,56.48 144.55,57.89 163.5,57.89 163.57,57.82 163.57,57.61 163.81,57.37 169.66,57.37 169.76,57.47 169.76,57.98 169.86,58.08 170.16,58.08 170.26,57.98 170.26,57.47 170.36,57.37 170.67,57.37 170.77,57.47 170.77,57.93 170.89,58.06 171.1,58.06 171.27,57.89 171.27,57.47 171.37,57.37 171.72,57.37 171.88,57.53 173.31,57.53 173.35,57.58 173.35,58.03 173.44,58.11 173.77,58.11 173.86,58.03 173.86,57.63 173.95,57.53 174.26,57.53 174.36,57.63 174.36,58.03 174.44,58.11 174.78,58.11 174.86,58.03 174.86,57.08 174.95,56.99 175.48,56.99 175.55,57.06 175.55,58 175.66,58.11 175.95,58.11 176.05,58 176.05,57.06 176.13,56.99 177.61,56.99 v2(177.7,57.08)
  BOTTOM w0.076: v2(134.3,52.51) 133.88,52.92 130.59,52.92 130.46,52.79 130.46,52.48 130.07,52.09 129.29,52.09 UC1.AY25
  BOTTOM w0.102: v2(177.7,57.08) 177.23,57.55 JDIMM1.157
DDR_A_D43: length 62
  IN1 w0.097: v2(179.22,57.08) 179.03,57.08 178.62,56.67 174.81,56.67 174.26,57.21 172.03,57.21 171.89,57.07 164.23,57.07 164.16,57 164.16,56.73 164.08,56.65 163.74,56.65 163.66,56.73 163.66,57.1 163.46,57.29 163.28,57.29 163.15,57.17 163.15,56.73 163.07,56.65 162.73,56.65 162.65,56.73 162.65,57.47 162.53,57.59 162.27,57.59 162.15,57.47 162.15,56.76 162.04,56.65 161.67,56.65 161.56,56.76 161.56,57.35 161.44,57.47 144.61,57.47 143.31,56.18 141.89,56.18 139.66,53.95 136.68,53.95 136.07,53.33 135.42,53.33 134.85,52.77 v2(134.85,52.45)
  BOTTOM w0.076: UC1.AW25 128.73,52.44 128.94,52.44 128.99,52.46 129,52.47 129.1,52.51 129.29,52.51 129.54,52.26 130,52.26 130.29,52.55 130.29,52.86 130.52,53.09 134.22,53.09 v2(134.85,52.45)
  BOTTOM w0.102: JDIMM1.159 178.15,58.15 v2(179.22,57.08)
DDR_A_D44: length 62.2
  IN1 w0.076: 136.52,52.14 135.97,51.58 132.38,51.58 v2(131.12,50.32)
  IN1 w0.097: v2(180.75,54.03) 180.29,54.48 178.54,54.48 178.49,54.44 178.19,54.44 178.09,54.53 178.09,54.66 177.99,54.75 177.68,54.75 177.59,54.66 177.59,54.48 177.46,54.36 177.21,54.36 177.08,54.48 177.08,54.66 176.99,54.75 176.68,54.75 176.58,54.66 176.58,54.46 176.45,54.33 176.2,54.33 176.08,54.46 176.08,54.66 175.98,54.75 174.9,54.75 174.58,54.44 170.67,54.44 170.57,54.53 170.57,54.75 170.5,54.83 170.15,54.83 170.07,54.75 170.07,54.53 169.97,54.44 169.7,54.44 169.44,54.18 163.78,54.18 163.13,54.83 160.47,54.83 159.71,55.6 145.41,55.6 143.9,54.09 142.9,54.09 140.95,52.14 136.52,52.14
  BOTTOM w0.076: UC1.AV27 127.99,50.98 128.39,50.58 128.8,50.58 128.97,50.41 129.42,50.41 129.55,50.29 130.46,50.29 130.49,50.32 v2(131.12,50.32)
  BOTTOM w0.102: v2(180.75,54.03) 181.27,53.51 182.4,53.51 182.72,53.83 182.72,54.16 182.82,54.25 JDIMM1.146
DDR_A_D45: length 62.9
  IN1 w0.076: 136.75,52.39 136.47,52.39 135.83,51.74 132.2,51.74 v2(131.37,52.57)
  IN1 w0.097: 136.75,52.39 136.8,52.44 140.82,52.44 142.77,54.39 143.78,54.39 145.28,55.9 159.83,55.9 160.59,55.13 171.71,55.13 172.11,54.74 174.46,54.74 174.77,55.05 178.64,55.05 178.79,54.91 181.1,54.91 181.17,54.83 181.17,54.56 181.3,54.44 181.55,54.44 181.68,54.56 181.68,54.96 181.77,55.05 182.15,55.05 182.27,54.94 v2(182.27,54.03)
  BOTTOM w0.076: UC1.AU27 127.21,51.63 127.4,51.82 128.28,51.82 128.41,51.76 128.62,51.76 128.77,51.84 128.9,51.84 129.06,51.76 130.57,51.76 v2(131.37,52.57)
  BOTTOM w0.102: JDIMM1.148 182.72,54.85 182.27,54.4 v2(182.27,54.03)
DDR_A_D46: length 62.1
  IN1 w0.097: v2(130.81,52.57) 130.81,52.73 131.48,53.39 133.96,53.39 134.56,54 136.1,54 136.65,54.55 139.41,54.55 141.64,56.78 143.01,56.78 144.62,58.38 171.2,58.38 171.68,57.9 172.7,57.9 173.22,58.41 176.23,58.41 176.35,58.29 176.35,57.44 176.48,57.32 176.73,57.32 176.86,57.44 176.86,57.78 176.98,57.9 177.23,57.9 177.36,57.78 177.36,57.62 177.46,57.52 182.14,57.52 182.27,57.39 v2(182.27,57.08)
  BOTTOM w0.076: UC1.AV25 128.1,52.22 128.34,51.98 128.45,51.93 128.58,51.93 128.6,51.94 128.68,51.98 128.74,52 128.94,52 129.1,51.93 130.45,51.93 130.81,52.29 v2(130.81,52.57)
  BOTTOM w0.102: v2(182.27,57.08) 182.27,57.58 182.55,57.85 JDIMM1.158
DDR_A_D47: length 63.9
  IN1 w0.097: v2(135.8,52.95) 136.04,52.95 136.74,53.65 139.79,53.65 142.02,55.88 143.44,55.88 144.69,57.13 160.45,57.13 161.22,56.35 164.85,56.35 164.97,56.48 164.97,56.65 165.1,56.77 165.46,56.77 165.58,56.65 165.58,56.43 165.66,56.35 166.1,56.35 166.18,56.43 166.18,56.67 166.28,56.77 169.33,56.77 169.45,56.65 169.45,56.49 169.58,56.37 169.92,56.37 170.01,56.46 170.01,56.68 170.11,56.77 170.42,56.77 170.52,56.68 170.52,56.46 170.61,56.37 170.92,56.37 171.02,56.46 171.02,56.68 171.11,56.77 171.42,56.77 171.52,56.68 171.52,56.47 171.63,56.37 172.69,56.37 172.79,56.46 172.79,56.82 172.88,56.91 173.19,56.91 173.29,56.82 173.29,56.46 173.38,56.37 178.75,56.37 179.04,56.66 180.59,56.66 180.75,56.81 v2(180.75,57.08)
  BOTTOM w0.076: v2(135.8,52.95) 135.49,53.25 130.45,53.25 130.13,52.93 130.13,52.62 129.94,52.43 129.61,52.43 129.5,52.54 129.36,52.68 129.06,52.68 129.01,52.66 128.9,52.6 127.6,52.6 UC1.AU25
  BOTTOM w0.102: v2(180.75,57.08) 182.12,58.45 JDIMM1.160
DDR_A_D48: length 62.7
  IN1 w0.076: 136.75,55.57 136.22,55.05 134.47,55.05 133.79,54.36 v2(133.77,54.36)
  IN1 w0.097: 136.75,55.57 136.82,55.65 138.96,55.65 141.43,58.12 141.59,58.12 141.83,57.88 142.01,57.88 142.22,58.09 142.22,58.27 141.99,58.5 141.99,58.68 142.2,58.89 142.35,58.89 142.83,58.41 143.01,58.41 143.19,58.59 143.19,58.77 142.86,59.1 142.86,59.31 143.03,59.48 143.24,59.48 143.6,59.13 143.73,59.13 144.09,59.48 154.37,59.48 154.5,59.61 154.5,60.03 154.6,60.13 154.91,60.13 155,60.03 155,59.61 155.13,59.48 155.38,59.48 155.51,59.61 155.51,60.03 155.6,60.13 155.91,60.13 156.01,60.03 156.01,59.61 156.14,59.48 156.39,59.48 156.51,59.61 156.51,60.03 156.61,60.13 156.92,60.13 157.01,60.03 157.01,59.61 157.14,59.48 157.42,59.48 157.52,59.58 157.52,60.03 157.61,60.13 157.92,60.13 158.02,60.03 158.02,59.58 158.12,59.48 158.59,59.48 158.71,59.6 158.71,59.98 158.86,60.14 163.32,60.14 163.45,60.01 163.45,59.6 163.57,59.48 169.62,59.48 169.74,59.6 169.74,60.06 169.85,60.17 170.13,60.17 170.24,60.06 170.24,59.6 170.36,59.48 170.6,59.48 170.72,59.6 170.72,60.06 170.83,60.17 171.12,60.17 171.22,60.06 171.22,59.79 171.35,59.66 177.66,59.66 v2(177.7,59.62)
  BOTTOM w0.076: v2(133.77,54.36) 133.16,53.75 130.2,53.75 130.03,53.58 129.43,53.58 129.42,53.57 UC1.AY23
  BOTTOM w0.102: v2(177.7,59.62) 177.43,59.35 JDIMM1.163
DDR_A_D49: length 63.9
  IN1 w0.076: v2(134.42,54.36) 134.94,54.88 136.34,54.88 136.75,55.29
  IN1 w0.097: v2(179.22,59.62) 179.22,58.52 179.1,58.39 178.83,58.39 178.7,58.52 178.7,58.98 178.57,59.11 178.27,59.11 178.14,58.98 178.14,58.63 178.02,58.5 177.77,58.5 177.64,58.63 177.64,59.12 177.54,59.22 172.88,59.22 172.37,58.71 172.01,58.71 171.53,59.19 163.26,59.19 163.13,59.31 163.13,59.68 162.98,59.83 162.73,59.83 162.6,59.7 162.6,59.29 162.5,59.19 162.25,59.19 162.1,59.34 162.1,59.7 161.97,59.83 161.72,59.83 161.6,59.7 161.6,59.29 161.49,59.19 160.61,59.19 160.52,59.28 160.52,59.65 160.42,59.75 160.11,59.75 160.01,59.65 160.01,59.28 159.92,59.19 159.61,59.19 159.51,59.28 159.51,59.65 159.41,59.75 159.1,59.75 159.01,59.65 159.01,59.28 158.91,59.19 144.29,59.19 142.68,57.58 141.31,57.58 139.08,55.35 136.8,55.35 136.75,55.29
  BOTTOM w0.076: UC1.AW23 128.72,53.57 128.92,53.37 129.09,53.28 129.36,53.28 129.5,53.42 130.1,53.42 130.27,53.58 133.65,53.58 v2(134.42,54.36)
  BOTTOM w0.102: v2(179.22,59.62) 178.82,60.03 176.97,60.03 176.9,59.95 JDIMM1.165
DDR_A_D50: length 63.2
  IN1 w0.076: 136.75,57.71 136.69,57.71 135.1,56.11 v2(135.02,56.11)
  IN1 w0.097: 136.75,57.71 136.82,57.78 138.02,57.78 142.52,62.29 160.11,62.29 160.24,62.41 160.24,63.26 160.36,63.39 160.61,63.39 160.74,63.26 160.74,62.41 160.87,62.29 161.43,62.29 161.56,62.41 161.56,63.15 161.69,63.27 161.93,63.27 162.06,63.15 162.06,62.41 162.19,62.29 162.44,62.29 162.56,62.41 162.56,63.39 162.69,63.52 162.94,63.52 163.07,63.39 163.07,62.41 163.19,62.29 163.44,62.29 163.57,62.41 163.57,63.39 163.7,63.52 169.81,63.52 169.9,63.42 169.9,62.87 170.03,62.74 170.31,62.74 170.4,62.84 170.4,63.39 170.53,63.52 170.78,63.52 170.91,63.39 170.91,62.84 171,62.74 171.28,62.74 171.41,62.87 171.41,63.42 171.51,63.52 173.9,63.52 174.71,62.71 177.57,62.71 v2(177.59,62.7)
  BOTTOM w0.076: v2(135.02,56.11) 134.26,55.34 130.93,55.34 130.64,55.05 129.29,55.05 UC1.AY21
  BOTTOM w0.102: JDIMM1.175 177.33,62.95 v2(177.59,62.7)
DDR_A_D51: length 63.7
  IN1 w0.076: v2(134.37,56.11) 134.46,56.11 134.82,56.46 135.22,56.46 136.52,57.77 136.52,58.09 136.67,58.24
  IN1 w0.097: v2(179.11,62.7) 178.71,63.1 175.05,63.1 174.34,63.82 159.99,63.82 159.77,63.6 159.77,62.68 159.68,62.59 159.37,62.59 159.27,62.68 159.27,63.72 159.17,63.82 158.86,63.82 158.77,63.72 158.77,62.68 158.67,62.59 158.36,62.59 158.26,62.68 158.26,63.72 158.17,63.82 157.86,63.82 157.76,63.72 157.76,62.68 157.66,62.59 142.4,62.59 138.05,58.24 136.67,58.24
  BOTTOM w0.076: v2(134.37,56.11) 133.77,55.51 130.86,55.51 130.57,55.22 129.04,55.22 128.75,54.92 UC1.AW21
  BOTTOM w0.102: JDIMM1.177 178.26,63.55 v2(179.11,62.7)
DDR_A_D52: length 64.5
  IN1 w0.076: 136.82,55.05 136.45,54.68 135.81,54.68 135.66,54.52 v2(135.66,54.36)
  IN1 w0.097: v2(182.27,59.62) 182.27,58.21 182.15,58.09 181.72,58.09 181.63,58.19 181.63,58.97 181.5,59.1 181.25,59.1 181.12,58.97 181.12,58.19 181.03,58.09 180.72,58.09 180.62,58.19 180.62,58.97 180.49,59.1 180.24,59.1 180.12,58.97 180.12,58.19 180.02,58.09 177.75,58.09 176.93,58.92 173.01,58.92 172.5,58.41 171.89,58.41 171.41,58.89 144.41,58.89 142.81,57.28 141.43,57.28 139.21,55.05 136.82,55.05
  BOTTOM w0.076: UC1.AV23 128.25,53.19 128.91,53.19 129.05,53.11 129.43,53.11 129.57,53.25 130.17,53.25 130.33,53.42 134.82,53.42 135.66,54.25 v2(135.66,54.36)
  BOTTOM w0.102: v2(182.27,59.62) 182.3,59.65 JDIMM1.164
DDR_A_D53: length 65
  IN1 w0.076: 136.86,55.95 136.12,55.21 133.97,55.21 v2(133.12,54.36)
  IN1 w0.097: 136.86,55.95 138.83,55.95 142.67,59.78 144.75,59.78 144.85,59.88 144.85,60.02 144.94,60.12 145.25,60.12 145.35,60.02 145.35,59.88 145.45,59.78 145.76,59.78 145.85,59.88 145.85,60.02 145.95,60.12 146.26,60.12 146.36,60.02 146.36,59.88 146.45,59.78 146.76,59.78 146.86,59.88 146.86,60.02 146.96,60.12 147.27,60.12 147.36,60.02 147.36,59.88 147.46,59.78 147.94,59.78 148.03,59.88 148.03,59.99 148.16,60.12 148.41,60.12 148.54,59.99 148.54,59.88 148.63,59.78 150.7,59.78 150.8,59.88 150.8,60.01 150.88,60.09 151.22,60.09 151.3,60.01 151.3,59.88 151.4,59.78 151.71,59.78 151.81,59.88 151.81,59.99 151.91,60.09 152.2,60.09 152.31,59.99 152.31,59.88 152.41,59.78 152.94,59.78 153.07,59.91 153.07,60.27 153.2,60.4 153.51,60.4 153.64,60.27 153.64,59.91 153.77,59.78 154.11,59.78 154.2,59.87 154.2,60.37 154.3,60.47 171.27,60.47 171.72,60.02 180.34,60.02 v2(180.75,59.62)
  BOTTOM w0.076: v2(133.12,54.36) 132.48,55 131.06,55 130.76,54.7 129.59,54.7 129.35,54.47 129.06,54.47 128.9,54.54 128.77,54.54 128.62,54.47 128.41,54.47 128.36,54.49 128.27,54.53 128.26,54.54 128.07,54.54 128.05,54.52 127.67,54.52 127.66,54.54 127.42,54.54 127.21,54.34 UC1.AU23
  BOTTOM w0.102: v2(180.75,59.62) 181.38,60.25 JDIMM1.166
DDR_A_D54: length 64.7
  IN1 w0.076: v2(135.67,56.11) 135.67,56.45 136.63,57.41 136.73,57.41
  IN1 w0.097: 136.73,57.41 136.8,57.48 138.14,57.48 142.65,61.99 164.29,61.99 164.6,62.29 171.1,62.29 171.17,62.22 171.17,62.11 171.27,62.01 171.58,62.01 171.68,62.11 171.68,62.41 171.8,62.54 172.05,62.54 172.18,62.41 172.18,62.11 172.31,61.98 172.56,61.98 172.68,62.11 172.68,62.81 172.81,62.93 173.15,62.93 173.27,62.81 173.27,61.97 173.37,61.87 173.68,61.87 173.78,61.97 173.78,62.71 173.9,62.84 174.15,62.84 174.28,62.71 174.28,61.97 174.38,61.87 174.69,61.87 174.78,61.97 174.78,62.16 174.91,62.29 180.23,62.29 v2(180.63,62.7)
  BOTTOM w0.076: v2(135.67,56.11) 135.22,55.66 135.21,55.66 134.73,55.17 131.19,55.17 131.19,55.17 130.99,55.17 130.7,54.88 129.53,54.88 129.29,54.63 129.1,54.63 128.99,54.68 128.94,54.7 128.74,54.7 128.68,54.68 128.59,54.64 128.58,54.63 128.45,54.63 128.4,54.66 128.34,54.68 128.21,54.82 UC1.AV21
  BOTTOM w0.102: JDIMM1.174 182.9,62.65 182.47,62.22 181.11,62.22 v2(180.63,62.7)
DDR_A_D55: length 64.7
  IN1 w0.076: v2(133.72,56.11) 133.72,55.85 133.82,55.75 135.82,55.75 136.03,55.96 136.03,56.57 136.56,57.11 136.75,57.11
  IN1 w0.097: 136.75,57.11 136.82,57.18 138.27,57.18 142.77,61.69 164.6,61.69 164.91,61.99 170.87,61.99 171.17,61.69 172.24,61.69 172.38,61.55 175.95,61.55 176.08,61.67 176.08,61.9 176.18,61.99 176.49,61.99 176.58,61.9 176.58,61.33 176.68,61.23 176.99,61.23 177.08,61.33 177.08,61.9 177.18,61.99 181.53,61.99 181.66,61.86 181.66,61.28 181.79,61.15 182.03,61.15 182.16,61.28 v2(182.16,62.7)
  BOTTOM w0.076: UC1.AU21 127.45,54.82 127.74,55.11 127.98,55.11 128,55.09 128.27,55.09 128.39,55.22 128.81,55.22 128.97,55.38 130.5,55.38 130.8,55.67 133.29,55.67 v2(133.72,56.11)
  BOTTOM w0.102: v2(182.16,62.7) 182.71,63.25 JDIMM1.176
DDR_A_D56: length 62.2
  IN1 w0.076: v2(132.42,56.11) 132.42,56.31 132.94,56.82 135.34,56.82 136.36,57.84 136.36,58.27 136.83,58.75 137.03,58.75
  IN1 w0.097: 137.03,58.75 137.85,58.75 142.19,63.09 156.09,63.09 157.32,64.32 175.5,64.32 175.63,64.19 175.63,63.73 175.76,63.6 177.88,63.6 178.01,63.73 178.01,64.7 178.14,64.82 178.38,64.82 178.51,64.7 178.51,63.73 178.64,63.6 178.98,63.6 179.11,63.73 v2(179.11,65.24)
  BOTTOM w0.076: v2(132.42,56.11) 131.86,56.67 130.93,56.67 130.14,55.88 129.29,55.88 UC1.AY19
  BOTTOM w0.102: v2(179.11,65.24) 178.63,64.75 JDIMM1.181
DDR_A_D57: length 63.5
  IN1 w0.076: v2(131.77,56.11) 131.77,56.42 132.37,57.01 135.3,57.01 136.19,57.91 136.19,58.34 136.9,59.05 137.03,59.05
  IN1 w0.097: v2(177.59,65.24) 177.59,63.97 177.52,63.9 177.19,63.9 177.06,64.03 177.06,65.21 176.93,65.34 176.68,65.34 176.56,65.21 176.56,64.03 176.43,63.9 176.06,63.9 175.93,64.03 175.93,64.5 175.8,64.63 156.05,64.63 155.93,64.5 155.93,63.52 155.8,63.39 155.42,63.39 155.32,63.49 155.32,64.35 155.23,64.44 154.92,64.44 154.82,64.35 154.82,63.49 154.72,63.39 154.41,63.39 154.32,63.49 154.32,63.87 154.19,64 153.94,64 153.81,63.87 153.81,63.49 153.72,63.39 142.06,63.39 137.72,59.05 137.03,59.05
  BOTTOM w0.076: v2(131.77,56.11) 131.38,56.5 131,56.5 130.2,55.71 129.04,55.71 128.75,56 UC1.AW19
  BOTTOM w0.102: v2(177.59,65.24) 177.47,65.35 JDIMM1.183
DDR_A_D58: length 61.9
  IN1 w0.097: v2(177.59,68.31) 176.2,68.31 176.1,68.21 176.1,67.99 175.97,67.86 175.72,67.86 175.6,67.99 175.6,68.19 175.47,68.32 175.2,68.32 175.07,68.19 175.07,67.61 174.95,67.48 174.7,67.48 174.57,67.61 174.57,68.19 174.44,68.32 173.92,68.32 173.79,68.19 173.79,67.33 173.66,67.2 173.41,67.2 173.29,67.33 173.29,68.29 173.19,68.39 172.19,68.39 172.1,68.29 172.1,67.47 171.88,67.25 170.05,67.25 169.31,67.99 166.28,67.99 165.71,67.42 162.37,67.42 162.27,67.33 162.27,66.92 162.14,66.79 161.89,66.79 161.77,66.92 161.77,67.33 161.67,67.42 161.26,67.42 161.14,67.3 161.14,66.92 161.01,66.79 150.68,66.79 149.51,65.62 141.19,65.62 137,61.44 136.73,61.44 136.12,60.82 134.86,60.82 133.14,59.11 132.56,59.11 132.37,58.92 v2(132.37,58.09)
  BOTTOM w0.076: UC1.AY17 129.49,57.35 129.5,57.34 130.33,57.34 130.48,57.49 131.77,57.49 v2(132.37,58.09)
  BOTTOM w0.102: JDIMM1.191 177.03,67.75 v2(177.59,68.31)
DDR_A_D59: length 63.3
  IN1 w0.097: v2(179.11,68.31) 178.58,68.84 174.73,68.84 174.58,68.69 171.92,68.69 171.8,68.56 171.8,67.7 171.67,67.57 171.42,67.57 171.29,67.7 171.29,68.2 171.17,68.33 170.92,68.33 170.79,68.2 170.79,67.7 170.66,67.57 170.42,67.57 170.29,67.7 170.29,68.24 170.2,68.33 165.84,68.33 165.71,68.2 165.71,67.85 165.59,67.72 165.3,67.72 165.21,67.82 165.21,68.22 165.11,68.32 164.8,68.32 164.7,68.22 164.7,67.82 164.61,67.72 161,67.72 160.37,67.09 150.56,67.09 149.39,65.92 141.06,65.92 136.87,61.74 135.34,61.74 132.92,59.32 132.35,59.32 v2(131.12,58.09)
  BOTTOM w0.076: v2(131.12,58.09) 131.12,58.06 130.72,57.65 130.41,57.65 130.28,57.52 129.41,57.52 129.29,57.65 129.1,57.65 128.94,57.57 128.73,57.57 UC1.AW17
  BOTTOM w0.102: JDIMM1.193 176.85,68.35 177.23,68.72 178.7,68.72 v2(179.11,68.31)
DDR_A_D60: length 63.6
  IN1 w0.076: 136.33,58.73 136.02,58.41 136.02,57.96 135.23,57.18 131.96,57.18 131.12,56.34 v2(131.12,56.11)
  IN1 w0.097: v2(180.63,65.24) 180.23,65.64 176.31,65.64 176.18,65.51 176.18,65.06 176.06,64.94 154.48,64.94 154.38,64.84 154.38,64.4 154.28,64.3 153.97,64.3 153.88,64.4 153.88,64.7 153.75,64.82 153.5,64.82 153.37,64.7 153.37,63.82 153.25,63.69 153,63.69 152.87,63.82 152.87,64 152.74,64.13 152.5,64.13 152.37,64 152.37,63.82 152.24,63.69 141.94,63.69 137.6,59.35 136.95,59.35 136.33,58.73
  BOTTOM w0.076: UC1.AV19 127.99,56.11 128.39,55.71 128.8,55.71 128.97,55.55 130.36,55.55 130.93,56.11 v2(131.12,56.11)
  BOTTOM w0.102: JDIMM1.180 181.42,64.45 v2(180.63,65.24)
DDR_A_D61: length 64.6
  IN1 w0.076: 137.03,59.64 136.95,59.64 135.84,58.53 135.84,58.02 135.33,57.51 134.03,57.51 v2(133.49,58.05)
  IN1 w0.097: v2(182.16,65.24) 181.45,65.94 175.8,65.94 175.1,65.24 153.06,65.24 152.97,65.14 152.97,64.52 152.87,64.43 152.56,64.43 152.46,64.52 152.46,65.01 152.34,65.14 152.07,65.14 151.94,65.01 151.94,64.12 151.81,63.99 151.48,63.99 151.36,64.12 151.36,64.27 151.23,64.4 150.91,64.4 150.78,64.27 150.78,64.12 150.66,63.99 141.82,63.99 137.47,59.64 137.03,59.64
  BOTTOM w0.076: v2(133.49,58.05) 132.6,57.16 130.62,57.16 130.47,57.01 129.51,57.01 129.4,56.9 129.06,56.9 128.9,56.97 128.77,56.97 128.62,56.9 128.41,56.9 128.36,56.92 128.27,56.96 128.26,56.97 127.42,56.97 127.21,56.77 UC1.AU19
  BOTTOM w0.102: v2(182.16,65.24) 182.34,65.05 JDIMM1.182
DDR_A_D62: length 63.1
  IN1 w0.097: v2(132.93,58.05) 132.93,58.47 134.97,60.51 136.19,60.51 136.82,61.14 137.12,61.14 141.31,65.32 149.63,65.32 150.8,66.5 163.05,66.5 163.35,66.8 165.51,66.8 166.32,67.61 169.14,67.61 169.85,66.89 174.85,66.89 175.18,67.22 177.17,67.22 177.29,67.35 177.29,67.73 177.42,67.86 177.67,67.86 177.8,67.73 177.8,67.3 177.91,67.18 178.18,67.18 178.3,67.3 178.3,67.75 178.43,67.89 181.73,67.89 v2(182.16,68.31)
  BOTTOM w0.076: UC1.AV17 128.1,57.35 128.34,57.11 128.45,57.06 128.58,57.06 128.6,57.07 128.68,57.11 128.68,57.11 128.74,57.14 128.94,57.14 129.1,57.06 129.33,57.06 129.44,57.17 130.4,57.17 130.55,57.32 132.2,57.32 v2(132.93,58.05)
  BOTTOM w0.102: v2(182.16,68.31) 182.42,68.05 JDIMM1.192
DDR_A_D63: length 64.4
  IN1 w0.097: v2(130.57,58.09) 131.21,58.74 131.35,58.74 132.11,59.5 132.69,59.5 135.22,62.04 136.75,62.04 140.94,66.22 149.26,66.22 150.43,67.39 160.25,67.39 160.89,68.04 162.21,68.04 162.31,68.13 162.31,68.53 162.4,68.63 162.71,68.63 162.81,68.53 162.81,68.13 162.91,68.04 163.22,68.04 163.31,68.13 163.31,68.53 163.41,68.63 163.72,68.63 163.82,68.53 163.82,68.13 163.91,68.04 164.22,68.04 164.32,68.13 164.32,68.53 164.41,68.63 171.43,68.63 171.79,68.99 174.46,68.99 174.61,69.14 179.8,69.14 v2(180.63,68.31)
  BOTTOM w0.076: UC1.AU17 127.51,57.65 128.26,57.65 128.35,57.74 128.9,57.74 129.01,57.79 129.06,57.81 129.35,57.81 129.48,57.68 130.16,57.68 v2(130.57,58.09)
  BOTTOM w0.102: JDIMM1.194 182.58,68.65 182.41,68.82 181.15,68.82 v2(180.63,68.31)
DDR_A_DQS0: length 74.9
  IN1 w0.097: v2(122.78,27.06) 123.18,26.66 123.73,26.66 124.07,26.33 124.07,24.47 127.59,20.95 128.45,20.95 133.32,16.08 155.78,16.08 159.99,11.87 163.63,11.87 164.07,11.42 178.11,11.42 179.19,10.34 180.42,10.34 180.56,10.48 180.56,10.6 180.3,10.86 v2(180.11,10.86)
  BOTTOM w0.076: v2(122.78,27.06) 122.78,26.99 122.55,26.76 122.34,26.76 122.27,26.83 122.27,28.68 122.25,28.74 122.23,28.78 122.2,28.85 122.2,28.98 122.21,29 122.25,29.08 122.27,29.13 122.27,29.34 122.2,29.5 122.2,29.63 122.25,29.73 122.42,29.73 122.49,29.66 UC1.AJ62
  BOTTOM w0.102: JDIMM1.12 182.11,11.65 182.01,11.75 180.82,11.75 180.5,11.44 180.5,11.17 180.2,10.86 v2(180.11,10.86)
DDR_A_DQS1: length 71.7
  IN1 w0.097: v2(126.13,26.55) 126.32,26.73 126.32,26.73 126.51,26.92 127.06,26.92 128.23,25.74 128.23,25.74 129.55,24.43 130.28,24.43 133.09,21.61 136.67,21.61 137.85,20.43 157.32,20.43 160.84,16.91 167.26,16.91 167.4,16.77 167.4,16.28 167.58,16.09 168.09,16.09 168.27,16.28 168.27,16.8 168.36,16.89 168.62,16.89 168.72,16.8 168.72,16.28 168.9,16.09 169.41,16.09 169.59,16.28 169.59,17.08 169.68,17.17 170.04,17.17 170.14,17.08 170.14,16.8 170.38,16.56 177.04,16.56 177.89,15.71 179.19,15.71 179.4,15.93 179.4,16.17 v2(179.6,16.38)
  BOTTOM w0.076: UC1.AN61 124.7,29.99 124.7,29.8 124.54,29.64 124.54,29.62 124.54,29.62 124.54,29.17 124.53,29.15 124.49,29.07 124.47,29.01 124.47,28.81 124.5,28.72 124.54,28.65 124.54,28.38 124.54,28.38 124.54,27.27 125.47,26.34 125.77,26.34 125.97,26.55 v2(126.13,26.55)
  BOTTOM w0.102: v2(179.6,16.38) 179.6,16.96 179.4,17.16 177.84,17.16 177.43,16.75 JDIMM1.29
DDR_A_DQS2: length 66.2
  IN1 w0.076: v2(132.28,27.59) 132.28,27.81 132.39,27.93 132.95,27.93 134.47,26.4 136.67,26.4 136.68,26.39 136.73,26.39 136.74,26.38 136.75,26.38
  IN1 w0.097: 136.75,26.38 138.05,26.38 138.53,25.9 141.02,25.9 141.68,25.24 157.98,25.24 160.4,22.83 162.62,22.83 163.45,21.99 171.45,21.99 171.59,21.85 171.59,21.5 171.82,21.26 175.36,21.26 175.55,21.44 175.55,21.93 175.63,22.01 175.91,22.01 176,21.93 176,21.45 176.22,21.23 176.63,21.23 176.84,21.44 176.84,21.87 176.94,21.97 177.2,21.97 177.25,21.92 177.25,21.53 177.56,21.22 179.21,21.22 179.45,21.46 179.45,21.93 v2(179.6,22.09)
  BOTTOM w0.076: v2(132.28,27.59) 132.28,27.8 132.43,27.96 132.43,29.68 130.12,31.99 129.6,31.99 129.35,32.23 129.06,32.23 129.01,32.21 129.01,32.21 128.9,32.16 128.77,32.16 128.75,32.17 128.67,32.21 128.62,32.23 128.41,32.23 128.25,32.16 128.12,32.16 128.02,32.21 127.94,32.29 127.94,32.38 128.01,32.45 UC1.AW57
  BOTTOM w0.102: JDIMM1.47 177.26,22.15 177.89,22.77 179.09,22.77 179.36,22.51 179.36,22.33 v2(179.6,22.09)
DDR_A_DQS3: length 61.8
  IN1 w0.076: 136.69,30.01 136.68,30.02 136.34,30.02 135.88,29.56 135.43,29.56 131.91,33.08 131.91,33.32 131.99,33.4 v2(131.99,33.77)
  IN1 w0.097: v2(181.13,27.49) 181.02,27.49 180.82,27.28 180.82,27.05 180.64,26.86 172.72,26.86 171.6,27.99 161.07,27.99 159.06,30 136.7,30 136.69,30.01
  BOTTOM w0.076: UC1.AW53 128.19,34.71 128.23,34.66 128.62,34.66 128.67,34.64 128.75,34.6 128.77,34.59 128.9,34.59 128.96,34.62 129.06,34.66 129.38,34.66 129.63,34.41 129.76,34.41 129.9,34.26 130.83,34.26 131.61,33.49 131.96,33.49 131.99,33.53 v2(131.99,33.77)
  BOTTOM w0.102: JDIMM1.64 182.75,27.25 182.54,27.04 182.28,27.04 182.18,26.94 181.02,26.94 180.88,27.08 180.88,27.24 v2(181.13,27.49)
DDR_A_DQS4: length 63.2
  IN1 w0.076: v2(131.03,48.89) 131.22,49.09 131.23,49.09 131.59,49.45 136.64,49.45 136.65,49.44 136.69,49.44 136.71,49.42 136.72,49.42
  IN1 w0.097: 136.72,49.42 143.1,49.42 146.05,52.37 156.48,52.37 157.44,51.41 158.17,51.41 158.4,51.18 158.73,51.18 159,51.45 159.42,51.45 159.68,51.2 160.13,51.2 160.4,51.46 161.11,51.46 161.28,51.29 161.28,51.04 161.52,50.8 161.98,50.8 162.22,51.04 162.22,51.42 162.27,51.46 162.55,51.46 162.67,51.35 162.67,50.98 162.85,50.79 163.13,50.79 163.56,50.36 163.85,50.36 164.22,50.73 164.42,50.73 164.52,50.62 164.52,50.27 164.68,50.11 167.75,50.11 168.01,50.37 168.84,50.37 169.11,50.09 169.98,50.09 170.59,50.7 172.18,50.7 172.36,50.52 177.25,50.52 177.35,50.42 177.35,49.97 177.7,49.62 179.04,49.62 179.29,49.87 179.29,50.02 179.49,50.22 v2(179.5,50.22)
  BOTTOM w0.076: v2(131.03,48.89) 130.75,48.62 130.75,48.45 130.63,48.33 129.69,48.33 129.29,48.73 129.1,48.73 129,48.68 128.99,48.68 128.94,48.66 128.74,48.66 128.58,48.73 128.45,48.73 128.35,48.68 128.29,48.66 128.09,48.66 127.95,48.72 127.93,48.72 127.86,48.79 127.77,48.88 127.77,49.04 127.69,49.11 UC1.AV30
  BOTTOM w0.102: JDIMM1.137 176.82,51.55 176.98,51.39 177.3,51.39 177.7,50.99 178.88,50.99 179.12,50.75 179.18,50.69 179.18,50.5 179.46,50.22 v2(179.5,50.22)
DDR_A_DQS5: length 61.9
  IN1 w0.076: 136.77,52.95 136.75,52.95 136.72,52.95 136.31,52.53 136.31,52.48 135.74,51.91 132.94,51.91 132.73,52.12 132.73,52.38 v2(132.57,52.54)
  IN1 w0.097: v2(180.37,55.51) 180.57,55.51 180.69,55.63 180.69,55.85 180.59,55.96 179.35,55.96 179.05,55.65 160.93,55.65 160.18,56.4 145.01,56.4 143.78,55.17 142.68,55.17 140.45,52.95 136.77,52.95
  BOTTOM w0.076: UC1.AW26 128.19,51.37 128.23,51.33 128.62,51.33 128.67,51.3 128.75,51.26 128.77,51.25 128.9,51.25 128.96,51.28 129.06,51.33 129.47,51.33 129.76,51.04 129.84,50.96 130.17,50.96 130.75,51.54 132.36,51.54 132.89,52.08 132.89,52.21 v2(132.57,52.54)
  BOTTOM w0.102: v2(180.37,55.51) 180.63,55.77 180.63,56.14 180.9,56.4 182.5,56.4 182.75,56.65 JDIMM1.154
DDR_A_DQS6: length 63.7
  IN1 w0.076: 137.03,56.48 137.01,56.48 137.02,56.49 137.02,56.5 136.68,56.5 136.37,56.19 136.37,55.8 135.98,55.4 133.37,55.4 132.98,55.01 132.56,55.01 132.17,55.4 131.73,55.4 131.64,55.31 131.64,54.6 131.64,54.6 131.64,54.57 v2(131.77,54.43)
  IN1 w0.097: v2(179.6,61.14) 179.54,61.14 179.41,61.02 179.41,60.75 179.19,60.53 175.97,60.53 175.69,60.81 175.05,60.81 174.77,60.53 173.79,60.53 173.5,60.81 172.87,60.81 172.59,60.53 171.98,60.53 171.52,60.99 170.62,60.99 170.31,61.29 169.98,61.29 169.7,61.01 169.1,61.01 168.84,61.27 168.36,61.27 168.08,60.98 152.53,60.98 152.14,60.6 149.08,60.6 148.77,60.91 148.45,60.91 148.17,60.62 147.73,60.62 147.45,60.91 147.13,60.91 146.84,60.62 146.41,60.62 146.13,60.91 145.81,60.91 145.53,60.62 144.74,60.62 144.4,60.29 143.64,60.29 143.3,60.62 142.75,60.62 138.6,56.48 137.03,56.48
  BOTTOM w0.076: UC1.AV22 127.69,54.25 127.77,54.17 127.77,54.02 127.86,53.93 127.93,53.86 127.95,53.86 128.09,53.79 128.29,53.79 128.35,53.82 128.45,53.86 128.58,53.86 128.74,53.79 128.94,53.79 128.99,53.82 129,53.82 129.1,53.86 129.29,53.86 129.4,53.75 129.96,53.75 130.13,53.92 131.43,53.92 131.61,54.09 131.61,54.27 v2(131.77,54.43)
  BOTTOM w0.102: JDIMM1.171 176.88,61.75 176.9,61.76 179.16,61.76 179.4,61.52 179.4,61.31 179.43,61.31 v2(179.6,61.14)
DDR_A_DQS7: length 63.6
  IN1 w0.097: v2(181.02,66.76) 180.79,66.76 180.63,66.92 180.63,67.13 180.38,67.38 179.21,67.38 178.52,66.68 175.56,66.68 175.17,66.28 163.63,66.28 163.28,65.93 151.44,65.93 150.31,64.8 141.49,64.8 137.14,60.44 136.73,60.44 136.5,60.21 135.43,60.21 135.05,59.83 135.05,58.41 v2(134.7,58.07)
  BOTTOM w0.076: v2(134.7,58.07) 134.92,57.85 134.92,57.54 134.38,56.99 130.75,56.99 129.97,56.22 129.62,56.22 129.38,56.46 129.06,56.46 129.01,56.44 128.9,56.39 128.77,56.39 128.75,56.4 128.67,56.44 128.62,56.46 128.23,56.46 128.19,56.5 UC1.AW18
  BOTTOM w0.102: v2(181.02,66.76) 180.77,66.52 180.77,66.29 180.83,66.23 181.94,66.23 182.38,66.67 182.67,66.67 182.85,66.85 JDIMM1.188
DDR_A_DQS#0: length 75.3
  IN1 w0.097: v2(122.78,26.48) 123.11,26.48 123.66,26.48 123.87,26.26 123.87,24.39 127.51,20.76 128.37,20.76 133.24,15.89 155.7,15.89 159.91,11.68 163.55,11.68 163.99,11.23 178.03,11.23 179.11,10.15 180.5,10.15 180.76,10.4 180.76,10.75 v2(180.87,10.86)
  BOTTOM w0.076: v2(122.78,26.48) 122.66,26.6 122.27,26.6 122.11,26.76 122.11,28.65 122.07,28.74 122.03,28.81 122.03,29.01 122.11,29.17 122.11,29.3 122.06,29.4 122.03,29.46 122.03,29.69 122.06,29.72 122.11,29.83 122.19,29.9 122.54,29.9 122.59,29.95 122.59,30.11 UC1.AJ61
  BOTTOM w0.102: v2(180.87,10.86) 180.69,11.04 180.69,11.07 180.71,11.08 180.71,11.35 180.91,11.55 181.93,11.55 182.03,11.45 182.51,11.45 182.9,11.05 JDIMM1.10
DDR_A_DQS#1: length 71.8
  IN1 w0.097: v2(178.84,16.38) 178.93,16.46 179.03,16.46 179.21,16.28 179.21,16.01 179.11,15.91 177.97,15.91 177.12,16.76 170.46,16.76 170.33,16.88 170.33,17.16 170.12,17.36 169.6,17.36 169.4,17.16 169.4,16.36 169.33,16.29 168.98,16.29 168.91,16.36 168.91,16.88 168.7,17.09 168.28,17.09 168.07,16.88 168.07,16.36 168.01,16.29 167.66,16.29 167.59,16.36 167.59,16.85 167.34,17.1 160.92,17.1 157.4,20.62 137.93,20.62 136.75,21.8 133.17,21.8 130.36,24.62 129.63,24.62 128.28,25.97 128.23,26.01 128.22,26.01 127.13,27.1 126.42,27.1 126.23,26.92 125.7,26.92 v2(125.58,27.04)
  BOTTOM w0.076: v2(125.58,27.04) 125.65,27.04 125.82,26.88 125.82,26.74 125.78,26.7 125.78,26.59 125.7,26.51 125.53,26.51 124.7,27.34 124.7,28.45 124.7,28.45 124.7,28.69 124.68,28.74 124.68,28.74 124.68,28.74 124.63,28.85 124.63,28.98 124.64,29 124.68,29.08 124.7,29.13 124.7,29.47 124.79,29.56 UC1.AN62
  BOTTOM w0.102: v2(178.84,16.38) 179.03,16.38 179.4,16.75 179.4,16.87 179.31,16.96 177.92,16.96 177.51,16.55 177.02,16.55 176.84,16.37 176.84,16.23 176.76,16.15 JDIMM1.27
DDR_A_DQS#2: length 66.3
  IN1 w0.076: v2(131.82,28.05) 131.94,27.93 132.17,27.93 132.32,28.09 133.02,28.09 134.54,26.56 136.73,26.56 136.74,26.57 136.75,26.57
  IN1 w0.097: v2(178.84,22.09) 179.05,22.09 179.25,21.89 179.25,21.54 179.13,21.42 177.64,21.42 177.44,21.61 177.44,22 177.28,22.17 176.86,22.17 176.65,21.95 176.65,21.52 176.55,21.42 176.3,21.42 176.19,21.53 176.19,22.01 175.99,22.21 175.55,22.21 175.35,22.01 175.35,21.52 175.28,21.45 171.9,21.45 171.78,21.58 171.78,21.93 171.53,22.18 163.53,22.18 162.7,23.02 160.48,23.02 158.06,25.43 141.76,25.43 141.1,26.09 138.61,26.09 138.13,26.57 136.75,26.57
  BOTTOM w0.076: v2(131.82,28.05) 131.91,27.96 132.18,27.96 132.26,28.03 132.26,29.6 130.03,31.82 129.53,31.82 129.29,32.07 129.1,32.07 129.08,32.06 128.94,31.99 128.74,31.99 128.58,32.07 128.45,32.07 128.35,32.02 128.29,31.99 128.09,31.99 127.92,32.07 127.86,32.13 127.77,32.22 127.77,32.37 127.69,32.45 UC1.AV57
  BOTTOM w0.102: v2(178.84,22.09) 178.99,22.09 179.16,22.26 179.16,22.42 179.01,22.57 177.97,22.57 177.35,21.95 177.12,21.95 176.73,21.55 JDIMM1.45
DDR_A_DQS#3: length 62.2
  IN1 w0.076: 136.69,30.19 136.28,30.19 135.82,29.73 135.48,29.73 132.07,33.15 132.07,33.25 132.12,33.31 v2(132.45,33.31)
  IN1 w0.097: 136.69,30.19 159.14,30.19 161.15,28.19 171.68,28.19 172.8,27.06 180.56,27.06 180.63,27.13 180.63,27.31 180.45,27.49 v2(180.37,27.49)
  BOTTOM w0.076: UC1.AV53 127.82,34.61 127.98,34.61 128.09,34.5 128.58,34.5 128.74,34.43 128.94,34.43 128.99,34.45 129.02,34.46 129.1,34.5 129.31,34.5 129.56,34.25 129.69,34.25 129.84,34.1 130.76,34.1 131.54,33.32 132.44,33.32 v2(132.45,33.31)
  BOTTOM w0.102: v2(180.37,27.49) 180.68,27.17 180.68,26.99 180.94,26.74 182.26,26.74 182.37,26.84 182.56,26.84 182.75,26.65 JDIMM1.62
DDR_A_DQS#4: length 63.2
  IN1 w0.076: 136.76,49.61 136.76,49.61 136.75,49.61 136.75,49.61 131.52,49.61 131.16,49.25 130.88,49.25 130.53,48.89 v2(130.36,48.89)
  IN1 w0.097: v2(178.73,50.22) 178.82,50.31 178.94,50.31 179.09,50.16 179.09,49.95 178.96,49.82 177.78,49.82 177.55,50.05 177.55,50.5 177.33,50.71 172.44,50.71 172.26,50.89 170.51,50.89 169.9,50.28 169.19,50.28 168.92,50.56 167.93,50.56 167.67,50.3 164.76,50.3 164.71,50.35 164.71,50.7 164.5,50.92 164.14,50.92 163.77,50.55 163.64,50.55 163.21,50.98 162.93,50.98 162.86,51.06 162.86,51.43 162.63,51.65 162.19,51.65 162.03,51.5 162.03,51.12 161.9,50.99 161.6,50.99 161.47,51.12 161.47,51.37 161.19,51.65 160.32,51.65 160.05,51.39 159.76,51.39 159.5,51.64 158.92,51.64 158.65,51.38 158.48,51.38 158.25,51.6 157.52,51.6 156.56,52.56 145.97,52.56 143.02,49.61 136.76,49.61
  BOTTOM w0.076: UC1.AW30 128.16,49.14 128,49.14 127.94,49.08 127.94,48.95 128.02,48.87 128.12,48.82 128.25,48.82 128.41,48.9 128.62,48.9 128.67,48.87 128.75,48.83 128.77,48.82 128.9,48.82 128.96,48.85 129.06,48.9 129.35,48.9 129.76,48.49 130.56,48.49 130.59,48.52 130.59,48.82 130.52,48.89 v2(130.36,48.89)
  BOTTOM w0.102: JDIMM1.135 176.79,50.95 177.02,51.18 177.22,51.18 177.61,50.79 178.79,50.79 178.98,50.6 178.98,50.47 v2(178.73,50.22)
DDR_A_DQS#5: length 62.2
  IN1 w0.076: 136.76,53.13 136.75,53.12 136.67,53.12 136.14,52.6 136.14,52.54 135.67,52.07 133.01,52.07 132.89,52.19 132.89,52.29 v2(133.14,52.54)
  IN1 w0.097: v2(181.13,55.51) 180.9,55.73 180.9,55.92 180.67,56.15 179.27,56.15 178.97,55.85 161.01,55.85 160.26,56.6 144.93,56.6 143.7,55.37 142.6,55.37 140.37,53.14 136.77,53.14 136.76,53.13
  BOTTOM w0.076: v2(133.14,52.54) 133.09,52.49 133.09,52.05 132.42,51.38 130.82,51.38 130.23,50.79 129.77,50.79 129.64,50.92 129.4,51.16 129.1,51.16 128.94,51.09 128.74,51.09 128.58,51.16 128.1,51.16 127.94,51.32 127.76,51.32 UC1.AV26
  BOTTOM w0.102: v2(181.13,55.51) 180.84,55.8 180.84,56.06 180.98,56.2 182.59,56.2 182.6,56.19 182.75,56.19 182.89,56.05 JDIMM1.152
DDR_A_DQS#6: length 63.7
  IN1 w0.076: 137.03,56.67 137.01,56.67 137,56.66 136.61,56.66 136.21,56.26 136.21,55.87 135.91,55.57 133.3,55.57 132.92,55.18 132.63,55.18 132.24,55.57 131.66,55.57 131.48,55.38 131.48,54.67 131.24,54.43 131.12,54.43 v2(131.1,54.46)
  IN1 w0.097: 137.03,56.67 138.52,56.67 142.67,60.82 143.38,60.82 143.72,60.48 144.32,60.48 144.66,60.82 145.45,60.82 145.73,61.1 146.21,61.1 146.49,60.81 146.76,60.81 147.05,61.1 147.53,61.1 147.81,60.82 148.09,60.82 148.37,61.1 148.85,61.1 149.16,60.79 152.06,60.79 152.45,61.17 168,61.17 168.28,61.46 168.92,61.46 169.18,61.2 169.62,61.2 169.9,61.48 170.39,61.48 170.7,61.18 171.6,61.18 172.06,60.72 172.51,60.72 172.79,61 173.58,61 173.87,60.72 174.69,60.72 174.97,61 175.77,61 176.05,60.72 179.11,60.72 179.22,60.83 179.22,61 179.07,61.14 v2(178.84,61.14)
  BOTTOM w0.076: v2(131.1,54.46) 131.12,54.43 131.33,54.43 131.42,54.35 131.42,54.13 131.36,54.08 130.06,54.08 129.89,53.91 129.47,53.91 129.35,54.03 129.35,54.03 129.06,54.03 129.01,54 128.93,53.97 128.9,53.96 128.77,53.96 128.75,53.96 128.67,54.01 128.62,54.03 128.41,54.03 128.25,53.96 128.12,53.96 128.02,54 127.94,54.09 127.94,54.18 128.01,54.25 UC1.AW22
  BOTTOM w0.102: v2(178.84,61.14) 179.1,61.14 179.2,61.25 179.2,61.43 179.07,61.56 176.98,61.56 176.88,61.46 176.88,61.33 176.7,61.15 JDIMM1.169
