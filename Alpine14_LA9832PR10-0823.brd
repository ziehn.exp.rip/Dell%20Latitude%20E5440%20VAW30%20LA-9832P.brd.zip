# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
Y3  25MHZ_18PF_7V25000034  [Y_7V25000034_4P]  182.51 131.84 270 top
Y4  32.768KHZ_12.5PF_9H03200031  [Y_Q13FC1350000_2P]  134.62 97.4 270 top
Y6  24MHZ_12PF_+-20PPM CRG3202412  [Y_X3G024000DC1H_4P]  170.27 112.42 0 top
YC1  32.768KHZ_12.5PF_9H03200031  [Y_Q13FC1350000_2P]  130.83 75.56 0 bottom
YC2  24MHZ_12PF_+-20PPM_CRG3202412  [Y_X3G024000DC1H_4P]  97.91 51.45 270 bottom
YV2401  27MHZ_12PF_X3G027000FC1H-H~D  [Y_X3G025000DI1H-H_4P]  67.37 99.92 180 bottom

## Library data of the parts
C3 C25 C30 C50 C118 C131 C134 C138 C145 C149 C153 C154 C169 C206 C211 C213 C220 C221 C223-C225 C228 C230 C240 C247 C405 C410 C412 C422 C425 C426 C430-C432 C437 C439 C441 C443 C452 C453 C458-C462 C2980 C3022 C3030 CC50 CC76 CC77 CV86 CV90 CV91 CV96 CV102 CV2918-CV2921 CV3048 CV3051 CV3053 CV3054 CV3056 CV3058 CV3060-CV3062 PC5 PC6 PC10-PC12 PC51 PC60-PC62 PC65 PC67-PC70 PC104 PC107 PC109 PC111 PC164 PC165 PC201 PC207 PC300 PC303 PC306 PC307 PC309 PC310 PC400 PC402 PC406 PC410 PC412 PC417 PC418 PC421 PC438 PC503 PC506 PC511-PC513 PC612 PC615 PC627 PC628 PC660-PC669 PC676-PC680 PC704 PC705 = C_0603
C5 C6 C17 C18 C73 C75 C76 C85 C115 C119 C120 C123-C127 C129 C130 C133 C135-C137 C139 C141-C144 C147 C148 C150 C152 C155-C161 C163 C167 C207 C210 C212 C214-C219 C226 C227 C229 C231-C234 C239 C246 C255 C256 C271 C273 C280 C333 C338 C382 C383 C395 C406 C409 C413 C414 C427 C434-C436 C438 C440 C442 C444-C451 C454-C456 C482 C633-C636 C645 C647 C648 C1001 C1185-C1189 C2962 C2963 C2965-C2969 C2972 C2987-C2992 C3004 C3005 C3023-C3029 C3031-C3034 CC14 CC15 CC23 CC25 CC41 CC48 CC52 CC57 CC68-CC70 CC74 CC80-CC82 CC84-CC86 CE10 CE11 CE14 CE20 CE22 CS1-CS4 CU16-CU23 CV87-CV89 CV94 CV95 CV97 CV100 CV101 CV103-CV105 CV226-CV228 CV231-CV236 CV239 CV240 CV2401-CV2408 CV2901 CV2902 CV2926-CV2969 PC3 PC4 PC53-PC55 PC57 PC102 PC103 PC112-PC115 PC150-PC153 PC156 PC157 PC202 PC205 PC206 PC301 PC302 PC304 PC305 PC308 PC317-PC324 PC401 PC407-PC409 PC413 PC414 PC424-PC429 PC431-PC435 PC439-PC441 PC500 PC502 PC504 PC507-PC510 PC514 PC515 PC613 PC614 PC616 PC617 PC619-PC626 PC670-PC673 PC700 PC701 PC706 PC708 = C_0402
C7 = C_0805: room: FAN
C8 C16 C21 C26 = C_0603: room: DP2320
C9-C15 C19 C20 C22-C24 C27-C29 C34 C42 C43 = C_0402: room: DP2320
C87 = C_0402: room: HDMI
C88 = C_0805: room: HDMI
C93-C95 C97-C99 = C_0402: room: DP125
C101 = C_0603: room: HDD
C102 C105 C106 C108 C109 C111-C114 = C_0402: room: HDD
C103 C248-C250 C252 = C_0402: room: WWAN
C116 C117 C121 C122 C128 C140 C408 C2964 CV3047 CV3049 CV3050 CV3052 CV3057 CV3059 CV3063 CV3064 PC9 PC52 PC56 PC58 PC59 PC100 PC101 PC105 PC106 PC154 PC155 PC158 PC159 PC163 PC200 PC203 PC204 PC311-PC314 PC360-PC389 PC411 PC415 PC416 PC419 PC420 PC422 PC423 PC430 PC436 PC437 PC505 PC600-PC605 PC674 PC675 PC702 PC703 = C_0805
C162 = C_0402: room: DP12412
C176-C179 C181 C183-C186 C189-C194 C198 = C_0402: room: LAN
C180 C182 = C_0603: room: LAN
C188 = C_0805: room: LAN
C199-C204 = C_0402: room: TPM
C209 C235-C238 = C_0402: room: OZ777
C242 C243 C257-C261 C268-C270 C272 = C_0402: room: WLAN
C251 = C_0805: room: WWAN
C253 = C_D2: room: WWAN
C254 = C_MP6VLPS220MC4R2: room: WWAN
C262 = C_0603: room: WLAN
C263-C267 = C_0402: room: SIM
C288 C290 = C_0805: room: USB
C289 C291-C293 = C_0402: room: USB
C294-C316 C319 CE8 CE9 = C_0402: room: DOCK
C317 C318 = C_0603: room: DOCK
C328 C336 = C_0603: room: SIO
C329-C332 C334 C337 C339 = C_0402: room: SIO
C340 C342-C347 C349-C365 C368 C369 C386 C387 = C_0402: room: KBC
C348 C366 = C_0603: room: KBC
C367 C370-C373 = C_0402: room: THERMAL
C374-C380 C384 = C_0402: room: KB/TP
C385 = C_0805: room: KB/TP
C389 = C_0603: room: +3.3V_ALW_PCH_SOURCE
C390 = C_0402: room: +3.3V_ALW_PCH_SOURCE
C391 = C_0402: room: +1.05V_RUN_SOURCE
C393 = C_0603: room: +1.05V_RUN_SOURCE
C396 = C_0603: room: +3.3V_SUS_SOURCE
C397 = C_0402: room: +3.3V_SUS_SOURCE
C398 = C_0402: room: +3.3V_M_SOURCE
C399 = C_0603: room: +3.3V_M_SOURCE
C400 = C_0603: room: +5V_RUN_SOURCE
C401 = C_0402: room: +5V_RUN_SOURCE
C402 = C_0402: room: +3.3V_RUN_SOURCE
C403 = C_0603: room: +3.3V_RUN_SOURCE
C404 = C_0402: room: LED
C809 = C_MP6VLPS220MC4R2
CC1-CC13 CC22 CC24 CC26 CC27 CC29-CC33 CC35-CC40 CC44-CC46 CC51 CC53 CC54 CC56 CC58-CC61 CC63-CC67 = C_0402: room: CPU
CC16-CC21 CC28 CC34 CC42 CC43 CC49 CC62 = C_0603: room: CPU
CC47 = C_0805: room: CPU
CC55 CC75 CC78 CC79 = C_1206
CC71 CC73 PC71 PC72 PC116 = C_D2
CD1-CD13 CD23-CD29 CD32-CD44 CD54-CD57 CD60 CD61 = C_0402: room: MEMORY
CD14-CD21 CD30 CD31 CD45-CD52 CD58 CD59 = C_0603: room: MEMORY
CD22 = C_D3: room: MEMORY
CD62 = C_D3
CE7 = C_0805: room: DOCK
CMOS1 ME1 = SHORTPADS: User Part Number: PART#; room: CPU
D1 = RB751S40T1_SOD523-2: room: FAN
D2 = AZ5125-02SPR7G_SOT23-3
D12-D14 = RB751S40T1_SOD523-2: room: WLAN
D17 = IP4292CZ10-TBR_XSON10_2P5X1: room: USB
D18 = PESD5V0U2BT_SOT23-3: room: USB
D19 = RB751S40T1_SOD523-2: room: DOCK
D20 = PESD24VS2UT_SOT23-3: room: DOCK
D22 = PESD5V0U2BT_SOT23-3: room: KB/TP
D23 D24 = RB751S40T1_SOD523-2: room: LED
D27 = L30ESD24VC3-2_SOT23-3: room: SWITCH
D65 PD4 = RB751VM-40TE-17_SOD323-2
D76 D79 D80 PD400 RTCD1 = BAT54CW_SOT323-3
D77 D78 D87 = PESD5V0U2BT_SOT23-3
D88 = L30ESDL5V0C3-2_SOT23-3
DE1 DE2 = PESD5V0U2BT_SOT23-3: room: CODEC
FD1-FD4 = FIDUCIAL_C40M80: room: LED
H1 H2 H4 = H_4P6: room: LED
H3 = H_4P3: room: LED
H5 H9 H12-H15 = H_2P8: room: LED
H6 H21 H22 = H_3P3: room: LED
H7 H11 H24 = H_2P8
H8 = H_5P0: room: LED
H10 = H_3P3X2P8: room: LED
H16 = H_2P3: room: LED
H17 = H_1P2: room: LED
H18-H20 H23 = H_3P3
HDMIU1 = AP2330W-7_SC59-3
JAPS1 = ACES_50506-01841-P01_18P
JBIO1 = ACES_51524-0060N-001_6P
JBT1 = ACES_50273-0020N-001_2P-T
JDEG1 = TYCO_1-2041070-0_10P: room: KBC
JDIMM1 = CONCR_0706F0BE80F_204P: room: MEMORY
JDIMM2 = CONCR_0706E0BE40F_204P: room: MEMORY
JDOCK1 = JAE_WD2F144WB3R300_144P: room: DOCK
JEXP1 = E-T_1001K-F40C-03L_40P
JFAN1 = ACES_50281-0040N-001_4P: room: ETY-ROOM
JHDMI1 = CONCR_099A6AC19CBLCNF_19P: room: ETY-ROOM
JIO1 = E-T_1000K-Y60E-01L_60P-T: room: ETY-ROOM
JKB1 = ACES_51524-01001-003_10P
JLED1 = ACES_51522-01201-001_12P
JLVDS1 = ACES_50398-04071-001_40P
JMED1 = ACES_51522-00601-001_6P
JMINI1 JMINI2 = LOTES_AAA-PCI-041-K01_52P: room: ETY-ROOM
JPWR1 = ACES_51522-01001-001_10P
JSATA1 = SANTA_196002-1_22P: room: HDD
JSATA2 = SANTA_201902-1_13P
JSD1 = ALPS_SCDADA0101_19P_NR-T: room: OZ777
JSIM1 = T-SOL_159-1000302602_10P: room: ETY-ROOM
JSPK1 = ACES_50273-00401-001_4P: room: ETY-ROOM
JTAA1 = ACES_50051-02071-001_20P-T: room: CPU
JTAG1 = SHORTPADS: User Part Number: PART#; room: KBC
JTP1 = ACES_51522-00801-001_8P
JTS1 = E-T_4260K-Q06N-23L_6P
JUDB1 = ACES_51522-02001-P02_20P
JUSB1 = SANTA_373280-4_9P-T: room: ETY-ROOM
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P: room: CPU
L1 L2 L4 L5 = MURAT_BLM18AG102SN1D_2P: room: ETY-ROOM
L9 L11 L12 L14 L15 L17 L18 L20 = R_0402: room: HDMI
L10 L13 L16 L19 = MURAT_DLW21SN900HQ2L_0805_4P: room: HDMI
L21 = MURAT_BLM21PG600SN1D_2P
L26 = TAIYO_CBC2012T4R7M_2P: room: LAN
L27-L34 R181 = R0603_0OHM: room: LAN
L35 L36 = MURAT_BLM18BD601SN1D_2P: room: OZ777
L37 = R0805_0OHM: room: USB
L40 L41 = MURAT_DLW21SN900HQ2L_0805_4P: room: USB
L42 = MURAT_DLW21SN900SQ2L_0805_4P: room: USB
L43 = MURAT_DLW21SN900SQ2L_0805_4P: room: DOCK
L44 L45 = R0603_0OHM: room: KB/TP
L46-L48 L52 L53 L57-L59 L72 = MURAT_DLW21SN900SQ2L_0805_4P
L49-L51 = MURAT_BLM18PG471SN1D_2P
L54 = SWLD_OCF2012181YZF_4P
L55 L56 = MURAT_DLW21SN900HQ2L_0805_4P
L69-L71 PR60 PR65 PR108 PR110 PR150 PR154 PR157 PR206 PR312 PR315 PR317 PR326 PR334 PR335 PR402 PR403 PR427 PR429 PR430 PR442 PR450 PR513 PR514 PR519 PR523 PR529 PR531 PR534 PR536 PR541-PR543 PR545 PR546 PR548-PR550 PR552 PR553 PR558-PR560 PR562 PR564 PR566 PR567 PR615 PR618 PR627 PR704 PR709 PR710 R38 R53 R63 R107 R143 R144 R153-R155 R165 R231 R234 R236 R238-R241 R244 R274-R277 R297 R306 R315 R333 R337 R341 R441 R443 R444 R461 R482 R483 R486 R487 R734 R741 R742 R2579 R2580 R2588 R2594-R2600 R2602 R2654-R2657 R2694 R2697 R2699 RC38 RC65 RC142 RC174 RC176 RC180 RC194 RC204 RC208 RC209 RC211 RC263 RD12 RD13 RV2404 RV2427 = R0402_0OHM
L73 LV76 = MURAT_BLM18PG300SN1D_2P
LC1-LC6 = MURAT_LQM2MPN2R2NG0L_2P: room: CPU
LE2-LE4 = R0603_0OHM
LV74 = MURAT_BLM18AG121SN1D_2P
LV80 = MURAT_BLM18PG181SN1D_2P
PBATT2 = ACES_51996-00971-001_9P
PC110 = C_MP2VLPS330MC4R2
PC315 PC316 = C_D
PC683 PC684 = C_X
PC709 = C_APXK2R5ARA331MF451
PD1 PD2 = TVNST52302AB0_SOT523-3
PD5 = BAV99W-7-F_SOT323-3
PD300 PD501 PD503 PD504 PD506-PD514 PD601 = SDMK0340L-7-F_SOD323-2
PD401 = BAT54HT1G_SOD323-2
PD500 PD502 PD505 = PDS5100H-13_POWERDI5-3
PH300-PH302 PR2-PR5 PR8-PR14 PR18 PR20 PR21 PR51-PR53 PR55-PR59 PR101 PR104-PR107 PR109 PR111 PR153 PR156 PR202-PR205 PR300-PR311 PR313 PR314 PR318 PR319 PR322 PR323 PR325 PR328-PR331 PR333 PR404 PR405 PR408 PR410 PR411 PR417 PR418 PR421 PR422 PR424 PR425 PR428 PR431 PR432 PR435 PR437 PR440 PR441 PR443-PR449 PR451-PR453 PR500-PR509 PR516-PR518 PR520-PR522 PR524-PR528 PR530 PR532 PR535 PR537-PR540 PR544 PR547 PR551 PR554-PR557 PR561 PR563 PR565 PR568 PR600 PR602-PR604 PR607 PR608 PR610 PR611 PR614 PR616 PR619-PR626 PR628 PR633-PR637 PR702 PR703 PR705 PR707 PR708 PR711 R25-R27 R35-R37 R39 R41 R43 R45 R48 R50-R52 R56-R62 R67 R68 R70-R73 R75-R79 R93-R102 R104-R106 R108-R110 R124 R136 R137 R139 R141 R142 R148-R150 R152 R156-R164 R166-R168 R170 R197 R201 R206 R208 R211 R212 R214 R229 R230 R290 R291 R296 R299 R302 R353 R376 R389 R391 R408 R449 R450 R459 R460 R462-R481 R484 R485 R488 R490-R492 R556 R2576-R2578 R2581-R2586 R2590-R2593 R2601 R2605 R2626-R2631 R2633-R2639 R2644 R2646-R2653 R2658-R2665 R2678 R2689 R2691-R2693 R2695 R2696 R2698 R2700 R2701 R2705 RC32 RC66 RC68 RC83 RC85 RC98 RC123 RC124 RC126 RC128 RC130 RC132 RC135 RC136 RC144 RC146 RC148 RC149 RC155-RC157 RC160 RC162 RC164-RC166 RC179 RC184-RC189 RC191 RC192 RC195-RC199 RC206 RC217 RC221 RC255 RC256 RC259 RC282-RC285 RC287-RC292 RC297 RC305 RC306 RC315 RC324 RTCR1 RV2 RV29 RV34 RV35 RV45 RV46 RV48-RV50 RV73-RV76 RV88-RV90 RV92-RV94 RV2433 RV2435-RV2442 RV2444 RV2446 RV2447 RV2647-RV2654 RV2703-RV2723 RV2805 RV2906-RV2909 RZ10 RZ11 RZ40 RZ41 = R_0402
PJP2 PJP3 = JUMP_43X39: room: HDD
PJP4 PJP8-PJP13 PJP101 PJP104 PJP401 PJP802 = JUMP_43X39
PJP5 = JUMP_43X39: room: TPM
PJP6 = JUMP_43X39: room: SIO
PJP7 = JUMP_43X39: room: KBC
PJP52 PJP53 PJP102 PJP103 PJP151 PJP600-PJP603 = JUMP_43X118
PJP150 PJP152 PJP200 PJP201 PJP700-PJP702 = JUMP_43X79
PJPDC1 = ACES_50299-00501-003_5P
PL1 PL2 = TAIYO_FBMJ4516HS720NT_2P
PL3 = MURAT_BLM18BD102SN1D_2P
PL4 PL5 = KC_FBMA-L11-453215800LMA90T_2P
PL51 PL400 = CYNTE_PCMB053T-1R0MS_2P
PL52 PL53 PL100 = PANAS_ETQP3W2R2WFN_2P
PL101 PL301 = KC_FBMA-L11-453215-121LMA90T_2
PL150 = TAI-T_TMPC0624H-R68MG-D_2P
PL200 = TAIYO_NRS4018T1R0NDGJ_2P
PL300 PL601 PL602 = TOKO_FDUE0640J-H-R22M-P3_4P
PL401 = CYNTE_PCMB103T-2R2MS_2P
PL700 = TOKO_FDSD0630-H-1R0M-P3_2P
PQ1 PQ518 = DMG2301U-7_SOT23-3
PQ2 = FDV301N-G_SOT23-3
PQ3 = MMST3904-7-F_SOT323-3
PQ4 PQ505 PQ510 PQ511 = FDS6679AZ-G_SO8
PQ5 = IMD2AGZT108_SC74-6
PQ51 PQ52 PQ700 = SIS412DN-T1-GE3_POWERPAK8-5
PQ53 PQ54 = SIS472DN-T1_POWERPAK1212-8-5
PQ100 = SI4128DY-T1-GE3_SO8
PQ101 = SI4134DY-T1-GE3_SO8
PQ400 = AON7403L_DFN8-5
PQ401 PQ402 PQ500 PQ517 PQ520 PQ522 PQ526 = NTR4502PT1G_SOT23-3
PQ403 = SI3993CDV-T1-GE3_TSOP6
PQ404 PQ600 PQ603 = SIR472DP-T1-GE3_POWERPAK8-5
PQ406 PQ601 PQ602 PQ604 PQ605 = SIRA06DP-T1-GE_POWERPAKSO-8-5
PQ409 PQ502 PQ503 PQ506 PQ507 PQ515 PQ516 PQ519 PQ523 Q5 Q21 Q30 Q32 Q122 Q123 Q125 Q140 Q143 QC4 QC6 QC8 QC9 QC11 QV2806 QZ5 QZ21 QZ22 = DMN66D0LDW-7_SOT363-6
PQ410 PQ411 PQ508 PQ512 PQ514 PQ521 PQ527-PQ529 = DMN65D8LW-7_SOT323-3
PQ501 PQ504 = SI4835DDY-T1-GE3_SO8
PQ524 = FDMC6679AZ_MLP8-5
PQ525 = AO3418_SOT23-3
PQ701 = SI7716ADN-T1-GE3_POWERPAK8-5
PR19 PR201 PR533 = R_0805
PR61 PR62 PR100 PR102 PR158 PR320 PR321 PR327 PR423 PR510 PR601 PR617 PR630 PR631 PR701 = R_0603
PR63 PR64 PR103 PR155 PR324 PR420 PR433 PR606 PR632 PR706 = R_1206
PR400 PR426 = R_1206_4P-D
PU1 = TS5A63157DCKR_SC70-6
PU51 = TPS51225CRUKR_QFN20_3X3
PU100 = G5616ARZ1U_TQFN20_3X3
PU150 = TPS51362RVER_QFN28_4P5X3P5
PU200 = SYN470DBC_DFN10_3X3
PU300 = TPS51622RSM_QFN32_4X4
PU301 = CSD97374CQ4M_SON8_3P5X4P5
PU401 = INA199A1DCKR_SC70-6
PU402 = BQ24717RGRR_QFN20_3P5X3P5
PU403 = LM358DR2G_SO8
PU404 = LM393DR_SO8
PU405 PU500 PU502-PU506 = 74AHC1G08GW_SOT353-5
PU600 = RT8813AGQW_WQFN24_4X4
PU700 = RT8237EZQW-2_WDFN10_3X3
PU701 = CD3301BRHHR_QFN36_6X6
Q9 = L2N7002WT1G_SC-70-3: room: KBC
Q11 Q13 Q14 = PMST3904_SOT323-3: room: THERMAL
Q12 = MMST3904-7-F_SOT323-3: room: THERMAL
Q15 = PMST3904_SOT323-3
Q16 = PDTA114EU_SC70-3: room: LED
Q19 Q22 Q24 Q28 = DMN66D0LDW-7_SOT363-6: room: ETY-ROOM
Q20 = L2N7002WT1G_SC-70-3
Q26 = PDTA114EU_SC70-3
Q124 = SI3457CDV-T1-GE3_TSOP6
Q126 Q137 Q138 = LP2301ALT1G_SOT23-3
Q133 Q135 = BSS138W-7-F_SOT323-3
Q142 = SI3456DDV-T1-GE3_TSOP6
QC1 = DMN66D0LDW-7_SOT363-6: room: CPU
QD1 = BSS138-G_SOT23-3: room: MEMORY
R1-R23 RC1-RC3 RC5-RC12 RC17-RC20 RC22-RC28 RC30 RC36 RC37 RC44-RC47 RC50 RC52 RC55 RC58 RC61 RC63 RC64 RC67 RC69 RC70 RC73 RC74 RC76 RC78-RC82 RC84 RC95-RC97 RC99 RC101-RC106 RC109 RC113-RC122 RC125 RC127 RC129 RC131 RC133 RC134 RC137-RC141 RC143 RC145 RC147 RC152-RC154 RC158 RC159 RC161 RC168-RC170 RC173 RC175 RC183 RC190 RC193 RC218 RC222 RC230 RC232 RC233 RC235-RC241 RC243 RC244 RC248-RC250 RC253 RC258 RC260 RC264 RC265 RC272 RC275 = R_0402: room: CPU
R24 = R_0402: room: ETY-ROOM
R28-R34 RD3 = R_0402: room: MEMORY
R40 R42 R44 R46 R47 R49 R54 R55 R64-R66 R69 R74 R440 = R_0402: room: DP2320
R91 R92 = R_0402: room: EDP
R120 R121 = R_0402: room: DP125
R122 R123 R125 R126 = R_0402: room: HDD
R130 RC254 = R0805_0OHM
R169 R175 R179 R180 R183 = R0402_0OHM: room: LAN
R171 R172 R176 R178 R184 R185 R187 RC280 = R_0402: room: LAN
R193 = R0402_0OHM: room: TPM
R205 = R_0402: room: OZ777
R215 R224 R225 R227 R228 = R_0402: room: WLAN
R216-R219 R226 R232 = R_0402: room: WWAN
R223 = R0402_0OHM: room: WLAN
R233 = R0402_0OHM: room: WWAN
R246-R251 = R_0402: room: USB
R252-R267 R269 R270 = R0402_0OHM: room: DOCK
R268 R271-R273 RE4 RE5 = R_0402: room: DOCK
R282-R286 R288 R289 R292 R293 R295 R298 R303-R305 R307-R313 R317 R320-R322 R324-R326 = R_0402: room: SIO
R294 R316 R318 R319 = R0402_0OHM: room: SIO
R327-R331 R335 R338 R340 R342 R343 R349 R351 R352 R354 R358 R360 R362 R363 R366 R367 R370 R371 R373 R375 R380-R384 R386-R388 R392 R393 R395-R399 R411 R414 = R_0402: room: KBC
R332 R334 R336 R374 R378 R379 R400 R413 = R0402_0OHM: room: KBC
R394 R402 R403 = R_0402: room: THERMAL
R404 R405 = R_0402: room: KB/TP
R406 R407 R410 = R0402_0OHM: room: KB/TP
R415 = R0402_0OHM: room: +V1.05DX_MODPHY_SOURCE
R416 = R0402_0OHM: room: +3.3V_ALW_PCH_SOURCE
R417 = R_0402: room: +1.05V_RUN_SOURCE
R418 = R0402_0OHM: room: +1.05V_RUN_SOURCE
R419 = R_0402: room: +V1.05DX_MODPHY_SOURCE
R421 = R_0402: room: +3.3V_SUS_SOURCE
R422 = R0402_0OHM: room: +3.3V_SUS_SOURCE
R423 = R_0402: room: +3.3V_M_SOURCE
R424 = R0402_0OHM: room: +3.3V_M_SOURCE
R425 = R_0402: room: +5V_RUN_SOURCE
R426 = R0402_0OHM: room: +5V_RUN_SOURCE
R428 R429 R432 R433 R435 R436 R438 = R_0402: room: LED
R2688 R2702-R2704 = MURAT_BLM18PG330SN1D_2P
RC4 RC14 RC33 RC40 RC48 RC49 RC53 RC54 RC59 RC60 RC72 RC86-RC88 RC90-RC94 RC100 RC107 RC108 RC110-RC112 RC163 RC172 RC181 RC245-RC247 RC261 RC267 = R0402_0OHM: room: CPU
RC16 = R0603_0OHM: room: CPU
RC242 RC276 = R_0603: room: CPU
RC262 = R0805_0OHM: room: CPU
RC279 RD1 RD5-RD7 RD10 RD11 = R0402_0OHM: room: MEMORY
RP1-RP18 = RP_0804_8P4R
SW5 = SW_EVQPLHA15_4P: room: ETY-ROOM
SW6 = SW_EVQPLHA15_4P
T92 T93 = TPC12: room: LAN
T171 T186-T191 = TPC12
U1 = W25Q64FVSSIQ_SO8: room: CPU
U2 = W25Q32FVSSIQ_SO8: room: CPU
U5 UC4 = 74AUP1G07GW_TSSOP5: room: CPU
U6 = IDTVMM2320BKG8_BGA_168P-NH: room: DP2320
U7 = W25X10BVSNIG_SO8: room: DP2320
U11 U13 = PI3C3125LEX_TSSOP14: room: DP125
U15 = LNG3DMTR_LGA16_3X3: room: HDD
U17 = ALC3226-CG_QFN48_7X7
U18 U19 U51 = TPS22966DPUR_SON14_2X3
U20 U24 = TC7SH08FU_SSOP5: room: LAN
U21 = WGI218LM-QQ89-B0_QFN48_6X6: room: LAN
U22 = APE8988Y_SOT26-6: room: LAN
U23 = PI3L720ZHEX_TQFN42_9X3P5: room: LAN
U25 = AT97SC3204-X2A14-AB_TSSOP28: room: TPM
U27 = OZ777FJ2LN_QFN48_6X6
U28 = SRV05-4PTCT_SOT23-6: room: SIM
U29 U33 U34 = APE8988Y_SOT26-6
U30 U86 U87 UC7 UV14 = TC7SH08FU_SSOP5
U37 = ECE5048-LZY_DQFN132_11X11: room: SIO
U38 = MEC5075-LZY_DQFN132_11X11: room: KBC
U39 = PI3V713-AZLEX_TQFN32_6X3
U41 = RT9818A-44GU3_SC70-3: room: KBC
U42 = TC7SH08FU_SSOP5: room: KBC
U43 = TPS22966DPUR_SON14_2X3: room: 3.3V_ALW_PCH_1.05V_RUN_SOURCE
U45 = TPS22966DPUR_SON14_2X3: room: 3.3V_SUS_M_SOURCE
U46 = TPS22966DPUR_SON14_2X3: room: 3.3V_5V_RUN_SOURCE
U47 = TC7SH08FU_SSOP5: room: LED
U52 = RTD2136S-VE-CG_QFN48_6X6
U83 = PS8713BTQFN24GTR2_TQFN24_4X4
U90 = USX2064-AEZG-TR_QFN36_6X6
U91 = PI2DBS212ZHEX_TQFN28_5P5X3P5
U93 = PI5A3157CEX_SC70-6
U94 = APE8939GN3_DFN8_3X3
UC1 = HASWELL-MCP-E-ULT_BGA_1168P-T: room: CPU
UC2 = 74AHC1G09GW_TSSOP5: room: CPU
UC3 = TC7SH08FU_SSOP5: room: CPU
UC5 = 5V60034DCG8_SO8: room: CPU
UC6 = 74CBTLV3126BQ_DHVQFN14_2P5X3
US1 = G547I2P81U_MSOP8
UV1 = N14M-GE-S-A2_FCBGA_595P
UV4-UV7 = MT41K256M16HA-125M-E_FBGA_96P
Y1 = Y_X1E000021042600_4P: room: DP2320
Y3 = Y_7V25000034_4P: room: LAN
Y4 = Y_Q13FC1350000_2P: room: KBC
Y6 = Y_X3G024000DC1H_4P
YC1 = Y_Q13FC1350000_2P: room: CPU
YC2 = Y_X3G024000DC1H_4P: room: CPU
YV2401 = Y_X3G025000DI1H-H_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
5V60034DCG8_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
74AHC1G08GW_SOT353-5
  oval 0.381x0.813 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74CBTLV3126BQ_DHVQFN14_2P5X3
  oval 1.041x0.254 smd: 1(0,0) 7(2.95,0) 8(2.95,0.5) 14(0,0.5)
  oval 0.254x1.041 smd: 2(0.475,-0.975) 3(0.975,-0.975) 4(1.475,-0.975) 5(1.975,-0.975) 6(2.475,-0.975) 9(2.475,1.475) 10(1.975,1.475) 11(1.475,1.475) 12(0.975,1.475) 13(0.475,1.475)
  rect 1.499x0.991 smd: 15(1.475,0.25)
ACES_50051-02071-001_20P-T
  round 0.787 hole 0.787 unplated: (-6.55,-1.2) (2.05,-1.2)
  oval 0.254x1.499 smd: 1(0,0) 2(0,-5.8) 3(-0.5,0) 4(-0.5,-5.8) 5(-1,0) 6(-1,-5.8) 7(-1.5,0) 8(-1.5,-5.8) 9(-2,0) 10(-2,-5.8) 11(-2.5,0) 12(-2.5,-5.8) 13(-3,0) 14(-3,-5.8) 15(-3.5,0) 16(-3.5,-5.8) 17(-4,0) 18(-4,-5.8) 19(-4.5,0) 20(-4.5,-5.8)
  custom 0.375x0.375 smd: 21(2.175,0) 22(-6.675,0)
  rect 1.854x2.007 smd: 23(2.175,-2.9) 24(-6.675,-2.9)
  rect 1.854x1.499 smd: 25(2.175,-5.8) 26(-6.675,-5.8)
ACES_50273-0020N-001_2P-T
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50273-00401-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 2.108x2.997 smd: 5(-2.55,-2.9) 6(6.3,-2.9)
ACES_50281-0040N-001_4P
  oval 0.787x2.007 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.007x2.489 smd: 5(2.2,-4.05) 6(-5.95,-4.05)
ACES_50299-00501-003_5P
  round 1.803 hole 1.803 unplated: (-0.2,5.2) (8.2,5.2)
  oval 0.889x2.388 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0)
ACES_50398-04071-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.194x3.2 smd: 41(-21.9,1.95) 45(2.4,1.95)
  rect 2.311x1.295 smd: 42(-18.65,3.9) 43(-9.75,3.9) 44(-0.85,3.9)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_51522-00601-001_6P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 2.489x1.905 smd: 7(-2.15,-3.3) 8(4.65,-3.3)
ACES_51522-00801-001_8P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 2.489x1.905 smd: 9(5.65,-3.3) 10(-2.15,-3.3)
ACES_51522-01001-001_10P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 2.489x1.905 smd: 11(-2.15,-3.3) 12(6.65,-3.3)
ACES_51522-01201-001_12P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 2.489x1.905 smd: 13(-2.15,-3.3) 14(7.65,-3.3)
ACES_51522-02001-P02_20P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 2.489x1.905 smd: 21(-2.15,-3.3) 22(11.65,-3.3)
ACES_51524-0060N-001_6P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 2.159x2.21 smd: 7(-2.825,-3.05) 8(7.825,-3.05)
ACES_51524-01001-003_10P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0)
  rect 2.489x2.21 smd: 11(-3,-3.05) 12(12,-3.05)
ACES_51996-00971-001_9P
  round 1.397 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.753x3.658 hole 0.991x2.896: 10(19.125,0) 11(-3.125,0)
ALC3226-CG_QFN48_7X7
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,7.1) 26(5,7.1) 27(4.5,7.1) 28(4,7.1) 29(3.5,7.1) 30(3,7.1) 31(2.5,7.1) 32(2,7.1) 33(1.5,7.1) 34(1,7.1) 35(0.5,7.1) 36(0,7.1)
  oval 0.889x0.254 smd: 13(6.3,0.8) 14(6.3,1.3) 15(6.3,1.8) 16(6.3,2.3) 17(6.3,2.8) 18(6.3,3.3) 19(6.3,3.8) 20(6.3,4.3) 21(6.3,4.8) 22(6.3,5.3) 23(6.3,5.8) 24(6.3,6.3) 37(-0.8,6.3) 38(-0.8,5.8) 39(-0.8,5.3) 40(-0.8,4.8) 41(-0.8,4.3) 42(-0.8,3.8) 43(-0.8,3.3) 44(-0.8,2.8) 45(-0.8,2.3) 46(-0.8,1.8) 47(-0.8,1.3) 48(-0.8,0.8)
  rect 5.512x5.512 smd: 49(2.75,3.55)
ALPS_SCDADA0101_19P_NR-T
  round 0.889 hole 0.889 unplated: (-7.075,-28.875) (13.425,-1.775)
  oval 0.787x1.549 smd: 1(0,0) 2(1.4,0) 3(2.8,0) 4(4.2,0) 5(7.1,0) 6(9.9,0) 7(11.3,0) 8(12.7,0) 9(-1.4,0) 18(8.5,0) 19(14.1,0)
  oval 1.346x0.787 smd: 10(-9.2,-22.925) 11(-9.2,-24.025) 12(-9.2,-25.125) 13(-9.2,-26.225) 14(20.05,-26.225) 15(20.05,-25.125) 16(20.05,-24.025) 17(20.05,-22.925)
  rect 1.397x1.448 smd: 20(17.2,0.65) 21(5.65,0.65) 22(-6.35,0.65)
  rect 1.448x1.397 smd: 23(19.525,-6.525) 24(-8.675,-6.525) 25(19.525,-20.625) 26(-8.675,-18.775)
AO3418_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON7403L_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APE8939GN3_DFN8_3X3
  oval 0.457x0.914 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3.08) 6(1.3,3.08) 7(0.65,3.08) 8(0,3.08)
  rect 2.388x1.6 smd: 9(0.975,1.54)
APE8988Y_SOT26-6
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0.95,2.4) 6(0,2.4)
AT97SC3204-X2A14-AB_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.22,0)
BAV99W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BQ24717RGRR_QFN20_3P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.45) 12(1.5,3.45) 13(1,3.45) 14(0.5,3.45) 15(0,3.45)
  oval 1.041x0.254 smd: 6(2.725,0.725) 7(2.725,1.225) 8(2.725,1.725) 9(2.725,2.225) 10(2.725,2.725) 16(-0.725,2.725) 17(-0.725,2.225) 18(-0.725,1.725) 19(-0.725,1.225) 20(-0.725,0.725)
  rect 2.057x2.057 smd: 21(1,1.725)
BSS138-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_MP2VLPS330MC4R2
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
C_MP6VLPS220MC4R2
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CD3301BRHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.14x4.14 smd: 37(2,2.9)
CONCR_099A6AC19CBLCNF_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-4.65,-1.45) 21(-4.65,-6.5) 22(13.65,-1.45) 23(13.65,-6.5)
CONCR_0706E0BE40F_204P
  round 1.6 hole 1.6 unplated: (-1.75,4.1)
  round 1.092 hole 1.092 unplated: (65.05,4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(0.3,8.2) 3(0.6,0) 4(0.9,8.2) 5(1.2,0) 6(1.5,8.2) 7(1.8,0) 8(2.1,8.2) 9(2.4,0) 10(2.7,8.2) 11(3,0) 12(3.3,8.2) 13(3.6,0) 14(3.9,8.2) 15(4.2,0) 16(4.5,8.2) 17(4.8,0) 18(5.1,8.2) 19(5.4,0) 20(5.7,8.2) 21(6,0) 22(6.3,8.2) 23(6.6,0) 24(6.9,8.2) 25(7.2,0) 26(7.5,8.2) 27(7.8,0) 28(8.1,8.2) 29(8.4,0) 30(8.7,8.2) 31(9,0) 32(9.3,8.2) 33(9.6,0) 34(9.9,8.2) 35(10.2,0) 36(10.5,8.2) 37(10.8,0) 38(11.1,8.2) 39(11.4,0) 40(11.7,8.2) 41(12,0) 42(12.3,8.2) 43(12.6,0) 44(12.9,8.2) 45(13.2,0) 46(13.5,8.2) 47(13.8,0) 48(14.1,8.2) 49(14.4,0) 50(14.7,8.2) 51(15,0) 52(15.3,8.2) 53(15.6,0) 54(15.9,8.2) 55(16.2,0) 56(16.5,8.2) 57(16.8,0) 58(17.1,8.2) 59(17.4,0) 60(17.7,8.2) 61(18,0) 62(18.3,8.2) 63(18.6,0) 64(18.9,8.2) 65(19.2,0) 66(19.5,8.2) 67(19.8,0) 68(20.1,8.2) 69(20.4,0) 70(20.7,8.2) 71(21,0) 72(21.3,8.2) 73(24,0) 74(24.3,8.2) 75(24.6,0) 76(24.9,8.2) 77(25.2,0) 78(25.5,8.2) 79(25.8,0) 80(26.1,8.2) 81(26.4,0) 82(26.7,8.2) 83(27,0) 84(27.3,8.2) 85(27.6,0) 86(27.9,8.2) 87(28.2,0) 88(28.5,8.2) 89(28.8,0) 90(29.1,8.2) 91(29.4,0) 92(29.7,8.2) 93(30,0) 94(30.3,8.2) 95(30.6,0) 96(30.9,8.2) 97(31.2,0) 98(31.5,8.2) 99(31.8,0) 100(32.1,8.2) 101(32.4,0) 102(32.7,8.2) 103(33,0) 104(33.3,8.2) 105(33.6,0) 106(33.9,8.2) 107(34.2,0) 108(34.5,8.2) 109(34.8,0) 110(35.1,8.2) 111(35.4,0) 112(35.7,8.2) 113(36,0) 114(36.3,8.2) 115(36.6,0) 116(36.9,8.2) 117(37.2,0) 118(37.5,8.2) 119(37.8,0) 120(38.1,8.2) 121(38.4,0) 122(38.7,8.2) 123(39,0) 124(39.3,8.2) 125(39.6,0) 126(39.9,8.2) 127(40.2,0) 128(40.5,8.2) 129(40.8,0) 130(41.1,8.2) 131(41.4,0) 132(41.7,8.2) 133(42,0) 134(42.3,8.2) 135(42.6,0) 136(42.9,8.2) 137(43.2,0) 138(43.5,8.2) 139(43.8,0) 140(44.1,8.2) 141(44.4,0) 142(44.7,8.2) 143(45,0) 144(45.3,8.2) 145(45.6,0) 146(45.9,8.2) 147(46.2,0) 148(46.5,8.2) 149(46.8,0) 150(47.1,8.2) 151(47.4,0) 152(47.7,8.2) 153(48,0) 154(48.3,8.2) 155(48.6,0) 156(48.9,8.2) 157(49.2,0) 158(49.5,8.2) 159(49.8,0) 160(50.1,8.2) 161(50.4,0) 162(50.7,8.2) 163(51,0) 164(51.3,8.2) 165(51.6,0) 166(51.9,8.2) 167(52.2,0) 168(52.5,8.2) 169(52.8,0) 170(53.1,8.2) 171(53.4,0) 172(53.7,8.2) 173(54,0) 174(54.3,8.2) 175(54.6,0) 176(54.9,8.2) 177(55.2,0) 178(55.5,8.2) 179(55.8,0) 180(56.1,8.2) 181(56.4,0) 182(56.7,8.2) 183(57,0) 184(57.3,8.2) 185(57.6,0) 186(57.9,8.2) 187(58.2,0) 188(58.5,8.2) 189(58.8,0) 190(59.1,8.2) 191(59.4,0) 192(59.7,8.2) 193(60,0) 194(60.3,8.2) 195(60.6,0) 196(60.9,8.2) 197(61.2,0) 198(61.5,8.2) 199(61.8,0) 200(62.1,8.2) 201(62.4,0) 202(62.7,8.2) 203(63,0) 204(63.3,8.2)
CONCR_0706F0BE80F_204P
  round 1.6 hole 1.6 unplated: (-1.75,4.1)
  round 1.092 hole 1.092 unplated: (65.05,4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(0.3,8.2) 3(0.6,0) 4(0.9,8.2) 5(1.2,0) 6(1.5,8.2) 7(1.8,0) 8(2.1,8.2) 9(2.4,0) 10(2.7,8.2) 11(3,0) 12(3.3,8.2) 13(3.6,0) 14(3.9,8.2) 15(4.2,0) 16(4.5,8.2) 17(4.8,0) 18(5.1,8.2) 19(5.4,0) 20(5.7,8.2) 21(6,0) 22(6.3,8.2) 23(6.6,0) 24(6.9,8.2) 25(7.2,0) 26(7.5,8.2) 27(7.8,0) 28(8.1,8.2) 29(8.4,0) 30(8.7,8.2) 31(9,0) 32(9.3,8.2) 33(9.6,0) 34(9.9,8.2) 35(10.2,0) 36(10.5,8.2) 37(10.8,0) 38(11.1,8.2) 39(11.4,0) 40(11.7,8.2) 41(12,0) 42(12.3,8.2) 43(12.6,0) 44(12.9,8.2) 45(13.2,0) 46(13.5,8.2) 47(13.8,0) 48(14.1,8.2) 49(14.4,0) 50(14.7,8.2) 51(15,0) 52(15.3,8.2) 53(15.6,0) 54(15.9,8.2) 55(16.2,0) 56(16.5,8.2) 57(16.8,0) 58(17.1,8.2) 59(17.4,0) 60(17.7,8.2) 61(18,0) 62(18.3,8.2) 63(18.6,0) 64(18.9,8.2) 65(19.2,0) 66(19.5,8.2) 67(19.8,0) 68(20.1,8.2) 69(20.4,0) 70(20.7,8.2) 71(21,0) 72(21.3,8.2) 73(24,0) 74(24.3,8.2) 75(24.6,0) 76(24.9,8.2) 77(25.2,0) 78(25.5,8.2) 79(25.8,0) 80(26.1,8.2) 81(26.4,0) 82(26.7,8.2) 83(27,0) 84(27.3,8.2) 85(27.6,0) 86(27.9,8.2) 87(28.2,0) 88(28.5,8.2) 89(28.8,0) 90(29.1,8.2) 91(29.4,0) 92(29.7,8.2) 93(30,0) 94(30.3,8.2) 95(30.6,0) 96(30.9,8.2) 97(31.2,0) 98(31.5,8.2) 99(31.8,0) 100(32.1,8.2) 101(32.4,0) 102(32.7,8.2) 103(33,0) 104(33.3,8.2) 105(33.6,0) 106(33.9,8.2) 107(34.2,0) 108(34.5,8.2) 109(34.8,0) 110(35.1,8.2) 111(35.4,0) 112(35.7,8.2) 113(36,0) 114(36.3,8.2) 115(36.6,0) 116(36.9,8.2) 117(37.2,0) 118(37.5,8.2) 119(37.8,0) 120(38.1,8.2) 121(38.4,0) 122(38.7,8.2) 123(39,0) 124(39.3,8.2) 125(39.6,0) 126(39.9,8.2) 127(40.2,0) 128(40.5,8.2) 129(40.8,0) 130(41.1,8.2) 131(41.4,0) 132(41.7,8.2) 133(42,0) 134(42.3,8.2) 135(42.6,0) 136(42.9,8.2) 137(43.2,0) 138(43.5,8.2) 139(43.8,0) 140(44.1,8.2) 141(44.4,0) 142(44.7,8.2) 143(45,0) 144(45.3,8.2) 145(45.6,0) 146(45.9,8.2) 147(46.2,0) 148(46.5,8.2) 149(46.8,0) 150(47.1,8.2) 151(47.4,0) 152(47.7,8.2) 153(48,0) 154(48.3,8.2) 155(48.6,0) 156(48.9,8.2) 157(49.2,0) 158(49.5,8.2) 159(49.8,0) 160(50.1,8.2) 161(50.4,0) 162(50.7,8.2) 163(51,0) 164(51.3,8.2) 165(51.6,0) 166(51.9,8.2) 167(52.2,0) 168(52.5,8.2) 169(52.8,0) 170(53.1,8.2) 171(53.4,0) 172(53.7,8.2) 173(54,0) 174(54.3,8.2) 175(54.6,0) 176(54.9,8.2) 177(55.2,0) 178(55.5,8.2) 179(55.8,0) 180(56.1,8.2) 181(56.4,0) 182(56.7,8.2) 183(57,0) 184(57.3,8.2) 185(57.6,0) 186(57.9,8.2) 187(58.2,0) 188(58.5,8.2) 189(58.8,0) 190(59.1,8.2) 191(59.4,0) 192(59.7,8.2) 193(60,0) 194(60.3,8.2) 195(60.6,0) 196(60.9,8.2) 197(61.2,0) 198(61.5,8.2) 199(61.8,0) 200(62.1,8.2) 201(62.4,0) 202(62.7,8.2) 203(63,0) 204(63.3,8.2)
  rect 4.699x6.807 smd: 205(-5.7,-7.2) 206(69,-7.2)
CSD97374CQ4M_SON8_3P5X4P5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 6(0.8,3.5) 7(0.4,3.5) 8(0,3.5)
  custom 0.225x0.225 smd: 4(2.2,0.262) 5(2.2,3.238)
  rect 4.039x2.21 smd: 9(1.6,1.75)
CYNTE_PCMB053T-1R0MS_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
CYNTE_PCMB103T-2R2MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_1000K-Y60E-01L_60P-T
  round 0.66 hole 0.66 unplated: (-0.19,-2.125) (14.81,-2.125)
  oval 0.381x1.753 smd: 1(0,0) 2(0,-4.25) 59(14.62,0) 60(14.62,-4.25)
  oval 0.254x1.753 smd: 3(0.56,0) 4(0.56,-4.25) 5(1.06,0) 6(1.06,-4.25) 7(1.56,0) 8(1.56,-4.25) 9(2.06,0) 10(2.06,-4.25) 11(2.56,0) 12(2.56,-4.25) 13(3.06,0) 14(3.06,-4.25) 15(3.56,0) 16(3.56,-4.25) 17(4.06,0) 18(4.06,-4.25) 19(4.56,0) 20(4.56,-4.25) 21(5.06,0) 22(5.06,-4.25) 23(5.56,0) 24(5.56,-4.25) 25(6.06,0) 26(6.06,-4.25) 27(6.56,0) 28(6.56,-4.25) 29(7.06,0) 30(7.06,-4.25) 31(7.56,0) 32(7.56,-4.25) 33(8.06,0) 34(8.06,-4.25) 35(8.56,0) 36(8.56,-4.25) 37(9.06,0) 38(9.06,-4.25) 39(9.56,0) 40(9.56,-4.25) 41(10.06,0) 42(10.06,-4.25) 43(10.56,0) 44(10.56,-4.25) 45(11.06,0) 46(11.06,-4.25) 47(11.56,0) 48(11.56,-4.25) 49(12.06,0) 50(12.06,-4.25) 51(12.56,0) 52(12.56,-4.25) 53(13.06,0) 54(13.06,-4.25) 55(13.56,0) 56(13.56,-4.25) 57(14.06,0) 58(14.06,-4.25)
  custom 0.337x0.337 smd: 61(-1.065,-2.125) 62(15.685,-2.125)
E-T_1001K-F40C-03L_40P
  round 0.66 hole 0.66 unplated: (-10.81,-2.425) (1.19,-2.425)
  oval 0.381x1.143 smd: 1(0,0) 2(0,-4.85) 39(-9.62,0) 40(-9.62,-4.85)
  oval 0.254x1.143 smd: 3(-0.56,0) 4(-0.56,-4.85) 5(-1.06,0) 6(-1.06,-4.85) 7(-1.56,0) 8(-1.56,-4.85) 9(-2.06,0) 10(-2.06,-4.85) 11(-2.56,0) 12(-2.56,-4.85) 13(-3.06,0) 14(-3.06,-4.85) 15(-3.56,0) 16(-3.56,-4.85) 17(-4.06,0) 18(-4.06,-4.85) 19(-4.56,0) 20(-4.56,-4.85) 21(-5.06,0) 22(-5.06,-4.85) 23(-5.56,0) 24(-5.56,-4.85) 25(-6.06,0) 26(-6.06,-4.85) 27(-6.56,0) 28(-6.56,-4.85) 29(-7.06,0) 30(-7.06,-4.85) 31(-7.56,0) 32(-7.56,-4.85) 33(-8.06,0) 34(-8.06,-4.85) 35(-8.56,0) 36(-8.56,-4.85) 37(-9.06,0) 38(-9.06,-4.85)
  custom 0.4x0.4 smd: 41(2.14,-2.425) 42(-11.76,-2.425)
E-T_4260K-Q06N-23L_6P
  oval 0.508x1.6 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0)
  rect 1.194x1.702 smd: 7(-5.3,-2.25) 8(1.3,-2.25)
ECE5048-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
FDMC6679AZ_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FDS6679AZ-G_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.35) 6(2.54,5.35) 7(1.27,5.35) 8(0,5.35)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G547I2P81U_MSOP8
  oval 0.381x1.549 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.37) 6(1.3,4.37) 7(0.65,4.37) 8(0,4.37)
G5616ARZ1U_TQFN20_3X3
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.6x1.6 smd: 21(0.8,1.488)
H_1P2
  round 1.702 hole 1.194: 1(0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P3X2P8
  oval 3.81x3.302 hole 3.302x2.794: 1(0,0)
H_4P3
  round 4.801 hole 4.293: 1(0,0)
H_4P6
  round 5.105 hole 4.597: 1(0,0)
H_5P0
  round 5.512 hole 5.004: 1(0,0)
HASWELL-MCP-E-ULT_BGA_1168P-T
  round 0.508 smd: A3(-1.137,0) A62(-38.036,0) AW1(0,22.042) AW63(-38.628,22.057) AY2(-0.543,22.628) AY62(-38.062,22.628) B2(-0.508,0.508) B63(-38.628,0.592) C1(0,1.137)
  round 0.381 smd: A4(-1.894,0) A5(-2.554,0) A6(-3.75,0) A59(-35.9,0) A60(-36.726,0) A61(-37.386,0) AA9(-5.032,11.576) AA21(-11.688,11.489) AA23(-13.115,11.489) AA58(-35.377,11.33) AB10(-5.476,12.053) AB20(-11.18,11.896) AB21(-11.688,12.302) AB22(-12.607,11.896) AB23(-13.115,12.302) AB57(-35.057,11.98) AC9(-5.032,12.529) AC20(-11.18,12.709) AC22(-12.607,12.709) AC58(-35.377,12.63) AD10(-5.476,13.005) AD21(-11.688,13.115) AD23(-13.115,13.115) AD57(-35.057,13.28) AE9(-5.032,13.481) AE10(-5.476,13.958) AE20(-11.18,13.521) AE21(-11.688,13.928) AE22(-12.607,13.521) AE23(-13.115,13.928) AE58(-35.377,13.931) AF9(-5.032,14.434) AF11(-6.059,14.282) AF12(-6.872,14.282) AF14(-7.685,14.282) AF15(-8.497,14.282) AF17(-9.31,14.282) AF18(-10.123,14.282) AF20(-10.936,14.282) AF22(-12.607,14.334) AG10(-5.653,14.79) AG11(-6.465,14.79) AG13(-7.278,14.79) AG14(-8.091,14.79) AG16(-8.904,14.79) AG17(-9.717,14.79) AG19(-10.529,14.79) AG20(-11.342,14.79) AG23(-13.115,14.741) AG57(-35.057,14.581) AG58(-35.692,15.009) AH22(-12.607,15.147) AH24(-13.92,15.289) AH26(-15.22,15.289) AH28(-16.521,15.289) AH30(-17.821,15.289) AH32(-19.122,15.289) AH34(-20.422,15.289) AH36(-21.723,15.289) AH38(-23.023,15.289) AH40(-24.324,15.289) AH42(-25.624,15.289) AH44(-26.925,15.289) AH46(-28.225,15.289) AH49(-29.526,15.289) AH51(-30.826,15.289) AH53(-32.127,15.289) AH55(-33.427,15.289) AH57(-34.728,15.289) AJ23(-13.115,15.553) AJ25(-14.57,15.614) AJ27(-15.871,15.614) AJ29(-17.171,15.614) AJ31(-18.472,15.614) AJ33(-19.772,15.614) AJ35(-21.073,15.614) AJ37(-22.373,15.614) AJ39(-23.674,15.614) AJ41(-24.974,15.614) AJ43(-26.275,15.614) AJ45(-27.575,15.614) AJ47(-28.875,15.614) AJ50(-30.176,15.614) AJ52(-31.476,15.614) AJ54(-32.777,15.614) AJ56(-34.077,15.614) AJ58(-35.378,15.614) AT1(0,19.997) AT63(-38.628,19.848) AU1(0,20.657) AU63(-38.628,20.673) AV1(0,21.318) AV2(-0.66,21.308) AV62(-37.978,21.318) AV63(-38.628,21.333) AW2(-0.66,21.968) AW3(-1.321,21.968) AW61(-37.328,21.978) AW62(-37.978,21.978) AY3(-1.267,22.628) AY4(-1.928,22.628) AY5(-2.588,22.628) AY59(-36.088,22.628) AY60(-36.748,22.628) AY61(-37.409,22.628) B3(-1.259,0.65) B61(-37.315,0.66) B62(-37.978,0.724) C2(-0.65,1.259) C62(-37.978,1.384) C63(-38.628,1.316) D1(0,1.861) D63(-38.628,1.976) E1(0,2.522) E23(-13.333,2.601) E25(-14.714,2.601) E27(-15.84,2.601) E29(-17.221,2.601) E31(-18.348,2.601) E33(-19.729,2.601) E35(-20.855,2.601) E37(-22.236,2.601) E39(-23.363,2.601) E41(-24.744,2.601) E43(-25.87,2.601) E45(-27.251,2.601) E47(-28.378,2.601) E49(-29.759,2.601) E51(-30.885,2.601) E53(-32.266,2.601) E55(-33.393,2.601) E57(-34.774,2.601) E63(-38.628,2.647) F1(0,3.436) F22(-12.717,3.058) F24(-14.023,3.126) F26(-15.277,3.126) F28(-16.531,3.126) F30(-17.785,3.126) F32(-19.038,3.126) F34(-20.292,3.126) F36(-21.546,3.126) F38(-22.8,3.126) F40(-24.053,3.126) F42(-25.307,3.126) F44(-26.561,3.126) F46(-27.815,3.126) F48(-29.068,3.126) F50(-30.322,3.126) F52(-31.576,3.126) F54(-32.83,3.126) F56(-34.083,3.126) F58(-35.377,3.126) G22(-12.607,3.768) G23(-13.333,3.451) G25(-14.714,3.451) G27(-15.84,3.451) G29(-17.221,3.451) G31(-18.348,3.451) G33(-19.729,3.451) G35(-20.855,3.451) G37(-22.236,3.451) G39(-23.363,3.451) G41(-24.744,3.451) G43(-25.87,3.451) G45(-27.251,3.451) G47(-28.378,3.451) G49(-29.759,3.451) G51(-30.885,3.451) G53(-32.266,3.451) G55(-33.393,3.451) G57(-34.774,3.451) H22(-12.607,4.581) H23(-13.115,4.174) H57(-35.057,4.101) J22(-12.607,5.393) J23(-13.115,4.987) J58(-35.377,4.827) K9(-5.032,5.861) K10(-5.935,5.7) K12(-6.888,5.7) K14(-7.84,5.7) K16(-8.793,5.7) K18(-9.745,5.7) K19(-10.698,5.7) K21(-11.65,5.7) K23(-13.115,5.8) K57(-35.057,5.478) L10(-5.476,6.338) L11(-6.412,6.144) L13(-7.364,6.144) L15(-8.317,6.144) L17(-9.269,6.144) L18(-10.222,6.144) L20(-11.18,6.206) L22(-12.607,6.206) L58(-35.377,6.128) M9(-5.032,6.814) M20(-11.18,7.019) M21(-11.688,6.613) M22(-12.607,7.019) M23(-13.115,6.613) M57(-35.057,6.778) N10(-5.476,7.29) N21(-11.688,7.425) N23(-13.115,7.425) N58(-35.377,7.428) P9(-5.032,7.766) P20(-11.18,7.832) P22(-12.607,7.832) P57(-35.057,8.078) R10(-5.476,8.243) R20(-11.18,8.645) R21(-11.688,8.238) R22(-12.607,8.645) R23(-13.115,8.238) T9(-5.032,8.719) T21(-11.688,9.051) T23(-13.115,9.051) T58(-35.377,8.729) U9(-5.032,9.671) U10(-5.476,9.195) U20(-11.18,9.457) U22(-12.607,9.457) U57(-35.057,9.379) V10(-5.476,10.148) V21(-11.688,9.864) V23(-13.115,9.864) V58(-35.377,10.029) W9(-5.032,10.624) W20(-11.18,10.27) W21(-11.688,10.677) W22(-12.607,10.27) W23(-13.115,10.677) W57(-35.057,10.679) Y10(-5.476,11.1) Y20(-11.18,11.083) Y22(-12.607,11.083)
  round 0.305 smd: A8(-4.538,0) A9(-5.452,0) A11(-6.367,0) A12(-7.116,0) A14(-8.03,0) A15(-8.945,0) A17(-9.694,0) A18(-10.608,0) A20(-11.523,0) A21(-12.272,0) A23(-13.186,0) A24(-14.023,0.325) A25(-14.714,0) A27(-15.84,0) A28(-16.531,0.325) A29(-17.221,0) A31(-18.348,0) A32(-19.038,0.325) A33(-19.729,0) A35(-20.855,0) A36(-21.546,0.325) A37(-22.236,0) A39(-23.363,0) A40(-24.053,0.325) A41(-24.744,0) A43(-25.87,0) A44(-26.561,0.325) A45(-27.251,0) A47(-28.378,0) A48(-29.068,0.325) A49(-29.759,0) A51(-30.885,0) A52(-31.576,0.325) A53(-32.266,0) A55(-33.393,0) A56(-34.083,0.325) A57(-34.774,0) AA1(0,11.717) AA2(-0.65,11.717) AA3(-1.3,11.678) AA4(-1.951,11.678) AA59(-36.027,11.638) AA60(-36.678,11.638) AA61(-37.328,11.638) AA62(-37.978,11.676) AA63(-38.628,11.676) AB5(-2.637,12.053) AB6(-3.287,12.053) AB7(-3.937,12.053) AB8(-4.587,12.053) AC1(0,12.466) AC2(-0.65,12.466) AC3(-1.3,12.504) AC4(-1.951,12.504) AC59(-36.027,12.464) AC60(-36.678,12.464) AC61(-37.328,12.464) AC62(-37.978,12.426) AC63(-38.628,12.426) AD1(0,13.215) AD2(-0.65,13.215) AD3(-1.3,13.177) AD4(-1.951,13.177) AD5(-2.637,13.005) AD6(-3.287,13.005) AD7(-3.937,13.005) AD8(-4.587,13.005) AD59(-36.027,13.137) AD60(-36.678,13.137) AD61(-37.328,13.137) AD62(-37.978,13.175) AD63(-38.628,13.175) AE5(-2.637,13.958) AE6(-3.287,13.958) AE7(-3.937,13.958) AE8(-4.587,13.958) AE59(-36.027,13.962) AE60(-36.678,13.962) AE61(-37.328,13.962) AE62(-37.978,13.924) AE63(-38.628,13.924) AF1(0,13.964) AF2(-0.65,13.964) AF3(-1.3,14.003) AF4(-1.951,14.003) AG1(0,14.714) AG2(-0.65,14.714) AG3(-1.3,14.676) AG4(-1.951,14.676) AG5(-2.637,14.91) AG6(-3.287,14.91) AG7(-3.937,14.91) AG8(-4.587,14.91) AG21(-11.955,15.122) AG60(-36.352,14.602) AG61(-37.003,14.602) AG62(-37.653,14.602) AG63(-38.303,14.602) AH1(0,15.463) AH2(-0.65,15.463) AH3(-1.3,15.501) AH4(-1.951,15.501) AH10(-5.653,15.476) AH11(-6.465,15.476) AH13(-7.278,15.476) AH14(-8.091,15.476) AH16(-8.904,15.476) AH17(-9.717,15.476) AH19(-10.529,15.476) AH20(-11.342,15.476) AH60(-36.678,15.278) AH61(-37.328,15.278) AH62(-37.978,15.278) AH63(-38.628,15.278) AJ5(-2.637,15.863) AJ6(-3.287,15.863) AJ7(-3.937,15.863) AJ8(-4.587,15.863) AJ10(-5.653,16.126) AJ11(-6.465,16.126) AJ13(-7.278,16.126) AJ14(-8.091,16.126) AJ60(-36.352,15.954) AJ61(-37.003,15.954) AJ62(-37.653,15.954) AJ63(-38.303,15.954) AK1(0,16.212) AK2(-0.65,16.212) AK3(-1.3,16.174) AK4(-1.951,16.174) AK8(-4.303,16.451) AK18(-9.848,16.266) AK20(-10.801,16.266) AK21(-11.753,16.266) AK60(-36.678,16.523) AK61(-37.328,16.523) AK62(-37.978,16.629) AK63(-38.628,16.629) AL1(0,16.962) AL2(-0.65,16.962) AL3(-1.3,17) AL4(-1.951,17) AL5(-2.901,16.776) AL7(-3.739,16.776) AL8(-4.303,17.101) AL10(-5.658,16.776) AL11(-6.221,17.101) AL13(-7.576,16.776) AL15(-8.14,17.101) AL17(-9.222,16.583) AL18(-9.848,16.916) AL20(-10.801,16.916) AL21(-11.753,16.916) AL22(-12.706,16.916) AL23(-13.529,16.916) AL25(-14.504,16.916) AL26(-15.456,16.916) AL28(-16.409,16.916) AL29(-17.361,16.916) AL31(-18.26,16.591) AL32(-18.824,16.916) AL33(-19.726,16.916) AL35(-20.729,16.916) AL36(-21.58,16.916) AL38(-22.634,16.916) AL39(-23.542,16.591) AL40(-24.131,16.916) AL42(-24.944,16.916) AL43(-25.897,16.916) AL45(-26.874,16.916) AL46(-27.802,16.916) AL48(-28.856,16.916) AL49(-29.757,16.916) AL51(-30.761,16.916) AL52(-31.583,16.916) AL54(-32.61,16.916) AL55(-33.562,16.916) AL57(-34.509,16.916) AL58(-35.408,16.916) AL60(-36.352,17.169) AL61(-37.003,17.169) AM1(0,17.711) AM2(-0.65,17.711) AM3(-1.3,17.673) AM4(-1.951,17.673) AM5(-2.901,17.426) AM7(-3.739,17.426) AM8(-4.303,17.752) AM10(-5.658,17.426) AM11(-6.221,17.752) AM13(-7.576,17.426) AM15(-8.14,17.752) AM17(-9.222,17.233) AM18(-9.848,17.567) AM20(-10.801,17.567) AM21(-11.753,17.567) AM22(-12.706,17.567) AM23(-13.529,17.567) AM25(-14.504,17.567) AM26(-15.456,17.567) AM28(-16.409,17.567) AM29(-17.361,17.567) AM31(-18.26,17.242) AM32(-18.824,17.567) AM33(-19.726,17.567) AM35(-20.729,17.567) AM36(-21.58,17.567) AM38(-22.634,17.567) AM40(-24.131,17.567) AM42(-24.944,17.567) AM43(-25.897,17.567) AM45(-26.874,17.567) AM46(-27.802,17.567) AM48(-28.856,17.567) AM49(-29.757,17.567) AM51(-30.761,17.567) AM52(-31.583,17.567) AM54(-32.61,17.567) AM55(-33.562,17.567) AM57(-34.509,17.567) AM58(-35.408,17.567) AM60(-36.678,17.816) AM61(-37.328,17.816) AM62(-37.978,17.709) AM63(-38.628,17.709) AN1(0,18.46) AN2(-0.65,18.46) AN3(-1.3,18.498) AN4(-1.951,18.498) AN5(-2.901,18.077) AN7(-3.739,18.077) AN8(-4.303,18.402) AN10(-5.658,18.077) AN11(-6.221,18.402) AN13(-7.576,18.077) AN15(-8.14,18.402) AN17(-9.222,17.883) AN18(-9.848,18.217) AN20(-10.801,18.217) AN21(-11.753,18.217) AN22(-12.706,18.217) AN23(-13.529,18.217) AN25(-14.504,18.217) AN26(-15.456,18.217) AN28(-16.409,18.217) AN29(-17.361,18.217) AN31(-18.26,17.892) AN32(-18.824,18.217) AN33(-19.726,18.217) AN35(-20.729,18.217) AN36(-21.58,18.217) AN38(-22.634,18.217) AN39(-23.542,17.892) AN40(-24.131,18.217) AN42(-24.944,18.217) AN43(-25.897,18.217) AN45(-26.874,18.217) AN46(-27.802,18.217) AN48(-28.856,18.217) AN49(-29.757,18.217) AN51(-30.761,18.217) AN52(-31.583,18.217) AN54(-32.61,18.217) AN55(-33.562,18.217) AN57(-34.509,18.217) AN58(-35.408,18.217) AN60(-36.352,18.385) AN61(-37.003,18.385) AN62(-37.653,18.385) AN63(-38.303,18.385) AP1(0,19.21) AP2(-0.65,19.21) AP3(-1.3,19.171) AP4(-1.951,19.171) AP5(-2.901,18.727) AP7(-3.739,18.727) AP8(-4.303,19.052) AP10(-5.658,18.727) AP11(-6.221,19.052) AP13(-7.576,18.727) AP15(-8.14,19.052) AP17(-9.222,18.533) AP18(-9.848,18.867) AP20(-10.801,18.867) AP21(-11.753,18.867) AP22(-12.706,18.867) AP23(-13.529,18.867) AP25(-14.504,18.867) AP26(-15.456,18.867) AP28(-16.409,18.867) AP29(-17.361,18.867) AP31(-18.26,18.542) AP32(-18.824,18.867) AP33(-19.726,18.867) AP35(-20.729,18.867) AP36(-21.58,18.867) AP38(-22.634,18.867) AP39(-23.542,18.542) AP40(-24.131,18.867) AP42(-24.944,18.867) AP43(-25.897,18.867) AP45(-26.874,18.867) AP46(-27.802,18.867) AP48(-28.856,18.867) AP49(-29.757,18.867) AP51(-30.761,18.867) AP52(-31.583,18.867) AP54(-32.61,18.867) AP55(-33.562,18.867) AP57(-34.509,18.867) AP58(-35.408,18.867) AP60(-36.678,19.06) AP61(-37.328,19.06) AP62(-37.978,19.06) AP63(-38.628,19.06) AR5(-2.901,19.377) AR7(-3.739,19.377) AR8(-4.303,19.702) AR10(-5.658,19.377) AR11(-6.221,19.702) AR13(-7.576,19.377) AR15(-8.14,19.702) AR17(-9.222,19.184) AR18(-9.848,19.517) AR20(-10.801,19.517) AR21(-11.753,19.517) AR22(-12.706,19.517) AR23(-13.529,19.517) AR25(-14.504,19.517) AR26(-15.456,19.517) AR28(-16.409,19.517) AR29(-17.361,19.517) AR31(-18.26,19.192) AR32(-18.824,19.517) AR33(-19.726,19.517) AR35(-20.729,19.517) AR36(-21.58,19.517) AR38(-22.634,19.517) AR39(-23.542,19.192) AR40(-24.131,19.517) AR42(-24.944,19.517) AR43(-25.897,19.517) AR45(-26.874,19.517) AR46(-27.802,19.517) AR48(-28.856,19.517) AR49(-29.757,19.517) AR51(-30.761,19.517) AR52(-31.583,19.517) AR54(-32.61,19.517) AR55(-33.562,19.517) AR57(-34.509,19.517) AR58(-35.408,19.517) AT2(-0.65,19.959) AT3(-1.3,19.997) AT4(-1.951,19.997) AT5(-2.901,20.027) AT7(-3.739,20.027) AT10(-5.658,20.027) AT13(-7.576,20.027) AT35(-20.437,20.22) AT37(-22.011,20.22) AT40(-23.586,20.22) AT42(-25.161,20.22) AT43(-26.736,20.22) AT46(-28.311,20.22) AT49(-29.912,20.248) AT61(-37.003,19.634) AT62(-37.812,19.69) AU2(-0.655,20.647) AU3(-1.315,20.647) AU4(-1.976,20.647) AU6(-3.337,20.678) AU7(-4.163,20.678) AU8(-4.836,20.678) AU10(-5.661,20.678) AU11(-6.335,20.678) AU12(-7.16,20.678) AU14(-7.833,20.678) AU15(-8.659,20.678) AU16(-9.222,20.353) AU17(-9.86,20.678) AU18(-10.536,20.353) AU19(-11.105,20.678) AU20(-11.751,20.353) AU21(-12.397,20.678) AU22(-12.966,20.353) AU23(-13.642,20.678) AU24(-14.318,20.353) AU25(-14.993,20.678) AU26(-15.669,20.353) AU27(-16.238,20.678) AU28(-16.884,20.353) AU29(-17.531,20.678) AU30(-18.1,20.353) AU31(-18.775,20.678) AU33(-19.372,20.33) AU34(-19.974,20.678) AU35(-20.899,20.678) AU36(-21.549,20.678) AU37(-22.474,20.678) AU39(-23.124,20.678) AU40(-24.048,20.678) AU41(-24.699,20.678) AU42(-25.623,20.678) AU43(-26.274,20.678) AU44(-27.198,20.678) AU46(-27.848,20.678) AU47(-28.773,20.678) AU49(-29.423,20.678) AU50(-30.4,20.678) AU51(-30.98,20.353) AU52(-31.656,20.678) AU53(-32.331,20.353) AU54(-32.9,20.678) AU55(-33.547,20.353) AU56(-34.193,20.678) AU57(-34.762,20.353) AU58(-35.438,20.678) AU59(-36.002,20.353) AU60(-36.566,20.678) AU61(-37.277,20.401) AU62(-37.978,20.663) AV3(-1.321,21.308) AV4(-1.976,21.308) AV5(-2.664,21.328) AV6(-3.337,21.328) AV7(-4.163,21.328) AV8(-4.836,21.328) AV10(-5.661,21.328) AV11(-6.335,21.328) AV12(-7.16,21.328) AV14(-7.833,21.328) AV15(-8.659,21.328) AV16(-9.222,21.003) AV17(-9.86,21.328) AV18(-10.536,21.003) AV19(-11.105,21.328) AV20(-11.751,21.003) AV21(-12.397,21.328) AV22(-12.966,21.003) AV23(-13.642,21.328) AV24(-14.318,21.003) AV25(-14.993,21.328) AV26(-15.669,21.003) AV27(-16.238,21.328) AV28(-16.884,21.003) AV29(-17.531,21.328) AV30(-18.1,21.003) AV31(-18.775,21.328) AV33(-19.4,21.003) AV34(-20.024,21.328) AV35(-20.849,21.328) AV36(-21.599,21.328) AV37(-22.424,21.328) AV39(-23.173,21.328) AV40(-23.999,21.328) AV41(-24.748,21.328) AV42(-25.574,21.328) AV43(-26.323,21.328) AV44(-27.149,21.328) AV46(-27.898,21.328) AV47(-28.723,21.328) AV49(-29.473,21.328) AV50(-30.298,21.328) AV51(-30.98,21.003) AV52(-31.656,21.328) AV53(-32.331,21.003) AV54(-32.9,21.328) AV55(-33.547,21.003) AV56(-34.193,21.328) AV57(-34.762,21.003) AV58(-35.438,21.328) AV59(-36.002,21.003) AV60(-36.566,21.328) AV61(-37.302,21.051) AW4(-1.976,21.968) AW5(-2.626,21.978) AW6(-3.375,21.978) AW7(-4.125,21.978) AW8(-4.874,21.978) AW10(-5.623,21.978) AW11(-6.373,21.978) AW12(-7.122,21.978) AW14(-7.871,21.978) AW15(-8.621,21.978) AW16(-9.222,21.653) AW17(-9.86,21.978) AW18(-10.536,21.653) AW19(-11.211,21.978) AW21(-12.291,21.978) AW22(-12.966,21.653) AW23(-13.642,21.978) AW24(-14.318,21.653) AW25(-14.993,21.978) AW26(-15.669,21.653) AW27(-16.345,21.978) AW29(-17.424,21.978) AW30(-18.1,21.653) AW31(-18.775,21.978) AW33(-19.451,21.653) AW34(-20.024,21.978) AW35(-20.849,21.978) AW36(-21.599,21.978) AW37(-22.424,21.978) AW39(-23.173,21.978) AW40(-23.999,21.978) AW41(-24.748,21.978) AW42(-25.574,21.978) AW43(-26.323,21.978) AW44(-27.149,21.978) AW46(-27.898,21.978) AW47(-28.723,21.978) AW49(-29.473,21.978) AW50(-30.298,21.978) AW51(-30.98,21.653) AW52(-31.656,21.978) AW53(-32.331,21.653) AW54(-33.007,21.978) AW56(-34.087,21.978) AW57(-34.762,21.653) AW58(-35.438,21.978) AW59(-36.002,21.653) AW60(-36.566,21.978) AY6(-3.375,22.628) AY7(-4.125,22.628) AY8(-4.874,22.628) AY10(-5.623,22.628) AY11(-6.373,22.628) AY12(-7.122,22.628) AY14(-7.871,22.628) AY15(-8.621,22.628) AY16(-9.184,22.303) AY17(-9.86,22.628) AY18(-10.536,22.303) AY19(-11.211,22.628) AY21(-12.291,22.628) AY22(-12.966,22.303) AY23(-13.642,22.628) AY24(-14.318,22.303) AY25(-14.993,22.628) AY26(-15.669,22.303) AY27(-16.345,22.628) AY29(-17.424,22.628) AY30(-18.1,22.303) AY31(-18.775,22.628) AY33(-19.451,22.303) AY34(-20.024,22.628) AY35(-20.849,22.628) AY36(-21.599,22.628) AY37(-22.424,22.628) AY39(-23.173,22.628) AY40(-23.999,22.628) AY41(-24.748,22.628) AY42(-25.574,22.628) AY43(-26.323,22.628) AY44(-27.149,22.628) AY46(-27.898,22.628) AY47(-28.723,22.628) AY49(-29.473,22.628) AY50(-30.298,22.628) AY51(-30.98,22.303) AY52(-31.656,22.628) AY53(-32.331,22.303) AY54(-33.007,22.628) AY56(-34.087,22.628) AY57(-34.762,22.303) AY58(-35.438,22.628) B4(-1.922,0.65) B5(-3.138,0.643) B6(-4.119,0.643) B8(-4.891,0.643) B9(-5.716,0.643) B11(-6.697,0.643) B12(-7.469,0.643) B14(-8.294,0.643) B15(-9.275,0.643) B17(-10.047,0.643) B18(-10.872,0.643) B20(-11.853,0.643) B21(-12.272,1.196) B22(-12.625,0.643) B23(-13.451,0.643) B24(-14.023,0.975) B25(-14.714,0.65) B26(-15.277,0.975) B27(-15.84,0.65) B28(-16.531,0.975) B29(-17.221,0.65) B30(-17.785,0.975) B31(-18.348,0.65) B32(-19.038,0.975) B33(-19.729,0.65) B34(-20.292,0.975) B35(-20.855,0.65) B36(-21.546,0.975) B37(-22.236,0.65) B38(-22.8,0.975) B39(-23.363,0.65) B40(-24.053,0.975) B41(-24.744,0.65) B42(-25.307,0.975) B43(-25.87,0.65) B44(-26.561,0.975) B45(-27.251,0.65) B46(-27.815,0.975) B47(-28.378,0.65) B48(-29.068,0.975) B49(-29.759,0.65) B50(-30.322,0.975) B51(-30.885,0.65) B52(-31.576,0.975) B53(-32.266,0.65) B54(-32.83,0.975) B55(-33.393,0.65) B56(-34.083,0.975) B57(-34.774,0.65) B58(-35.337,0.975) B59(-35.9,0.65) B60(-36.665,0.66) C3(-1.302,1.302) C4(-2.118,1.272) C5(-2.772,1.196) C6(-3.776,1.196) C8(-4.538,1.196) C9(-5.351,1.196) C11(-6.354,1.196) C12(-7.116,1.196) C14(-7.929,1.196) C15(-8.932,1.196) C17(-9.694,1.196) C18(-10.507,1.196) C20(-11.51,1.196) C21(-11.891,1.786) C22(-12.678,1.786) C23(-13.085,1.196) C24(-14.051,2.032) C25(-14.714,1.3) C26(-15.277,1.626) C27(-15.84,1.3) C28(-16.558,2.032) C29(-17.221,1.3) C30(-17.785,1.626) C31(-18.348,1.3) C32(-19.066,2.032) C33(-19.729,1.3) C34(-20.292,1.626) C35(-20.855,1.3) C36(-21.573,2.032) C37(-22.236,1.3) C38(-22.8,1.626) C39(-23.363,1.3) C40(-24.081,2.032) C41(-24.744,1.3) C42(-25.307,1.626) C43(-25.87,1.3) C44(-26.588,2.032) C45(-27.251,1.3) C46(-27.815,1.626) C47(-28.378,1.3) C48(-29.07,2.032) C49(-29.759,1.3) C50(-30.322,1.626) C51(-30.885,1.3) C52(-31.578,1.991) C53(-32.266,1.3) C54(-32.83,1.626) C55(-33.393,1.3) C56(-34.085,1.991) C57(-34.774,1.3) C58(-35.337,1.626) C59(-35.9,1.3) C61(-37.003,1.237) D2(-0.65,2.075) D3(-1.3,2.037) D5(-2.678,1.842) D6(-3.369,1.786) D8(-4.157,1.786) D9(-4.944,1.786) D11(-5.852,1.786) D12(-6.735,1.786) D14(-7.522,1.786) D15(-8.43,1.786) D17(-9.313,1.786) D18(-10.1,1.786) D20(-11.008,1.786) D21(-12.235,2.423) D23(-13.377,1.786) D25(-14.714,1.951) D26(-15.277,2.276) D27(-15.84,1.951) D29(-17.221,1.951) D30(-17.785,2.276) D31(-18.348,1.951) D33(-19.729,1.951) D34(-20.292,2.276) D35(-20.855,1.951) D37(-22.236,1.951) D38(-22.8,2.276) D39(-23.363,1.951) D41(-24.744,1.951) D42(-25.307,2.276) D43(-25.87,1.951) D45(-27.251,1.951) D46(-27.815,2.276) D47(-28.378,1.951) D49(-29.759,1.951) D50(-30.322,2.276) D51(-30.885,1.951) D53(-32.266,1.951) D54(-32.83,2.276) D55(-33.393,1.951) D57(-34.774,1.951) D58(-35.337,2.276) D59(-35.9,1.951) D60(-36.678,1.801) D61(-37.328,1.801) D62(-37.978,2.035) E2(-0.65,2.725) E3(-1.3,2.687) E4(-1.951,2.687) E5(-2.602,2.619) E6(-3.554,2.619) E8(-4.507,2.619) E10(-5.459,2.619) E11(-6.412,2.619) E13(-7.364,2.619) E15(-8.317,2.619) E17(-9.269,2.619) E18(-10.222,2.619) E20(-11.174,2.619) E59(-36.027,2.647) E60(-36.678,2.647) E61(-37.328,2.647) E62(-37.978,2.685) F2(-0.65,3.474) F3(-1.3,3.512) F4(-1.951,3.512) F5(-2.602,3.269) F6(-3.554,3.269) F8(-4.507,3.269) F10(-5.459,3.269) F11(-6.412,3.269) F13(-7.364,3.269) F15(-8.317,3.269) F17(-9.269,3.269) F18(-10.222,3.269) F20(-11.174,3.269) F59(-36.027,3.472) F60(-36.678,3.472) F61(-37.328,3.472) F62(-37.978,3.434) F63(-38.628,3.434) G1(0,4.224) G2(-0.65,4.224) G3(-1.3,4.185) G4(-1.951,4.185) G5(-2.602,3.919) G6(-3.554,3.919) G8(-4.507,3.919) G10(-5.459,3.919) G11(-6.412,3.919) G13(-7.364,3.919) G15(-8.317,3.919) G17(-9.269,3.919) G18(-10.222,3.919) G20(-11.174,3.919) H5(-2.602,4.569) H6(-3.554,4.569) H8(-4.507,4.569) H10(-5.459,4.569) H11(-6.412,4.569) H13(-7.364,4.569) H15(-8.317,4.569) H17(-9.269,4.569) H18(-10.222,4.569) H20(-11.174,4.569) H59(-36.027,4.145) H60(-36.678,4.145) H61(-37.328,4.145) H62(-37.978,4.183) H63(-38.628,4.183) J1(0,4.973) J2(-0.65,4.973) J3(-1.3,5.011) J4(-1.951,5.011) J5(-2.627,5.22) J6(-3.567,5.22) J8(-4.507,5.22) J10(-5.459,5.22) J11(-6.412,5.22) J13(-7.364,5.22) J15(-8.317,5.22) J17(-9.269,5.22) J18(-10.222,5.22) J20(-11.174,5.22) J21(-12.095,4.986) J59(-36.027,4.971) J60(-36.678,4.971) J61(-37.328,4.971) J62(-37.978,4.933) J63(-38.628,4.933) K1(0,5.722) K2(-0.65,5.722) K3(-1.3,5.684) K4(-1.951,5.684) K59(-36.027,5.644) K60(-36.678,5.644) K61(-37.328,5.644) K62(-37.978,5.682) K63(-38.628,5.682) L1(0,6.471) L2(-0.65,6.471) L3(-1.3,6.51) L4(-1.951,6.51) L5(-2.637,6.338) L6(-3.287,6.338) L7(-3.937,6.338) L8(-4.587,6.338) L59(-36.027,6.469) L60(-36.678,6.469) L61(-37.328,6.469) L62(-37.978,6.431) L63(-38.628,6.431) N1(0,7.221) N2(-0.65,7.221) N3(-1.3,7.183) N4(-1.951,7.183) N5(-2.637,7.29) N6(-3.287,7.29) N7(-3.937,7.29) N8(-4.587,7.29) N59(-36.027,7.142) N60(-36.678,7.142) N61(-37.328,7.142) N62(-37.978,7.181) N63(-38.628,7.181) P1(0,7.97) P2(-0.65,7.97) P3(-1.3,8.008) P4(-1.951,8.008) P59(-36.027,7.968) P60(-36.678,7.968) P61(-37.328,7.968) P62(-37.978,7.93) P63(-38.628,7.93) R5(-2.637,8.243) R6(-3.287,8.243) R7(-3.937,8.243) R8(-4.587,8.243) T1(0,8.719) T2(-0.65,8.719) T3(-1.3,8.681) T4(-1.951,8.681) T59(-36.027,8.641) T60(-36.678,8.641) T61(-37.328,8.641) T62(-37.978,8.679) T63(-38.628,8.679) U1(0,9.469) U2(-0.65,9.469) U3(-1.3,9.507) U4(-1.951,9.507) U5(-2.637,9.195) U6(-3.287,9.195) U7(-3.937,9.195) U8(-4.587,9.195) U59(-36.027,9.467) U60(-36.678,9.467) U61(-37.328,9.467) U62(-37.978,9.428) U63(-38.628,9.428) V1(0,10.218) V2(-0.65,10.218) V3(-1.3,10.18) V4(-1.951,10.18) V5(-2.637,10.148) V6(-3.287,10.148) V7(-3.937,10.148) V8(-4.587,10.148) V59(-36.027,10.14) V60(-36.678,10.14) V61(-37.328,10.14) V62(-37.978,10.178) V63(-38.628,10.178) Y1(0,10.967) Y2(-0.65,10.967) Y3(-1.3,11.005) Y4(-1.951,11.005) Y5(-2.637,11.1) Y6(-3.287,11.1) Y7(-3.937,11.1) Y8(-4.587,11.1) Y59(-36.027,10.965) Y60(-36.678,10.965) Y61(-37.328,10.965) Y62(-37.978,10.927) Y63(-38.628,10.927)
  round 0.33 smd: AK22(-12.655,16.266) AK23(-13.529,16.266) AK25(-14.504,16.266) AK26(-15.456,16.266) AK28(-16.409,16.266) AK29(-17.311,16.266) AK32(-18.824,16.266) AK33(-19.726,16.266) AK35(-20.729,16.266) AK36(-21.58,16.266) AK38(-22.609,16.266) AK40(-24.106,16.266) AK42(-24.944,16.266) AK43(-25.897,16.266) AK45(-26.874,16.266) AK46(-27.776,16.266) AK48(-28.83,16.266) AK49(-29.732,16.266) AK51(-30.735,16.266) AK52(-31.583,16.266) AK54(-32.61,16.266) AK55(-33.562,16.266) AK57(-34.509,16.266) AK58(-35.408,16.266)
