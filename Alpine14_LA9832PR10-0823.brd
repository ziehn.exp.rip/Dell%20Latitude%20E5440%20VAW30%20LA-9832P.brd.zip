# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_GLANTX_N3_C: length 3
  TOP w0.102: U21.39 175.05,140.04 174.95,140.13 174.6,140.13 174.34,140.39 174.32,140.39 173.99,140.72 173.99,140.74 173.85,140.88 173.59,140.88 C176.1
PCIE_PRX_GLANTX_P3: length 127.1
  TOP w0.102: C179.2 172.1,141.19 171.79,141.19 171.67,141.07 v2(171.31,141.07)
  IN1 w0.076: 108.6,66.08 108.6,66.07 108.6,66.06 108.6,66.05 108.55,66 108.55,65.99 107.89,65.32 107.89,62.04 108.29,61.64 108.29,60.98 108.44,60.83 108.44,60.79 108.45,60.79 109.61,60.79 109.74,60.66 109.74,60.51 109.63,60.4 v2(109.48,60.4)
  IN1 w0.097: 108.6,66.08 109.49,66.97 109.49,72.02 112.11,74.64 112.11,75.27 111.81,75.56 111.81,80.02 112.48,80.68 113.24,80.68 114.15,81.59 117.79,81.59 119.75,83.56 123.35,83.56 124.56,84.76 125.2,84.76 132.37,91.94 132.37,98.15 133.59,99.36 134.67,99.36 136.08,100.77 136.08,103.57 136.35,103.84 136.35,106.46 136.92,107.03 136.92,109.51 136.24,110.19 136.24,116.58 137.01,117.34 138.11,117.34 138.64,117.87 138.64,118.4 140.51,120.27 141.3,120.27 143.8,122.78 145.87,122.78 146.78,123.68 146.78,124.23 147.61,125.07 148.1,125.07 157.52,134.49 157.52,138.36 159.42,140.26 160.63,140.26 162.72,142.36 168.99,142.36 170.49,140.86 171.11,140.86 v2(171.31,141.07)
  BOTTOM w0.089: v2(109.48,60.4) 109.8,60.72 UC1.F11
PCIE_PRX_GLANTX_P3_C: length 3
  TOP w0.102: U21.38 175.05,140.44 174.95,140.35 174.69,140.35 174.38,140.66 v3(174.33,140.71) 173.94,141.09 173.59,141.09 C179.1
PCIE_PRX_MMITX_N1: length 140.7
  IN1 w0.097: v2(11.11,21.91) 11.27,21.75 11.27,20.97 11.76,20.48 18.1,20.48 23.24,25.62 23.24,34.96 25.9,37.62 25.9,42.77 29.5,46.37 29.5,48.44 32.99,51.93 32.99,58.22 34.85,60.07 34.85,61.12 34.77,61.2 v2(34.77,62.76)
  IN3 w0.076: 107.21,56.53 107.62,56.94 109.96,56.94 110.09,57.07 110.09,57.4 110.22,57.52 v2(110.22,57.52)
  IN3 w0.102: v2(34.77,62.76) 34.77,63.44 34.92,63.59 37.21,63.59 39.1,65.49 71.91,65.49 73.16,64.23 76.33,64.23 77.81,62.74 79.08,62.74 82.82,59.01 83.78,59.01 85.15,57.64 91.93,57.64 92.58,56.99 100.84,56.99 102.14,55.68 106.37,55.68 107.21,56.53
  BOTTOM w0.076: UC1.G17 110.45,57.76 v2(110.22,57.52)
  BOTTOM w0.102: C238.1 11.29,22.25 11.29,22.09 v2(11.11,21.91)
PCIE_PRX_MMITX_N1_C: length 2.3
  BOTTOM w0.102: C238.2 11.29,23.83 11.29,24.26 11.66,24.63 11.66,24.79 11.56,24.89 U27.8
PCIE_PRX_MMITX_P1: length 140.7
  IN1 w0.097: v2(11.69,21.91) 11.48,21.69 11.48,21.06 11.85,20.69 18.01,20.69 23.02,25.71 23.02,35.04 25.69,37.71 25.69,42.85 29.29,46.45 29.29,48.53 32.78,52.02 32.78,58.31 34.64,60.16 34.64,61.03 34.56,61.11 34.56,62.38 v2(34.18,62.76)
  IN3 w0.076: 107.06,56.68 107.48,57.1 109.9,57.1 109.93,57.14 109.93,57.32 109.72,57.52 v2(109.48,57.52)
  IN3 w0.102: v2(34.18,62.76) 34.55,63.13 34.55,63.53 34.84,63.81 37.12,63.81 39.01,65.7 72,65.7 73.25,64.44 76.42,64.44 77.9,62.96 79.17,62.96 82.9,59.22 83.87,59.22 85.24,57.85 92.02,57.85 92.67,57.2 100.93,57.2 102.26,55.87 106.25,55.87 107.06,56.68
  BOTTOM w0.076: UC1.F17 109.8,57.85 v2(109.48,57.52)
  BOTTOM w0.102: C237.1 11.51,22.24 11.51,22.1 v2(11.69,21.91)
PCIE_PRX_MMITX_P1_C: length 2.3
  BOTTOM w0.102: U27.7 11.96,24.89 11.87,24.79 11.87,24.54 11.51,24.17 11.51,23.84 C237.2
PCIE_PRX_WLANTX_N4: length 258.4
  IN1 w0.076: v2(109.43,59.43) 109.63,59.62 109.63,59.72 109.46,59.88 108.5,59.88 108.42,59.96 108.41,59.96 108.37,60 108.35,60 108.35,60
  IN1 w0.097: 108.35,60 107.21,61.15 107.21,66.07 108.41,67.28 108.41,73.12 109.43,74.14 110.63,74.14 111.04,74.55 111.04,75.11 110.51,75.65 110.51,79.77 112.1,81.37 112.95,81.37 113.95,82.37 117.29,82.37 119.58,84.66 122.99,84.66 123.86,85.53 124.81,85.53 131.69,92.4 131.69,97.91 131.56,98.04 131.56,101.4 133.49,103.33 133.49,107.86 133.61,107.97 133.61,112.77 134.07,113.23 134.07,116.94 136,118.88 136,119.6 137.44,121.04 138.15,121.04 141.84,124.72 143.42,124.72 145.5,126.81 146.88,126.81 154.72,134.66 154.72,139.06 156.42,140.75 156.42,142.34 157.33,143.25 163.89,143.25 167.42,146.78 173.84,146.78 179.25,152.19 190.31,152.19 191.79,153.66 195.81,153.66 199.23,157.08 200.46,157.08 201.69,158.32 228.52,158.32 231.61,161.41 237.87,161.41 239.07,162.61 245.85,162.61 246.42,163.19 253.58,163.19 253.59,163.2 260.01,163.2 264.4,158.8 266.55,158.8 268.07,157.28 274.23,157.28 276.52,154.99 286.25,154.99 286.61,155.36 286.61,155.48 v2(286.41,155.69)
  BOTTOM w0.076: v2(109.43,59.43) 109.8,59.8 UC1.F13
  BOTTOM w0.102: v2(286.41,155.69) 286.55,155.83 286.55,155.97 286.26,156.27 JMINI1.23
PCIE_PRX_WLANTX_P4: length 258.4
  IN1 w0.076: v2(110.05,59.43) 109.79,59.69 109.79,59.78 109.53,60.04 108.56,60.04 108.48,60.13
  IN1 w0.097: v2(286.99,155.69) 286.82,155.52 286.82,155.27 286.34,154.78 276.43,154.78 274.14,157.07 267.98,157.07 266.46,158.59 264.31,158.59 259.92,162.99 253.68,162.99 253.67,162.98 246.5,162.98 245.93,162.4 239.16,162.4 237.95,161.2 231.7,161.2 228.61,158.11 201.78,158.11 200.54,156.87 199.32,156.87 195.9,153.45 191.87,153.45 190.4,151.98 179.34,151.98 173.93,146.57 167.51,146.57 163.97,143.04 157.41,143.04 156.63,142.25 156.63,140.66 154.93,138.97 154.93,134.57 146.96,126.6 145.59,126.6 143.5,124.51 141.92,124.51 138.24,120.83 137.53,120.83 136.22,119.52 136.22,118.79 134.28,116.85 134.28,113.14 133.82,112.68 133.82,107.88 133.7,107.77 133.7,103.24 131.77,101.31 131.77,98.13 131.9,98 131.9,92.31 124.9,85.31 123.95,85.31 123.08,84.45 119.67,84.45 117.38,82.16 114.04,82.16 113.04,81.16 112.19,81.16 110.72,79.68 110.72,75.73 111.25,75.2 111.25,74.46 110.72,73.93 109.52,73.93 108.62,73.04 108.62,67.19 107.42,65.99 107.42,61.19 108.48,60.13
  BOTTOM w0.089: UC1.G13 110.45,59.83 v2(110.05,59.43)
  BOTTOM w0.102: JMINI1.25 287.06,156.27 286.77,155.97 286.77,155.91 v2(286.99,155.69)
PCIE_PTX_EXPRX_N: length 36.1
  IN1 w0.097: v2(118.21,12.88) 118.21,12.95 117.85,13.31 117.41,13.31 116.33,12.23 113.31,12.23 111.02,14.52 103.04,14.52 102.22,15.34 102.22,16.89 101.57,17.53 101.57,17.7 99.46,19.82 95.32,19.82 93.68,21.45 91.38,21.45 91.14,21.21 91.14,20.99 v2(91.47,20.66)
  BOTTOM w0.102: R99.1 117.72,12.88 v2(118.21,12.88) 118.71,12.88 R93.1 ; v2(91.47,20.66) 91.32,20.51 91.32,19.9 C647.1
PCIE_PTX_EXPRX_N_C: length 2
  TOP w0.102: JEXP1.28 91.56,17.87 v2(91.47,17.78)
  BOTTOM w0.102: C647.2 91.73,18.04 v2(91.47,17.78)
PCIE_PTX_EXPRX_N_M: length 186.8
  TOP w0.102: U91.23 164.42,137.06 164.56,137.2 169.42,137.2 171.61,135 171.61,131.32 172.52,130.42 175.02,130.42 175.27,130.17 175.94,130.17 v2(176.12,129.98)
  IN3 w0.102: v2(176.12,129.98) 176.49,130.35 176.8,130.35 177.38,129.77 177.38,128.68 178.47,127.58 178.47,125.65 179.8,124.32 179.8,120.26 184.52,115.54 184.52,113.52 185.66,112.38 185.66,110.1 186.46,109.3 186.46,104.97 185.3,103.81 185.3,94.13 180.8,89.62 178.92,89.62 175.65,86.36 173.82,86.36 173.26,85.8 173.26,85.65 171.4,83.78 171.4,81.92 169.49,80.01 166.15,80.01 165.76,79.62 161.74,79.62 161.17,79.06 161.17,77.02 162.02,76.17 162.02,76.08 v2(161.79,75.84)
  BOTTOM w0.102: v2(161.79,75.84) 161.99,76.04 161.99,76.12 161.83,76.28 158.91,76.28 158.63,76 155.38,76 152.21,72.82 152.21,65.8 154.32,63.69 154.32,39.98 135.99,21.65 129.6,21.65 127.39,19.44 127.39,17.63 126.61,16.84 v3(125.09,16.84) 124.61,16.84 120.95,13.19 119.71,13.19 119.57,13.05 119.57,12.93 R93.2
PCIE_PTX_EXPRX_P: length 36.1
  IN1 w0.097: v2(118.21,13.52) 117.32,13.52 116.24,12.44 113.4,12.44 111.11,14.73 103.13,14.73 102.43,15.43 102.43,16.97 101.78,17.62 101.78,17.79 99.54,20.03 95.4,20.03 93.77,21.66 91.29,21.66 90.93,21.3 90.93,20.7 v2(90.89,20.66)
  BOTTOM w0.102: R98.1 117.72,13.52 v2(118.21,13.52) 118.71,13.52 R71.1 ; C648.1 91.11,19.77 91.11,20.43 v2(90.89,20.66)
PCIE_PTX_EXPRX_P_C: length 1.9
  TOP w0.102: JEXP1.30 91.06,17.95 v2(90.89,17.78)
  BOTTOM w0.102: v2(90.89,17.78) 90.84,17.83 C648.2
PCIE_PTX_EXPRX_P_M: length 186.8
  TOP w0.102: U91.24 164.42,137.56 164.56,137.42 169.51,137.42 171.83,135.09 171.83,131.41 172.6,130.64 175.11,130.64 175.36,130.38 175.94,130.38 v2(176.12,130.57)
  IN3 w0.102: v2(162.37,75.84) 162.24,75.98 162.24,76.26 161.39,77.11 161.39,78.97 161.83,79.4 165.85,79.4 166.24,79.8 169.58,79.8 171.61,81.83 171.61,83.69 173.48,85.56 173.48,85.71 173.91,86.14 175.74,86.14 179.01,89.41 180.88,89.41 185.52,94.04 185.52,103.72 186.68,104.88 186.68,109.39 185.88,110.19 185.88,112.47 184.73,113.61 184.73,115.63 180.02,120.35 180.02,124.41 178.69,125.74 178.69,127.67 177.59,128.77 177.59,129.86 176.89,130.57 v2(176.12,130.57)
  BOTTOM w0.102: v2(162.37,75.84) 162.2,76.02 162.2,76.21 161.92,76.49 158.82,76.49 158.54,76.21 155.29,76.21 151.99,72.91 151.99,65.71 154.1,63.6 154.1,40.07 135.9,21.87 129.51,21.87 127.18,19.53 127.18,17.72 126.52,17.06 125.37,17.06 125.36,17.07 124.83,17.07 124.82,17.06 124.52,17.06 120.87,13.4 119.99,13.4 R71.2
PCIE_PTX_GLANRX_N3: length 154.4
  TOP w0.102: v2(171.62,138.85) 171.8,139.04 172,139.04 C181.1
  IN1 w0.097: v2(102.67,50.47) 102.36,50.78 102.36,54.73 99.8,57.29 99.8,65.76 98.89,66.67 98.89,69.37 97.67,70.59 97.67,78.18 97.43,78.42 97.43,82.83 100.05,85.44 100.05,86.48 100.91,87.34 103.33,87.34 105.06,89.07 107.23,89.07 108.57,90.41 114.76,90.41 116.25,91.9 120.81,91.9 121.39,92.48 121.39,97.59 125.34,101.55 125.34,108.45 127.04,110.14 127.04,119.91 128.19,121.07 128.19,123.21 132.43,127.45 132.43,128.06 135.83,131.46 137.11,131.46 139.47,133.81 140.06,133.81 141.55,135.29 142.44,135.29 v2(142.71,135.02)
  BOTTOM w0.076: UC1.C29 107.66,49.99 107.38,49.71 v3(103.36,49.71) 102.62,49.71 102.47,49.86 102.47,50.28 v2(102.67,50.47)
  BOTTOM w0.102: v2(142.71,135.02) 142.71,135.03 142.96,135.28 147.1,135.28 148.88,137.06 160.72,137.06 160.98,137.33 164.3,137.33 166,139.03 171.44,139.03 v2(171.62,138.85)
PCIE_PTX_GLANRX_N3_C: length 2.7
  TOP w0.102: U21.42 175.05,138.84 174.95,138.93 174.69,138.93 174.6,139.02 174.04,139.02 174.03,139.03 173.58,139.03 C181.2
PCIE_PTX_GLANRX_P3: length 154.5
  TOP w0.102: C178.1 172,139.25 171.8,139.25 v2(171.62,139.44)
  IN1 w0.097: v2(142.71,135.6) 142.61,135.5 141.46,135.5 139.98,134.02 139.38,134.02 137.03,131.67 135.75,131.67 132.22,128.15 132.22,127.54 127.98,123.29 127.98,121.15 126.82,120 126.82,110.23 125.13,108.53 125.13,101.63 121.18,97.68 121.18,92.57 120.72,92.11 116.16,92.11 114.67,90.62 108.49,90.62 107.14,89.28 104.97,89.28 103.24,87.55 100.83,87.55 99.84,86.57 99.84,85.53 97.22,82.91 97.22,78.33 97.46,78.09 97.46,70.51 98.68,69.29 98.68,66.58 99.59,65.68 99.59,57.21 102.15,54.64 102.15,50.54 v2(102.09,50.47)
  BOTTOM w0.076: v2(102.09,50.47) 102.24,50.32 102.28,50.28 102.28,49.78 102.54,49.52 107.42,49.52 UC1.B30
  BOTTOM w0.102: v2(171.62,139.44) 171.42,139.25 165.91,139.25 164.21,137.54 160.89,137.54 160.63,137.28 148.79,137.28 147.01,135.5 142.81,135.5 v2(142.71,135.6)
PCIE_PTX_GLANRX_P3_C: length 2.7
  TOP w0.102: C178.2 173.6,139.25 v3(174.32,139.25) 174.68,139.25 174.78,139.15 174.95,139.15 175.05,139.24 U21.41
PCIE_PTX_MMIRX_N1: length 138.6
  IN1 w0.097: v2(13.47,21.96) 13.22,21.71 13.22,21.65 13.48,21.39 17.69,21.39 18.58,22.28 18.58,23.8 22.33,27.55 22.33,35.42 24.97,38.07 24.97,43.15 28.53,46.71 28.53,48.78 32.08,52.34 32.08,58.58 33.04,59.54 33.04,59.77 33.55,60.28 33.55,60.78 v2(33.54,60.79)
  IN3 w0.102: v2(102.13,47.62) 102.31,47.62 102.44,47.49 102.44,47.01 102.37,46.94 100.11,46.94 99.06,48 95.76,48 95.43,48.33 95.43,50.92 93.49,52.85 91.11,52.85 87.51,56.44 84.62,56.44 83.26,57.8 82.32,57.8 78.59,61.54 77.32,61.54 75.81,63.05 72.55,63.05 71.44,64.16 39.57,64.16 36.19,60.79 34.11,60.79 34.11,60.78 33.54,60.78 v2(33.54,60.79)
  BOTTOM w0.076: UC1.C30 107.48,49.01 107.48,48.75 107.34,48.6 107.23,48.57 107.1,48.57 107.04,48.6 107.03,48.61 106.95,48.63 106.73,48.63 106.58,48.56 103.67,48.56 103.3,48.19 102.59,48.19 102.34,47.93 102.34,47.79 102.16,47.62 v2(102.13,47.62)
  BOTTOM w0.102: C236.1 13.61,22.58 13.27,22.24 13.27,22.17 v2(13.47,21.96)
PCIE_PTX_MMIRX_N1_C: length 2.4
  BOTTOM w0.102: C236.2 13.29,23.84 13.29,24.04 12.67,24.66 12.67,24.97 12.76,25.06 U27.5
PCIE_PTX_MMIRX_P1: length 138.6
  IN1 w0.097: v2(33.95,60.38) 33.94,60.38 33.25,59.68 33.25,59.45 32.3,58.5 32.3,52.25 28.74,48.7 28.74,46.62 25.18,43.06 25.18,37.98 22.54,35.34 22.54,27.46 18.79,23.72 18.79,22.19 17.78,21.18 13.39,21.18 12.99,21.58 12.99,21.86 v2(12.89,21.96)
  IN3 w0.102: v2(33.95,60.38) 33.95,60.38 34.13,60.57 34.2,60.57 34.2,60.57 36.28,60.57 39.66,63.95 71.35,63.95 72.46,62.83 75.72,62.83 77.23,61.32 78.5,61.32 82.23,57.59 83.17,57.59 84.53,56.23 87.43,56.23 91.02,52.63 93.4,52.63 95.21,50.83 95.21,48.24 95.67,47.78 98.97,47.78 100.02,46.73 102.46,46.73 102.62,46.89 102.62,47.34 v2(102.84,47.55)
  BOTTOM w0.076: v2(102.84,47.55) 102.78,47.49 102.59,47.49 102.5,47.58 102.5,47.87 102.66,48.03 103.37,48.03 103.71,48.37 103.99,48.37 104.11,48.25 104.37,48.25 104.49,48.37 104.88,48.37 105,48.25 105.33,48.25 105.45,48.37 105.7,48.37 105.82,48.25 106.15,48.25 106.27,48.37 106.54,48.37 106.81,48.47 106.92,48.47 106.99,48.44 107.04,48.42 107.07,48.41 107.26,48.41 107.41,48.45 107.56,48.55 107.61,48.6 107.64,48.64 107.64,48.84 107.69,48.89 107.82,48.89 UC1.C31
  BOTTOM w0.102: C235.1 12.75,22.58 13.05,22.28 13.05,22.09 12.93,21.96 v2(12.89,21.96)
PCIE_PTX_MMIRX_P1_C: length 2.4
  BOTTOM w0.102: C235.2 13.07,23.84 13.07,23.95 12.46,24.57 12.46,24.97 12.36,25.06 U27.6
PCIE_PTX_WLANRX_N4: length 296.2
  IN1 w0.097: v2(287,159.13) 287,158.64 286.98,158.62 286.98,158.15 286.63,157.8 276.78,157.8 274.97,159.61 269.57,159.61 267.72,161.46 266.27,161.46 262,165.73 249.17,165.73 248.51,165.07 238.85,165.07 237.14,163.36 229.83,163.36 226.67,160.2 200.93,160.2 199.79,159.06 198.22,159.06 195.28,156.12 192.97,156.12 192.68,155.82 189.58,155.82 187.93,154.17 172.44,154.17 171.74,154.87 171.74,156.5 167.85,160.39 158.98,160.39 158.22,159.63 158.22,158.61 156.46,156.86 156.46,155.4 155.97,154.91 155.42,154.91 153.6,153.09 153.6,147.83 152.87,147.1 152.1,147.1 149.6,144.6 149.6,140.42 144.51,135.33 144.01,135.33 142.97,134.29 141.58,134.29 138.83,131.54 138.17,131.54 137.4,130.77 136.28,130.77 133.27,127.77 133.27,127.22 130.91,124.86 130.91,123.83 129.3,122.22 129.3,121.2 127.74,119.64 127.74,116.39 127.72,116.38 127.72,108.37 126.04,106.69 126.04,101 122.11,97.07 122.11,92.22 121.03,91.13 116.52,91.13 115.02,89.64 108.85,89.64 107.6,88.38 106.21,88.38 104.24,86.41 102.4,86.41 99.25,83.27 99.25,82.23 98.57,81.55 98.57,78.04 98.36,77.84 98.36,70.88 99.69,69.55 99.69,66.88 100.49,66.08 100.49,57.59 103.05,55.03 103.05,51.71 103.43,51.32 104.2,51.32 104.49,51.03 104.49,50.66 v2(104.67,50.47)
  BOTTOM w0.076: UC1.B29 107.1,49.99 106.63,50.47 106.06,50.47 105.65,50.06 104.56,50.06 104.49,50.13 104.49,50.36 104.61,50.47 v2(104.67,50.47)
  BOTTOM w0.102: v2(287,159.13) 286.75,159.13 286.57,159.31 286.57,159.58 286.81,159.81 287.9,159.81 287.95,159.76 287.95,159.5 287.76,159.31 C242.1
PCIE_PTX_WLANRX_N4_C: length 4
  BOTTOM w0.102: C242.2 288.66,159.64 288.82,159.81 289.23,159.81 289.56,159.47 289.56,158.6 289.76,158.4 289.76,158.16 289.46,157.86 JMINI1.31
PCIE_PTX_WLANRX_P4: length 296.1
  IN1 w0.097: v2(286.58,158.71) 286.77,158.53 286.77,158.24 286.54,158.01 276.86,158.01 275.06,159.82 269.66,159.82 267.81,161.67 266.36,161.67 262.09,165.94 249.08,165.94 248.43,165.28 238.77,165.28 237.05,163.57 229.74,163.57 226.58,160.41 200.84,160.41 199.7,159.27 198.13,159.27 195.19,156.33 192.89,156.33 192.59,156.03 189.5,156.03 187.85,154.38 172.53,154.38 171.95,154.95 171.95,156.58 167.93,160.6 158.89,160.6 158.01,159.72 158.01,158.7 156.25,156.94 156.25,155.48 155.89,155.12 155.33,155.12 153.39,153.18 153.39,147.92 152.79,147.31 152.01,147.31 149.39,144.69 149.39,140.51 144.42,135.54 143.92,135.54 142.88,134.5 141.49,134.5 138.74,131.75 138.09,131.75 137.31,130.98 136.19,130.98 133.06,127.85 133.06,127.31 130.7,124.94 130.7,123.92 129.09,122.31 129.09,121.29 127.53,119.72 127.53,116.48 127.51,116.47 127.51,108.46 125.83,106.78 125.83,101.09 121.9,97.16 121.9,92.3 120.94,91.34 116.43,91.34 114.94,89.85 108.77,89.85 107.51,88.59 106.12,88.59 104.15,86.63 102.31,86.63 99.04,83.36 99.04,82.32 98.36,81.63 98.36,78.13 98.15,77.93 98.15,70.79 99.48,69.47 99.48,66.79 100.28,65.99 100.28,57.5 102.84,54.95 102.84,51.62 103.35,51.11 104.11,51.11 104.3,50.92 104.3,50.47 104.2,50.37 103.99,50.37 v2(103.89,50.47)
  BOTTOM w0.076: v2(103.89,50.47) 104.08,50.47 104.33,50.22 104.33,50.06 104.49,49.9 105.76,49.9 106.14,50.28 106.53,50.28 106.6,50.2 106.6,50.06 UC1.A29
  BOTTOM w0.102: v2(286.58,158.71) 286.58,158.99 286.36,159.22 286.36,159.67 286.72,160.02 287.5,160.02 C243.1
PCIE_PTX_WLANRX_P4_C: length 4
  BOTTOM w0.102: C243.2 288.9,160.02 289.32,160.02 289.79,159.55 v3(289.79,159.16) 289.79,158.67 289.98,158.49 289.98,158.14 290.26,157.86 JMINI1.33
PCIE_WAKE#: length 363.5
  TOP w0.102: R340.2 v2(149.02,111.24) ; v2(90.46,17.07) 88.94,17.07 88.37,17.64 88.37,18.15 88.5,18.29 JEXP1.40 ; v2(147.33,107.17) 147.8,107.17 147.93,107.3 147.93,107.76 147.64,108.04 U38.B38 ; v2(159.46,85.85) 159.22,85.61 159.22,85.06 159.48,84.79 161.78,84.79 162.83,83.75 v1(163.44,83.75) v2(164.57,83.75)
  IN1 w0.097: v2(276.14,152.77) 275.25,151.88 272.77,151.88 269.72,154.93 267.31,154.93 266.93,155.31 264.93,155.31 259.05,161.19 253.78,161.19 253.18,160.59 245.05,160.59 244.29,159.83 243.8,159.83 241.61,157.64 237.88,157.64 234.8,154.55 229.46,149.22 228.01,149.22 227.42,148.62 224.71,148.62 219.59,143.5 217.59,143.5 213.59,139.5 213.59,137.21 211.56,135.18 211.56,132.83 209.42,130.7 v2(206.79,130.7) 201.78,130.7 200.77,129.68 189.19,129.68 185.36,125.85 181.9,125.85 181.52,125.47 176.69,125.47 174.7,123.47 166.88,123.47 165.31,121.91 159.23,121.91 158.41,121.09 156.82,121.09 156.06,121.85 154.41,121.85 153.96,121.4 153.96,118.62 152.11,116.77 147.74,116.77 147.48,116.51 147.48,115.75 148.48,114.76 148.48,112.54 149.05,111.96 149.05,111.27 v2(149.02,111.24) 148.57,110.8 148.57,108.21 147.54,107.17 v2(147.33,107.17)
  IN2 w0.102: v2(164.57,83.75) 164.17,83.75 162.72,82.3 162.72,81.36 160.92,79.56 160.92,76.36 159.74,75.18 159.74,72.77 161.4,71.11 161.4,67.69 157.8,64.09 157.8,50.88 156.65,49.74 156.65,18.88 151.18,13.4 130.96,13.4 128.82,15.55 122.31,15.55 121.3,14.53 115.23,14.53 114.63,13.94 113.09,13.94 112.5,14.53 103.7,14.53 102.75,13.58 98.34,13.58 95.35,16.56 90.97,16.56 v2(90.46,17.07)
  IN3 w0.102: v2(159.46,85.85) 159.46,86.17 158.97,86.66 158.97,88.03 155.49,91.51 155.49,94.85 154.41,95.93 154.41,106.71 153.29,107.83 153.29,109.47 152.08,110.67 149.52,110.67 149.02,111.17 v2(149.02,111.24)
  BOTTOM w0.102: JMINI2.1 208.39,129.1 v2(206.79,130.7) ; JMINI1.1 274.26,156.17 276.14,154.3 v2(276.14,152.77)
PD#B: length 2.2
  TOP w0.102: R2626.1 300.7,165.69 U83.5
PE_REXT: length 3.7
  BOTTOM w0.102: v1(15.46,22.95) 14.91,23.5 R205.2 13.16,24.85 U27.4
PE_RST#: length 13.1
  IN2 w0.102: v2(4.57,33.95) 5.94,32.57 5.94,28.79 v2(7.77,26.97)
  BOTTOM w0.102: R443.2 4.79,34.16 v2(4.57,33.95) 4.07,33.44 3.96,33.44 R27.1 3.45,33.44 3.17,33.16 v1(3.17,32.49) ; U27.15 7.92,27.11 v2(7.77,26.97)
PECI_EC: length 204.8
  TOP w0.102: R375.2 135.61,114.86 v2(135.67,114.93)
  IN1 w0.097: v2(109.26,120.59) 109.18,120.59 107.9,119.31 107.21,119.31 106.62,118.71 92.53,118.71 89.13,115.31 89.13,111.09 89.99,110.23 89.99,91.44 85.9,87.35 85.9,85.63 84.17,83.91 84.17,82.01 83.41,81.24 83.41,73.28 84.04,72.64 84.04,67.23 86.28,64.99 86.28,60.18 86.66,59.8 86.66,57.88 87.58,56.96 87.58,43.28 89.4,41.46 92.27,41.46 92.69,41.88 93.49,41.88 95.18,40.19 95.18,32.84 94.81,32.47 94.81,30.36 94.36,29.91 94.36,28.5 94.2,28.35 92.98,28.35 92.44,27.8 91.41,27.8 91.1,27.49 91.1,26.74 87.92,23.57 87.92,21.9 88.05,21.77 88.05,18.6 87.96,18.51 87.96,17.36 88.92,16.4 v2(89,16.4)
  IN3 w0.102: v2(89,16.4) 91.19,16.4 92.07,17.29 98.36,17.29 101.13,20.06 101.59,20.06 101.76,20.23 107.04,20.23 109.41,22.6 111.73,22.6 113.15,24.01 114.8,24.01 v2(115.1,24.31)
  BOTTOM w0.076: UC1.N62 114,28.96 114,28.63 114.92,27.7 114.92,25.9
  BOTTOM w0.102: v2(109.26,120.59) 109.4,120.45 110.96,120.45 112.93,118.48 119.37,118.48 119.71,118.14 121.48,118.14 123.76,120.43 126.97,120.43 127.49,119.9 129.8,119.9 130.3,119.41 133.33,119.41 136.11,116.63 136.11,115.36 v2(135.67,114.93) ; v2(115.1,24.31) 114.92,24.49 114.92,25.9
PECI_EC_R: length 11.1
  TOP w0.102: U38.A48 141.39,109.97 141.26,110.1 141.09,110.1 140.67,109.69 140.5,109.69 140.34,109.85 140.34,110.03 140.7,110.39 140.7,110.55 140.58,110.67 140.41,110.67 140.04,110.31 139.88,110.31 139.76,110.43 139.76,110.6 140.12,110.96 140.12,111.13 140,111.25 139.83,111.25 139.46,110.88 139.31,110.88 139.05,111.13 138.88,111.31 137.9,111.31 v1(136.87,112.33) 136.5,112.7 C395.1 R375.1
PEG_A_CLKRQ#: length 47.5
  TOP w0.102: v2(107.72,85.14) 108.29,85.14 RC162.2 ; QC11.3 70.05,80.93 69.89,80.76 69.89,78.82 69.18,78.11 v1(69.18,77.56) 69.18,77.47 69.63,77.02 70.21,77.02 71.86,78.67 72.49,78.67 73.51,79.68 v2(74.97,79.68)
  IN3 w0.102: v2(74.97,79.68) 75.86,80.57 77.89,80.57 78.84,81.53 81.44,81.53 83.36,83.44 89.98,83.44 90.74,84.2 97.4,84.2 97.88,84.69 107.27,84.69 v2(107.72,85.14)
PEG_EXP: length 84.7
  IN1 w0.097: v2(101.23,39.84) 101.03,39.65 99.91,39.65 99.43,39.17 99.43,31.7 101.47,29.65 106.26,29.65 108.7,32.1 111.13,32.1 111.87,31.36 111.87,27.29 113.13,26.04 113.13,21.35 114.32,20.15 114.32,18.98 116.29,17.01 119.68,17.01 121.39,15.3 126.99,15.3 130.63,11.66 130.63,9.26 132.16,7.73 132.16,4.96 131.4,4.2 123.86,4.2 123.35,3.69 121.68,3.69 v2(121.49,3.89)
  BOTTOM w0.076: UC1.C42 107.72,41.64 107.54,41.46 107.54,41.29 107.34,41.08 107.23,41.05 107.1,41.05 107.04,41.07 107.03,41.09 106.95,41.11 106.73,41.11 106.61,41.05 106.33,41.05 106.24,40.97 106.19,40.97 106.11,40.88 104.61,40.88 104.29,40.56 102.83,40.56 101.92,39.65 101.42,39.65 v2(101.23,39.84)
  BOTTOM w0.102: v2(121.49,3.89) 121.31,3.71 120.9,3.71 RC184.1
PEG_EXP#: length 84.2
  IN1 w0.097: v2(121.49,3.3) 121.65,3.47 123.44,3.47 123.95,3.98 131.49,3.98 132.38,4.86 132.38,7.82 130.85,9.35 130.85,11.75 127.08,15.53 121.48,15.53 119.78,17.23 116.39,17.23 114.55,19.07 114.55,20.25 113.35,21.44 113.35,26.13 112.1,27.39 112.1,31.45 111.22,32.32 108.61,32.32 106.16,29.88 101.57,29.88 99.66,31.79 99.66,39.08 100,39.43 101.06,39.43 v2(101.23,39.26)
  BOTTOM w0.076: UC1.C43 107.45,40.95 107.41,40.93 107.26,40.89 107.07,40.89 107.04,40.9 106.92,40.95 106.81,40.95 106.64,40.89 106.59,40.89 106.58,40.87 106.56,40.89 106.39,40.89 106.36,40.86 106.36,40.85 106.19,40.68 104.69,40.68 104.37,40.36 102.92,40.36 102,39.45 101.42,39.45 v2(101.23,39.26)
  BOTTOM w0.102: v2(121.49,3.3) 121.31,3.48 120.9,3.48 RC160.1
PEG_GTX_C_HRX_N0: length 26.1
  TOP w0.102: v2(87.18,60.74) 86.99,60.93 86.46,60.93 85.93,61.46 85.93,65.24 79.3,71.87 75.99,71.87 CV2403.1
  BOTTOM w0.102: R106.1 94.18,60.91 92.48,60.91 92.31,60.74 89.17,60.74 88.97,60.93 87.38,60.93 v2(87.18,60.74)
PEG_GTX_C_HRX_N0_M: length 76.6
  IN3 w0.102: v2(115.81,11.13) 115.02,11.13 114.48,11.68 114.48,14.15 115.15,14.82 117.53,14.82 119.71,17 119.71,19.82 119.58,19.94 119.58,25.36 118.29,26.66 118.29,27.78 117.66,28.4 114.31,28.4 111.44,31.27 110.78,31.27 110.55,31.04 109.98,31.04 109.54,31.48 108.04,31.48 106.86,32.66 106.86,45.7 105.96,46.6 105.96,50.42 105.29,51.08 100.85,51.08 99.52,52.42 95.45,52.42 93.86,54 91.32,54 90.03,55.3 90.03,56.11 90.25,56.33 90.8,56.33 v2(90.86,56.39)
  BOTTOM w0.102: R97.2 116.34,11.31 115.99,11.31 v2(115.81,11.13) ; v2(90.86,56.39) 91.03,56.21 91.22,56.21 91.94,56.93 91.94,57.24 R101.1
PEG_GTX_C_HRX_N0_R: length 24.7
  IN3 w0.076: 106.34,61.91 106.39,61.86 106.39,61.85 107.46,60.79 109.67,60.79 109.96,61.08 109.96,61.17 v2(110.13,61.36)
  IN3 w0.102: 106.34,61.91 105.81,62.44 100.93,62.44 99.34,60.85 96.9,60.85 v2(96.75,60.7)
  BOTTOM w0.076: UC1.F10 109.8,61.68 v2(110.13,61.36)
  BOTTOM w0.102: R101.2 91.94,58.82 91.94,59.09 92.21,59.36 93.35,59.36 93.36,59.38 93.89,59.38 93.9,59.36 96.15,59.36 97.22,60.43 97.22,60.79 97.12,60.88 96.93,60.88 v2(96.75,60.7) 96.54,60.91 95.76,60.91 R106.2
PEG_GTX_C_HRX_N1: length 45.2
  TOP w0.102: CV2405.1 73.98,70.69 78.77,70.69 84.14,65.32 84.14,63.76 84.59,63.3 84.59,61.55 84.83,61.31 85.03,61.31 v2(85.22,61.13)
  IN3 w0.076: v2(109.99,62.25) 109.89,62.16 109.89,61.84 109.74,61.69 109.15,61.69 109.1,61.74 109.09,61.74
  IN3 w0.102: v2(85.22,61.13) 85.4,61.31 85.88,61.31 86.89,62.32 89.99,62.32 90.47,61.84 95.25,61.84 95.73,62.32 99.47,62.32 100.29,63.15 106.64,63.15 108.05,61.74 109.09,61.74
  BOTTOM w0.076: UC1.F8 109.8,62.43 v2(109.99,62.25)
PEG_GTX_C_HRX_N2: length 49.1
  TOP w0.102: CV2407.1 71.16,70.11 71.4,70.11 71.81,69.7 v3(78.24,69.7) 79.05,69.7 83.65,65.09 83.65,63.55 84.05,63.16 84.05,62.48 83.79,62.22 83.41,62.22 v2(83.36,62.18)
  IN3 w0.076: v2(110.79,61.36) 110.79,61.57 110.36,62 110.36,62.49 110.17,62.68 108.42,62.68 107.34,63.76 107.32,63.76 107.27,63.8 107.27,63.8 107.26,63.8 107.25,63.81
  IN3 w0.102: 107.25,63.81 107.17,63.88 102.3,63.88 101.92,64.27 100.34,64.27 99.16,63.08 86.61,63.08 86.23,62.7 84.59,62.7 84.28,62.39 83.57,62.39 v2(83.36,62.18)
  BOTTOM w0.076: v2(110.79,61.36) 110.78,61.37 110.78,61.68 110.9,61.81 111.06,61.81 UC1.H10
PEG_GTX_C_HRX_N3: length 38.8
  TOP w0.102: CV2401.1 77.82,67.95 v3(79.2,67.95) 79.78,67.95 82.96,64.77 82.96,63.62 82.61,63.28 82.19,63.28 v2(82.14,63.22)
  IN3 w0.102: v2(108.78,63.24) 108.94,63.24 109.18,63.48 109.18,63.58 109.13,63.63 108.46,63.63 107.08,65.02 100.08,65.02 98.91,63.85 97.23,63.85 96.77,64.3 96.23,64.3 95.71,63.78 86.3,63.78 85.96,63.45 82.36,63.45 v2(82.14,63.22)
  BOTTOM w0.076: v2(108.78,63.24) 109.15,63.61 UC1.E6
PEG_GTX_C_HRX_P0: length 26.2
  TOP w0.102: v2(87.18,61.33) 86.99,61.14 86.55,61.14 86.14,61.55 86.14,65.33 79.39,72.09 76.22,72.09 CV2402.1
  BOTTOM w0.102: R105.1 94.18,61.12 92.39,61.12 92.22,60.95 89.25,60.95 89.06,61.14 87.38,61.14 v2(87.18,61.33)
PEG_GTX_C_HRX_P0_M: length 76.5
  IN3 w0.102: v2(115.81,11.71) 115.44,11.34 115.11,11.34 114.69,11.77 114.69,14.06 115.24,14.6 117.62,14.6 119.93,16.91 119.93,19.91 119.8,20.03 119.8,25.45 118.5,26.75 118.5,27.87 117.75,28.62 114.4,28.62 111.53,31.49 110.69,31.49 110.46,31.26 110.07,31.26 109.63,31.7 108.13,31.7 107.07,32.75 107.07,45.79 106.17,46.69 106.17,50.51 105.38,51.3 100.94,51.3 99.61,52.63 95.54,52.63 93.95,54.22 91.41,54.22 90.25,55.39 90.25,56.02 90.34,56.11 90.55,56.11 90.59,56.07 v2(90.86,55.8)
  BOTTOM w0.102: v2(115.81,11.71) 115.99,11.53 116.34,11.53 R96.2 ; R100.1 92.16,57.24 92.16,56.84 91.31,56 91.06,56 v2(90.86,55.8)
PEG_GTX_C_HRX_P0_R: length 25
  IN3 w0.076: 106.47,62.04 107.56,60.95 109.6,60.95 109.79,61.15 109.79,61.24 109.7,61.33 v2(109.45,61.33)
  IN3 w0.102: v2(96.75,61.28) 96.96,61.07 99.25,61.07 100.84,62.65 105.86,62.65 106.47,62.04
  BOTTOM w0.076: v2(109.45,61.33) 109.15,61.62 UC1.E10
  BOTTOM w0.102: R105.2 95.76,61.12 96.59,61.12 v2(96.75,61.28) 96.93,61.1 97.21,61.1 97.43,60.87 97.43,60.34 96.24,59.15 v3(93.62,59.15) 92.3,59.15 92.16,59 92.16,58.82 R100.2
PEG_GTX_C_HRX_P1: length 45.1
  TOP w0.102: CV2404.1 73.98,70.9 78.86,70.9 84.35,65.41 84.35,63.85 84.81,63.39 84.81,61.64 84.92,61.53 85.03,61.53 v2(85.22,61.71)
  IN3 w0.076: v2(109.43,62.31) 109.54,62.31 109.63,62.21 109.63,62.1 109.7,62.03 109.7,61.92 109.66,61.88 109.23,61.88 109.17,61.94 109.11,61.94 109.1,61.95 109.09,61.95
  IN3 w0.102: 109.09,61.95 108.14,61.95 106.73,63.36 100.2,63.36 99.38,62.54 95.64,62.54 95.16,62.06 90.56,62.06 90.08,62.54 86.8,62.54 85.79,61.53 85.4,61.53 v2(85.22,61.71)
  BOTTOM w0.076: v2(109.43,62.31) 109.43,62.56 109.28,62.71 UC1.E8
PEG_GTX_C_HRX_P2: length 49.1
  TOP w0.102: CV2406.1 70.71,69.66 70.71,69.84 70.76,69.89 71.31,69.89 71.72,69.48 77.97,69.48 77.98,69.47 78.51,69.47 78.52,69.48 78.96,69.48 83.44,65 83.44,63.46 83.83,63.07 83.83,62.56 83.72,62.45 83.67,62.45 v2(83.36,62.76)
  IN3 w0.076: v2(110.72,62.22) 110.83,62.22 110.96,62.35 110.96,62.73 110.9,62.79 110.78,62.79 110.63,62.64 110.44,62.64 110.21,62.87 108.5,62.87 107.4,63.96
  IN3 w0.102: 107.4,63.96 107.26,64.1 102.39,64.1 102.01,64.48 100.25,64.48 99.07,63.3 86.52,63.3 86.14,62.92 84.51,62.92 84.19,62.6 83.52,62.6 v2(83.36,62.76)
  BOTTOM w0.076: v2(110.72,62.22) 110.77,62.17 110.77,61.97 110.56,61.76 UC1.G10
PEG_GTX_C_HRX_P3: length 38.9
  TOP w0.102: v2(82.14,63.81) 82.46,63.49 82.52,63.49 82.74,63.71 82.74,64.68 79.69,67.73 79.47,67.73 79.46,67.72 78.93,67.72 78.92,67.73 77.51,67.73 77.41,67.63 77.41,67.48 CV2408.1
  IN3 w0.102: v2(82.14,63.81) 82.29,63.66 85.87,63.66 86.21,64 95.62,64 96.14,64.52 96.86,64.52 97.32,64.06 98.82,64.06 99.99,65.23 107.17,65.23 108.55,63.85 109.22,63.85 109.4,63.67 109.4,63.39 v2(109.5,63.29)
  BOTTOM w0.076: UC1.F6 109.62,63.66 109.5,63.54 v2(109.5,63.29)
PEG_GTX_HRX_N0: length 13.9
  TOP w0.102: v4(66.49,78.19) 66.39,78.09 66.08,78.09 65.86,77.88 65.86,76.34 68.04,74.16 70.07,74.16 70.9,73.33 71.24,73.33 v3(72.07,72.5) 72.69,71.87 74.57,71.87 CV2403.2
  BOTTOM w0.102: v4(66.49,78.19) 66.49,78.06 66.22,77.79 UV1.AB9
PEG_GTX_HRX_N1: length 13.2
  TOP w0.102: CV2405.2 72.4,70.69 71.47,70.69 70.37,71.78 70.37,72.99 69.73,73.63 67.7,73.63 65.8,75.53 65.8,75.72 65.41,76.1 65.41,77.5 65.29,77.63 65.12,77.63 65.12,77.63 v4(64.86,77.37)
  BOTTOM w0.102: UV1.AC10 65.28,76.95 v4(64.86,77.37)
PEG_GTX_HRX_N2: length 11.9
  TOP w0.102: CV2407.2 69.76,70.11 68.05,70.11 67.72,69.78 66.46,69.78 66.16,70.07 v3(66.16,73.96) 66.16,74.79 65.57,75.39 65.57,75.62 65.07,76.12 64.95,76.12 64.79,76.27 64.79,76.48 v4(64.86,76.55)
  BOTTOM w0.102: v4(64.86,76.55) 64.46,76.95 UV1.AC11
PEG_GTX_HRX_N3: length 21.6
  TOP w0.102: CV2401.2 76.43,67.95 76.03,67.95 75.86,68.13 74.73,68.13 74.09,67.49 67.41,67.49 65.4,69.5 65.4,70.4 65.43,70.42 65.43,71.08 65.4,71.11 v3(65.4,72.47) 65.4,74.64 64.45,75.59 64.45,76.9 v4(64.01,77.33)
  BOTTOM w0.102: UV1.AB12 63.61,77.74 v4(64.01,77.33)
PEG_GTX_HRX_P0: length 13.9
  TOP w0.102: CV2402.2 74.83,72.56 74.36,72.09 72.78,72.09 71.33,73.54 70.99,73.54 70.15,74.38 68.13,74.38 66.08,76.43 66.08,77.69 66.2,77.82 66.61,77.82 66.74,77.7 66.74,77.52 66.61,77.39 v4(66.51,77.39)
  BOTTOM w0.102: v4(66.51,77.39) 66.09,76.97 UV1.AC9
PEG_GTX_HRX_P1: length 13.3
  TOP w0.102: v4(64.86,78.19) 65.21,77.84 65.38,77.84 65.63,77.59 65.63,76.19 66.01,75.81 66.01,75.62 67.79,73.84 69.82,73.84 70.58,73.08 v3(70.58,72.25) 70.58,71.87 71.56,70.9 72.4,70.9 CV2404.2
  BOTTOM w0.102: UV1.AB10 65.26,77.79 v4(64.86,78.19)
PEG_GTX_HRX_P2: length 12
  TOP w0.102: CV2406.2 70.2,69.66 70.2,69.84 70.15,69.89 68.14,69.89 67.81,69.56 66.37,69.56 65.95,69.98 65.95,74.7 65.35,75.3 65.35,75.53 65.13,75.75 v4(64.86,75.75)
  BOTTOM w0.102: v4(64.86,75.75) 64.46,76.15 UV1.AD11
PEG_GTX_HRX_P3: length 21.5
  TOP w0.102: v4(64.05,76.56) 64.05,75.69 65.19,74.55 v3(65.19,70.83) 65.19,69.41 67.32,67.28 74.18,67.28 74.81,67.91 75.77,67.91 75.94,67.73 76.69,67.73 76.77,67.66 76.77,67.4 CV2408.2
  BOTTOM w0.102: UV1.AC12 63.66,76.95 v4(64.05,76.56)
PEG_HTX_C_GRX_N0: length 46
  IN1 w0.097: v2(68.55,72.56) 68.69,72.7 69.21,72.7 69.97,71.94 78.71,71.94 80.08,70.57 80.08,66.45 81.47,65.05 81.47,60.05 85.62,55.91 85.62,52.18 85.2,51.76 85.2,51.29 85.4,51.09 85.66,51.09 v2(85.85,50.9)
  BOTTOM w0.102: v2(68.55,72.56) 68.41,72.7 68.17,72.7 67.92,72.95 67.92,73.6 UV1.AG7 ; CU16.1 93.16,54.11 92.58,54.11 91.48,53.01 88.38,53.01 86.45,51.08 86.03,51.08 v2(85.85,50.9)
PEG_HTX_C_GRX_N1: length 50.3
  IN1 w0.097: v2(84.76,49.84) 84.7,49.9 84.24,49.9 84.05,50.09 84.05,50.64 84.37,50.97 84.37,51.92 84.92,52.47 84.92,55.62 80.75,59.79 80.75,64.79 79.39,66.15 79.39,70.11 78.26,71.24 69.68,71.24 69.43,70.99 68.5,70.99 v2(68.49,71)
  BOTTOM w0.102: UV1.AE7 67.77,75.22 67.27,74.72 67.27,74.18 67.18,74.09 67.18,73.5 67.47,73.21 67.47,71.68 67.75,71.4 68.2,71.4 68.49,71.11 v2(68.49,71) ; CU18.1 93.28,52.15 88.55,52.15 86.44,50.03 84.94,50.03 v2(84.76,49.84)
PEG_HTX_C_GRX_N2: length 52.4
  IN1 w0.097: v2(66.96,72.04) 67.12,72.19 67.47,72.19 67.58,72.08 67.58,70.96 68.34,70.2 69.66,70.2 69.96,70.51 78,70.51 78.43,70.08 78.43,68.29 78.02,67.88 78.02,66.51 80.03,64.49 80.03,59.51 83.79,55.76 83.79,53.12 84.03,52.87 84.23,52.87 v2(84.43,52.68)
  BOTTOM w0.102: CU20.1 97.42,56.38 92.71,56.38 90.89,54.56 86.73,54.56 85.03,52.86 84.61,52.86 v2(84.43,52.68) ; v2(66.96,72.04) 66.78,72.22 66.57,72.22 66.3,72.48 66.3,73.43 66.46,73.59 66.46,74.03 66.33,74.16 65.94,74.16 65.82,74.27 65.82,74.44 65.94,74.55 UV1.AF9
PEG_HTX_C_GRX_N3: length 49.5
  IN1 w0.097: v2(83.87,51.66) 83.68,51.85 83.46,51.85 83.08,52.23 83.08,55.47 79.32,59.22 79.32,64.21 77.3,66.24 77.3,68.3 77.51,68.51 77.51,69.14 77.19,69.46 67.92,69.46 66.99,70.39 66.84,70.39 v2(66.65,70.2)
  BOTTOM w0.102: UV1.AG10 65.42,73.62 65.42,71.02 66.05,70.39 66.46,70.39 v2(66.65,70.2) ; v2(83.87,51.66) 84.05,51.85 85.03,51.85 86.98,53.8 91.22,53.8 92.6,55.17 95.34,55.17 CU22.1
PEG_HTX_C_GRX_P0: length 45.9
  IN1 w0.097: v2(85.85,51.48) 85.66,51.3 85.49,51.3 85.41,51.38 85.41,51.67 85.83,52.09 85.83,56 81.69,60.14 81.69,65.14 80.29,66.54 80.29,70.66 78.8,72.15 70.06,72.15 69.29,72.91 68.79,72.91 v2(68.55,73.14)
  BOTTOM w0.102: CU17.1 93.41,54.33 92.49,54.33 91.39,53.23 88.29,53.23 86.36,51.3 86.03,51.3 v2(85.85,51.48) ; UV1.AG6 68.24,73.75 68.13,73.65 68.13,73.04 68.22,72.96 68.37,72.96 v2(68.55,73.14)
PEG_HTX_C_GRX_P1: length 50.3
  IN1 w0.097: v2(84.76,50.43) 84.44,50.11 84.33,50.11 84.26,50.18 84.26,50.56 84.58,50.88 84.58,51.83 85.13,52.38 85.13,55.71 80.96,59.88 80.96,64.88 79.6,66.23 79.6,70.19 78.35,71.45 69.59,71.45 69.35,71.21 68.97,71.21 68.81,71.38 v2(68.81,71.49)
  BOTTOM w0.102: UV1.AF7 68.12,74.55 68.25,74.42 68.25,74.1 68.19,74.03 68.05,74.03 67.92,74.16 67.55,74.16 67.43,74.03 67.43,73.56 67.69,73.3 67.69,71.77 67.84,71.62 68.29,71.62 68.42,71.49 v2(68.81,71.49) ; CU19.1 93.29,52.36 88.46,52.36 86.35,50.25 84.94,50.25 v2(84.76,50.43)
PEG_HTX_C_GRX_P2: length 52.4
  IN1 w0.097: v2(66.96,72.62) 67.18,72.4 67.56,72.4 67.79,72.17 67.79,71.05 68.42,70.41 69.57,70.41 69.87,70.72 78.09,70.72 78.64,70.17 78.64,68.2 78.23,67.79 78.23,66.59 80.25,64.58 80.25,59.6 84,55.85 84,53.2 84.12,53.08 84.25,53.08 v2(84.43,53.26)
  BOTTOM w0.102: CU21.1 97.57,56.63 97.51,56.63 97.47,56.6 92.62,56.6 90.8,54.78 86.64,54.78 84.94,53.08 84.61,53.08 v2(84.43,53.26) ; v2(66.96,72.62) 66.78,72.44 66.65,72.44 66.52,72.57 66.52,73.35 66.67,73.5 66.67,74.12 66.46,74.34 66.46,74.86 66.09,75.22 UV1.AE9
PEG_HTX_C_GRX_P3: length 49.5
  IN1 w0.097: v2(66.65,70.79) 66.83,70.6 67.07,70.6 68.01,69.67 77.28,69.67 77.72,69.23 77.72,68.42 77.51,68.21 77.51,66.32 79.53,64.3 79.53,59.31 83.29,55.55 83.29,52.32 83.54,52.06 83.68,52.06 v2(83.87,52.25)
  BOTTOM w0.102: v2(83.87,52.25) 84.05,52.06 84.94,52.06 86.89,54.02 91.13,54.02 92.51,55.39 95.17,55.39 CU23.1 ; UV1.AG9 65.8,73.75 65.63,73.59 65.63,71.11 66.14,70.6 66.46,70.6 v2(66.65,70.79)
PEG_HTX_GRX_N0: length 15
  BOTTOM w0.076: 100.94,53.94 100.96,53.94 100.97,53.95 v3(101.57,53.95) 102.15,53.95 102.5,54.31 106.67,54.31 106.87,54.11 107.28,54.11 107.63,53.75 107.77,53.75 107.87,53.85 107.87,53.99 UC1.C23
  BOTTOM w0.102: 100.94,53.94 100.68,53.94 100.35,53.61 99.36,53.61 99.03,53.94 98.3,53.94 R102.2 97.19,54.08 95.67,54.08 95.49,53.9 94.79,53.9 CU16.2
PEG_HTX_GRX_N0_M: length 62.9
  IN3 w0.102: v2(115.81,12.91) 115.62,13.09 115.4,13.09 115.17,13.31 115.17,13.86 115.44,14.12 118,14.12 121.08,17.2 121.08,24.88 118.96,27 118.96,28.32 118.29,29 115.25,29 114.22,30.03 113.91,30.03 111.8,32.15 108.24,32.15 107.4,32.99 107.4,46.17 106.72,46.85 106.72,50.79 105.16,52.35 101.66,52.35 100.37,53.65 100.28,53.65 100.18,53.65 99.99,53.65 99.73,53.4 v2(99.73,53.2)
  BOTTOM w0.102: R102.1 99.06,53.13 99.66,53.13 v2(99.73,53.2) ; v2(115.81,12.91) 115.99,13.09 116.34,13.09 R99.2
PEG_HTX_GRX_N1: length 13.8
  BOTTOM w0.076: 100.94,52.4 100.95,52.4 100.96,52.42 101.72,52.42 103.21,53.9 105.89,53.9 106.27,53.52 106.72,53.52 106.96,53.76 UC1.B23
  BOTTOM w0.102: CU18.2 94.87,52.14 95.13,52.14 95.39,52.4 100.94,52.4
PEG_HTX_GRX_N2: length 10.5
  BOTTOM w0.076: 101.06,56 101.07,56 101.11,56.04 102.26,56.04 102.9,55.39 v3(103.59,55.39) 105.13,55.39 105.32,55.2 106.2,55.2 106.25,55.25 106.64,55.25 107,54.89 107.32,54.89 107.56,54.65 107.84,54.65 107.92,54.74 107.92,54.86 107.84,54.94 UC1.B21
  BOTTOM w0.102: 101.06,56 100.96,56 100.94,55.97 100.46,55.97 100.43,56 99.81,56 99.45,56.35 99.1,56.35 CU20.2
PEG_HTX_GRX_N3: length 11.1
  BOTTOM w0.076: 100.94,54.97 100.96,54.97 100.97,54.98 103.29,54.98 103.61,54.66 106.9,54.66 106.97,54.59 UC1.B22
  BOTTOM w0.102: CU22.2 96.84,55.26 99.53,55.26 99.82,54.97 100.94,54.97
PEG_HTX_GRX_P0: length 15
  BOTTOM w0.076: 100.94,54.16 100.96,54.16 100.97,54.14 102.07,54.14 102.42,54.5 106.75,54.5 106.95,54.3 107.3,54.3 107.43,54.43 108.21,54.43 UC1.C22
  BOTTOM w0.102: 100.94,54.16 100.6,54.16 100.26,53.83 99.45,53.83 99.12,54.16 98.32,54.16 R104.2 97.45,54.3 95.58,54.3 95.4,54.12 94.96,54.12 CU17.2
PEG_HTX_GRX_P0_M: length 62.9
  IN3 w0.102: v2(99.74,54.31) 99.74,54.1 99.97,53.86 100.08,53.86 100.46,53.86 101.75,52.57 105.24,52.57 106.93,50.88 106.93,46.94 107.62,46.26 107.62,33.08 108.33,32.36 111.89,32.36 114,30.25 114.31,30.25 115.34,29.21 118.38,29.21 119.18,28.41 119.18,27.09 121.3,24.97 121.3,17.11 118.09,13.91 115.53,13.91 115.39,13.77 115.39,13.4 115.49,13.31 115.62,13.31 v2(115.81,13.49)
  BOTTOM w0.102: v2(99.74,54.31) 99.38,54.66 R104.1 ; R98.2 116.34,13.31 115.99,13.31 v2(115.81,13.49)
PEG_HTX_GRX_P1: length 13.7
  BOTTOM w0.076: UC1.A23 106.65,54.03 106.76,53.92 106.76,53.82 106.65,53.71 106.35,53.71 105.97,54.09 103.13,54.09 101.65,52.61 v3(101.37,52.61) 100.95,52.61 100.94,52.62 100.94,52.62
  BOTTOM w0.102: 100.94,52.62 95.3,52.62 95.04,52.36 94.88,52.36 CU19.2
PEG_HTX_GRX_P2: length 10.5
  BOTTOM w0.076: 101.06,56.21 101.08,56.21 101.1,56.2 102.32,56.2 102.97,55.55 103.33,55.55 103.34,55.57 103.85,55.57 103.86,55.55 105.19,55.55 105.38,55.36 106.13,55.36 106.18,55.41 106.71,55.41 107.07,55.05 107.33,55.05 107.6,55.32 UC1.C21
  BOTTOM w0.102: CU21.2 99.03,56.57 99.54,56.57 99.9,56.21 v3(100.75,56.21) 101.06,56.21
PEG_HTX_GRX_P3: length 11
  BOTTOM w0.076: UC1.A21 106.45,54.85 106.27,54.85 106.1,55.03 106,55.03 105.83,54.85 105.64,54.85 105.49,55.01 105.35,55.01 105.19,54.85 105,54.85 104.85,55.01 104.71,55.01 104.56,54.85 104.37,54.85 104.22,55.01 104.01,55.01 103.86,54.85 103.65,54.85 103.33,55.17 v3(102.17,55.17) 100.97,55.17 100.96,55.19 100.94,55.19
  BOTTOM w0.102: 100.94,55.19 99.91,55.19 99.62,55.47 96.84,55.47 CU23.2
PEG_VGA: length 19.2
  TOP w0.102: v2(96.29,39.6) 96.09,39.4 95.76,39.4 95.65,39.5 RC179.1
  BOTTOM w0.076: 100.94,43.6 100.95,43.6 100.96,43.61 101.6,43.61 101.98,43.23 104.3,43.23 104.63,43.56 106.76,43.56 107.04,43.85 UC1.B39
  BOTTOM w0.102: RC196.1 96.69,39.44 96.45,39.44 v2(96.29,39.6) 95.98,39.29 95.9,39.29 95.54,39.66 95.54,43.02 v3(96.14,43.62) 96.87,44.35 99.55,44.35 100.31,43.6 100.94,43.6
PEG_VGA#: length 19.3
  TOP w0.102: v2(96.29,39.01) 96.18,39.13 95.76,39.13 95.65,39.03 RC157.1
  BOTTOM w0.076: UC1.A39 106.5,43.89 106.41,43.89 106.33,43.81 106.2,43.81 106.05,43.95 105.87,43.95 105.72,43.81 104.53,43.81 104.2,43.48 102.08,43.48 101.7,43.85 100.96,43.85 100.95,43.86 100.94,43.86
  BOTTOM w0.102: RC165.1 96.69,39.17 96.45,39.17 v2(96.29,39.01) 96.28,39.03 95.79,39.03 95.27,39.55 95.27,43.13 96.76,44.62 v3(98.23,44.62) 99.67,44.62 100.42,43.86 100.94,43.86
PEG_VGA_EXP: length 58.5
  TOP w0.102: v2(115.82,3.89) 116,3.71 116.45,3.71 RC188.1
  IN3 w0.102: v2(115.82,3.89) 116.01,3.7 116.36,3.7 116.64,3.97 116.64,5.77 112.14,10.27 112.14,14.92 113.55,16.34 116.59,16.34 117.22,16.97 117.22,18.8 115.56,20.47 115.56,25.61 114.26,26.9 110.04,26.9 105.3,31.64 100.6,31.64 97.86,34.37 97.86,39.32 98.17,39.62 v2(98.68,39.62)
  BOTTOM w0.102: v2(98.68,39.62) 98.49,39.44 98.23,39.44 RC196.2
PEG_VGA_EXP#: length 58.5
  TOP w0.102: RC164.1 116.45,3.45 115.97,3.45 v2(115.82,3.3)
  IN3 w0.102: v2(98.68,39.04) 98.36,39.36 98.28,39.36 98.13,39.21 98.13,34.48 100.71,31.9 105.41,31.9 110.15,27.17 114.38,27.17 115.82,25.72 115.82,20.58 117.49,18.91 117.49,16.86 116.7,16.07 113.66,16.07 112.41,14.81 112.41,10.38 116.9,5.88 116.9,3.86 116.47,3.43 115.95,3.43 v2(115.82,3.3)
  BOTTOM w0.102: RC165.2 98.23,39.17 98.54,39.17 v2(98.68,39.04)
PEX_PLL_CLK_OUT: length 3.7
  BOTTOM w0.1: UV1.AF22 55.28,74.55 54.63,73.9 54.63,71.68 RV2.2
PEX_PLL_CLK_OUT#: length 4.9
  BOTTOM w0.1: RV2.1 54.84,71.76 54.84,73.75 55.21,74.12 55.51,74.12 55.8,74.41 55.8,74.92 55.37,75.35 UV1.AE22
PEX_PLLVDD_GPU: length 22.1
  TOP w0.102: CV3056.1 48.19,72.61 v1(48.19,73.18)
  TOP w0.508: v2(50.17,72.79) LV74.1 49.25,71.56 CV3056.1 ; CV227.1 61.68,78.87 v2(61.57,78.99) 61.45,78.87 CV97.1
  IN3 w0.508: v2(61.57,78.99) 61.19,78.99 58.84,76.64 55.85,76.64 54.9,75.68 53.89,75.68 53.31,75.11 53.31,73.33 52.49,72.51 50.46,72.51 v2(50.17,72.79)
  BOTTOM w0.254: UV1.AA14 61.96,78.59 v2(61.57,78.99) 61.17,78.59 UV1.AA15
PEX_TERMP: length 8.1
  BOTTOM w0.102: UV1.AF25 52.87,74.54 52.49,74.16 52.49,72.63 51.52,71.67 RV2703.1 47.34,71.67 v1(47,72.01)
PGOOD_3V_5V: length 4.6
  TOP w0.102: PR58.2 188.17,140.01 v1(188.43,140.26)
  TOP w0.203: 189.2,140.26 189.25,140.26 190.07,141.08 PU51.7
  TOP w0.254: 189.2,140.26 189.06,140.12 PR60.2 PR58.2
PIRQ#_TPM: length 41.5
  TOP w0.102: RC146.2 110.6,89.88 R73.2 110.09,88.42 v2(109.9,88.23) 109.68,88.23 v1(109.45,88)
  IN2 w0.102: v2(114.13,65.56) 113.92,65.56 113.75,65.74 113.75,66.41 113.14,67.02 111.85,67.02 111.5,67.37 110.22,67.37 106.93,70.65 102.11,70.65 100.94,71.83 100.94,78.79 102.11,79.96 103.48,79.96 108.6,85.08 108.6,85.29 107.92,85.96 107.92,87.18 108.97,88.23 v2(109.9,88.23)
  BOTTOM w0.076: v2(114.13,65.56) 113.83,65.26 UC1.N4
PIRQD: length 32.5
  TOP w0.102: R75.2 112.53,88.42 v2(113.18,87.77)
  IN2 w0.102: v2(113.18,87.77) 113.13,87.82 112.67,87.82 109.98,85.13 109.98,79.38 109.27,78.67 109.27,76.99 109.38,76.87 109.38,74.17 110.86,72.7 110.86,72.49 112.04,71.3 112.04,70.54 112.38,70.21 112.38,69.8 113.35,68.83 v2(113.35,68.55)
  BOTTOM w0.076: UC1.N2 113.76,66.8 113.46,67.09 113.46,68.44 v2(113.35,68.55) 113.1,68.8 113.1,69.25 v1(113.09,69.27) 113.02,69.34 113.02,69.84
  BOTTOM w0.102: RC148.2 115.48,72.7 115,72.22 113.73,72.22 113.02,71.5 113.02,69.84
PLT_LAN_RST#: length 11.9
  TOP w0.102: U20.4 172.74,143.85 R25.1 v1(174.34,143.31) v2(174.87,143.31) 175.85,142.33 176.29,142.33 176.5,142.12 U21.36 ; R201.1 v2(173.49,148.37)
  IN3 w0.102: v2(173.49,148.37) 174.87,147 v2(174.87,143.31)
PLTRST_GPU#: length 60.7
  TOP w0.102: v2(76.87,73.89) 75.91,73.89 v1(75.84,73.96) 74.97,74.83 74.97,75.6 74.76,75.81 UV14.2
  IN3 w0.102: v2(76.87,73.89) 76.25,74.51 76.25,75.54 77.6,76.89 82,76.89 84.03,78.92 92.05,78.92 92.84,79.71 97.43,79.71 98.02,79.12 101.2,79.12 102.4,80.32 110.13,80.32 111.12,81.31 114.02,81.31 114.9,82.19 117.2,82.19 118.57,83.55 118.57,83.89 119.3,84.62 122.45,84.62 v2(123.09,83.98)
  BOTTOM w0.102: v2(123.09,83.98) 123.09,83.82 123.74,83.18 123.74,81.66 RC180.1
PLTRST_LAN#: length 147.8
  TOP w0.102: U20.2 173.39,146.8 174.05,147.46 R201.2 175.24,148.52 v1(175.86,148.52) 180.19,148.52 v2(180.63,148.07)
  IN3 w0.102: v2(165.09,81.21) 165.3,81.42 168.38,81.42 169.37,82.4 169.37,83.77 171.36,85.76 171.36,87.86 172.39,88.89 174.49,88.89 176.04,90.44 176.95,90.44 177.63,91.12 179.33,91.12 181.49,93.28 182.27,93.28 183.86,94.87 183.86,108.58 180.45,111.99 180.45,113.35 179.63,114.18 179.63,117.81 178.61,118.83 178.61,123.6 174.99,127.22 174.99,130.96 176.95,132.91 176.95,135.5 177.27,135.82 177.27,142.55 181.01,146.3 181.01,147.69 v2(180.63,148.07)
  BOTTOM w0.102: v2(165.09,81.21) 165.09,81.19 162.09,84.19 156.67,84.19 156.03,83.56 154.07,83.56 153.7,83.93 150.74,83.93 147,87.67 143.59,87.67 142.82,86.91 141.32,86.91 140.63,87.6 137.4,87.6 134.51,90.49 131.13,90.49 130.25,89.6 130.25,88.02 130.85,87.42 130.85,83.38 130.39,82.92 126.47,82.92 126.15,82.6 RC91.1
PLTRST_MMI#: length 146.6
  IN2 w0.102: v2(77.06,72.64) 74.78,70.35 73.89,70.35 70.36,66.82 41.72,66.82 32.61,57.71 25.19,57.71 10.77,43.29 10.77,38.03 9.24,36.5 8.23,36.5 v2(7.66,35.93)
  IN3 w0.102: v2(122.5,83.98) 122.09,84.4 119.46,84.4 118.8,83.73 118.8,83.45 117.3,81.96 115,81.96 114.12,81.08 111.22,81.08 110.2,80.07 103.39,80.07 102.22,78.89 97.92,78.89 97.33,79.48 92.94,79.48 92.15,78.69 84.12,78.69 82.07,76.64 78.55,76.64 77.41,75.49 77.41,72.98 v2(77.06,72.64)
  BOTTOM w0.102: v2(77.06,72.64) 77.06,73.09 v1(77.27,73.3) ; R443.1 6.42,34.7 v2(7.66,35.93) ; v2(122.5,83.98) 122.5,83.72 123.42,82.8 RC90.1
PLTRST_VMM2320#: length 50.9
  TOP w0.102: U6.A13 117.17,108.1 v2(116.69,108.58)
  BOTTOM w0.102: v2(116.69,108.58) 117.45,109.34 v1(117.45,110.3) 117.45,111.18 118.34,112.07 126.72,112.07 127.8,110.99 127.8,98.86 129.77,96.89 129.77,88 130.59,87.18 130.59,83.57 130.2,83.18 125.6,83.18 125.11,82.68 125.11,81.18 RC92.1
PM_APWROK: length 39.9
  TOP w0.102: U38.A9 145.39,97.71 v2(145.34,97.65)
  IN1 w0.097: v2(145.89,85.94) 145.89,86.01 146.22,86.34 151.36,86.34 v2(153.01,87.99)
  IN3 w0.102: v2(145.34,97.65) 145.38,97.69 145.38,98.03 145.85,98.5 148.54,98.5 150.34,96.7 150.34,95.18 151.6,93.92 151.6,91.97 152.12,91.45 152.12,88.88 v2(153.01,87.99)
  BOTTOM w0.102: UC7.2 137.18,77.46 137.06,77.59 RC144.1 136.69,78.65 136.69,79.94 137.06,80.31 137.06,80.99 139.05,82.98 139.53,82.98 141.68,85.13 145.07,85.13 v2(145.89,85.94)
PM_APWROK_R: length 43
  TOP w0.102: v5(144.4,71.1) 144.03,71.1 v2(143.71,70.78)
  IN3 w0.076: v2(118.11,64.76) 118.37,65.02 118.77,65.02 119.2,65.45 119.2,66.62 119.58,67 129.67,67 130.77,68.1 133.79,68.1 134.18,67.72 135.06,67.72 135.91,68.57 135.91,68.94 136.75,69.78 136.75,69.84
  IN3 w0.102: v2(143.71,70.78) 143.23,71.26 142.21,71.26 141.93,70.98 139.67,70.98 139.17,70.48 137.12,70.48 136.75,70.1 136.75,69.84
  BOTTOM w0.089: v2(118.11,64.76) 118.29,64.58 UC1.AB5
  BOTTOM w0.102: v2(143.71,70.78) 143.2,71.29 142.99,71.29 141.58,72.7 141.58,73.71 140.63,74.67 138.28,74.67 137.83,75.11 UC7.4 137.83,75.56 138.28,76 138.28,77.98 RC144.2
PM_LANPHY_ENABLE: length 147.6
  TOP w0.102: v2(192.66,123.37) 192.66,124.93 191.54,126.05 187.99,126.05 185.58,128.46 v1(181.37,128.46) 177.38,128.46 176.95,128.9 176.95,131.06 176.5,131.5 R180.1 ; RC197.1 132.68,68.38 131.35,68.38 128.82,65.84 128.82,63.29 128.5,62.97 127.41,62.97 127.02,63.36 124.18,63.36 v2(123.66,63.89)
  IN2 w0.076: 129.37,69.84 129.37,68.81 127.8,67.24 124.81,67.24 123.93,66.35 123.93,65.71 123.29,65.08 123.29,64.25 v2(123.66,63.89)
  IN2 w0.102: v2(192.66,123.37) 192.66,121.3 188.7,117.34 188.7,115.25 185.14,111.69 185.14,107.88 183.87,106.61 183.87,103.5 182.79,102.42 182.79,98.54 177.44,93.19 177.44,91.75 173.74,88.05 173.74,87.98 173.38,87.62 170.02,87.62 169.76,87.88 166.99,87.88 166.67,88.2 161.89,88.2 161.52,88.57 157.03,88.57 156.61,88.15 155.36,88.15 154.98,87.77 154.39,87.77 153.48,86.86 152.26,86.86 149.85,84.44 149.85,84.29 148.15,82.59 143.87,82.59 143.44,83.02 137.49,83.02 134.91,80.45 134.91,78.22 134.06,77.37 134.06,76.98 134.29,76.75 134.29,74.15 133.84,73.7 132.88,73.7 132.54,73.36 131.69,73.36 129.37,71.04 129.37,69.84
  BOTTOM w0.076: UC1.AM7 123.96,63.58 v2(123.66,63.89)
POA_WAKE#: length 4.8
  TOP w0.102: RP17.3 140.63,96.98 140.16,97.45 139.69,97.45 139.48,97.65 139.48,98.12 140.25,98.89 140.25,99.62 140.44,99.81 U38.B68
POWER_SW#_MB: length 421.1
  TOP w0.102: v2(277.52,167.49) 277.98,167.95 278.36,167.95 278.55,167.76 JPWR1.10 ; v2(193.27,123.37) 193.27,127.05 192.8,127.52 SW5.1 ; C340.1 R329.2 v2(138.59,92.13)
  IN2 w0.102: v2(56.48,11.9) 60.91,16.34 70.72,16.34 72,15.05 95.47,15.05 97.88,12.64 103.09,12.64 104.11,13.67 109.62,13.67 110.64,12.65 111.84,12.65 112.35,12.14 112.35,10.96 112.87,10.45 113.87,10.45 115.05,9.27 119.02,9.27 123.58,13.83 128.18,13.83 130.11,11.9 152.36,11.9 159.19,18.73 159.19,34.48 161.8,37.08 161.8,64.39 162.98,65.57 162.98,72.95 167.82,77.79 167.82,81.19 165.53,83.48 v2(165.53,83.81) 165.72,83.62 167.91,83.62 168.43,84.14 172.54,84.14 174.52,86.12 175.54,86.12 176.02,86.61 176.02,86.94 179.6,90.52 179.6,91.48 180.86,92.73 180.86,94.09 184.95,98.18 184.95,101.3 188.95,105.31 188.95,117.21 193.27,121.53 v2(193.27,123.37)
  IN3 w0.102: v2(275.23,163.05) 275.02,162.83 268.81,162.83 267.12,164.52 258.8,164.52 257.95,163.67 254.63,163.67 254.16,164.14 246.23,164.14 245.46,163.38 238.04,163.38 237.86,163.2 229.87,163.2 228.23,161.56 224.81,161.56 218.6,155.35 218.6,145.53 212.25,139.18 212.25,137.59 210.31,135.65 210.24,135.65 208.8,134.21 208.8,132.61 207.3,131.11 197.71,131.11 193.59,126.99 193.59,123.69 v2(193.27,123.37)
  BOTTOM w0.102: v2(138.59,92.13) 138.59,91.34 139.05,90.89 142.59,90.89 143.06,90.42 145.29,90.42 145.76,90.89 146.89,90.89 147.39,90.39 149.4,90.39 150.56,89.22 151.03,89.22 152.7,87.56 154.52,87.56 154.86,87.21 159.07,87.21 159.49,86.8 161.81,86.8 163.59,85.02 165.26,85.02 165.53,84.75 v2(165.53,83.81) ; SW6.1 41.77,22.1 42.52,21.35 42.52,13.9 45.14,11.28 55.85,11.28 v2(56.48,11.9) ; v2(277.52,167.49) D27.2 277.52,165.33 v5(275.85,163.66) v2(275.23,163.05)
POWER_SW_IN#: length 11.3
  TOP w0.102: v2(141.24,100.29) 141.22,100.31 U38.B67 ; v2(140.69,93.78) 141.01,93.46 C343.1 141,92.13 R329.1 140.14,92.77 R327.2
  BOTTOM w0.102: v2(140.69,93.78) 140.56,93.91 140.56,99.61 v1(140.76,99.81) v2(141.24,100.29)
PROC_OPI_RCOMP: length 3.7
  BOTTOM w0.076: 131.06,58.96 130.97,58.87 129.94,58.87 129.75,58.68 129.25,58.68 UC1.AY15
  BOTTOM w0.305: 131.06,58.96 v1(131.52,58.96) 131.74,58.96 132.34,59.55 RC237.1
PROCHOT#_EC: length 11.9
  TOP w0.102: U38.A46 142.39,111.5 143.04,112.14 143.04,114.86 v1(142.56,115.34) 141.63,116.27 R342.2 R335.2 139.06,116.27 R334.1 137.71,116.25 Q9.2
PROCHOT_GATE: length 83.9
  TOP w0.102: v2(175.81,110.6) 175.81,110.09 v1(176.03,109.86) ; R283.2 174.03,94.02 v2(173.74,94.02) 173.42,94.34 U37.A50
  TOP w0.254: v2(120.5,119.11) 120.8,118.8 PU405.2
  IN3 w0.102: v2(173.74,94.02) 175,95.28 175,99.65 175.23,99.88 175.23,106.14 174.45,106.93 174.45,108.5 174.93,108.98 174.93,109.72 v2(175.81,110.6)
  BOTTOM w0.102: v2(120.5,119.11) 121.07,119.11 123.35,121.39 127.37,121.39 127.89,120.87 130.2,120.87 130.7,120.37 133.73,120.37 135.55,118.55 137.77,118.55 138.02,118.8 139.36,118.8 140.42,117.74 143.84,117.74 144.12,117.47 145.14,117.47 145.77,116.83 158.42,116.83 159.95,115.31 165.14,115.31 166.92,113.53 166.92,112.26 169.16,110.01 169.31,110.01 169.47,109.85 172.65,109.85 173.4,110.6 v2(175.81,110.6)
