# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW_LAN_TX3+: length 128
  TOP w0.089: U23.25 187.27,160.14 187.3,160.17 187.3,160.34 v2(187.23,160.41)
  IN1 w0.089: v2(291.18,159.06) 291.06,159.18 291.06,159.44 290.66,159.83 288.87,159.83 288.76,159.95 281.09,159.95 278.55,162.49 272.83,162.49 271.25,164.08 267.24,164.08 263.29,168.02 236.97,168.02 234.75,165.8 229.14,165.8 225.84,162.51 193.05,162.51 191.36,160.82 187.64,160.82 v2(187.23,160.41)
  BOTTOM w0.089: v2(291.18,159.06) 291.06,159.18 291.06,159.26 291.25,159.46 302.74,159.46 303.19,159.01 304.66,159.01 304.77,158.9 JIO1.35
SW_LAN_TX3-: length 127.2
  TOP w0.089: U23.24 187.77,160.37 v2(187.81,160.41)
  IN1 w0.089: v2(187.81,160.41) 187.89,160.49 191.5,160.49 193.19,162.18 225.98,162.18 229.27,165.47 234.88,165.47 237.11,167.69 263.15,167.69 267.1,163.74 271.11,163.74 272.7,162.16 278.41,162.16 280.95,159.62 288.62,159.62 288.74,159.5 290.53,159.5 290.73,159.3 290.73,159.18 v2(290.6,159.06)
  BOTTOM w0.089: v2(290.6,159.06) 290.66,159.12 290.66,159.42 291.09,159.85 302.9,159.85 303.35,159.4 JIO1.33
SWCLK_REQ#: length 184.5
  IN1 w0.097: v2(102.35,5.64) 102.35,4.99 104.77,2.58 118.82,2.58 119.12,2.88 119.12,8.39 v2(120.42,9.69)
  IN3 w0.102: v2(118.04,72.91) 118.09,72.96 120.7,72.96 122,71.67 123.01,71.67 123.35,72.01 127.41,72.01 129.7,74.31 129.7,76.94 ; 129.7,76.94 129.7,77.32 129.41,77.61 129.41,78.42 129.17,78.67 v2(128.61,78.67) ; 129.7,76.94 130.03,76.94 130.33,76.65 134.02,76.65 135.82,74.84 136.14,74.84 136.35,74.63 137.94,74.63 138.16,74.84 148.71,74.84 148.87,75 154.74,75 155.44,75.7 157.96,75.7 158.52,75.14 158.52,73.5 158.86,73.16 162.38,73.16 v2(163.75,74.54)
  BOTTOM w0.076: UC1.T2 115.26,66.8 114.97,67.08 114.97,67.41 114.85,67.53 114.85,69.03 115.34,69.52 115.34,69.84
  BOTTOM w0.102: v2(120.42,9.69) 120.42,10.48 124.97,15.04 129.16,15.04 132.9,18.78 137.09,18.78 157.47,39.15 157.47,67.95 156.91,68.51 156.91,71.71 157.33,72.14 159.28,72.14 160.18,73.04 162.38,73.04 163.75,74.41 v2(163.75,74.54) ; R488.2 103.09,4 R485.2 102.21,4.87 U93.4 v2(102.35,5.64) ; RP14.7 128.95,79 v2(128.61,78.67) ; 115.34,69.84 115.34,70.6 116.64,71.9 117.11,71.9 v1(117.61,72.4) 118.04,72.84 v2(118.04,72.91)
SYS_LED_MASK#: length 153.5
  TOP w0.102: R310.2 170.85,90.59 v2(170.15,91.29) ; v2(192.06,34.69) 191.62,34.24 191.62,33.71 191.74,33.58 191.74,31.93 189.2,29.39 189.2,25.37 188.12,24.29 188.12,15.51 186.47,13.86 177.25,13.86 175.69,12.3 175.69,7.75 172.31,4.37 172.31,3.74 172.5,3.55 Q24.2 ; 192.51,88.19 Q28.5 ; 192.51,88.19 192.32,88 192.32,87.18 191.93,86.8 188.57,86.8 187.83,87.53 187.83,89.5 186.73,90.61 v1(186.44,90.61) v2(185.65,90.61) ; 192.51,88.19 192.12,88.57 192.12,89.97 192.36,90.21 U47.1 ; v2(169.96,93.78) 169.98,93.76 U37.B48
  IN1 w0.097: v2(169.96,93.78) 169.96,91.48 v2(170.15,91.29)
  IN2 w0.102: v2(192.06,34.69) 190.17,36.58 190.17,40.01 188.05,42.13 188.05,48.71 183.79,52.96 183.79,53.85 182.73,54.92 176.88,54.92 176.39,55.41 176.39,68.69 177.2,69.5 179.59,69.5 181.67,71.58 181.67,74.6 182.31,75.24 184.26,75.24 185.23,76.2 185.23,90.18 v2(185.65,90.61)
  BOTTOM w0.102: v2(185.65,90.61) 185.08,91.18 182.16,91.18 181.11,90.14 180.09,90.14 179.86,90.36 171.98,90.36 171.05,91.29 v2(170.15,91.29)
SYS_PWROK: length 165.2
  TOP w0.102: RC110.1 136.16,17.51 v1(135.15,18.52) 134.48,19.19 131.52,19.19 130,17.67 129.2,17.67 v2(128.92,17.39) ; U37.B57 172.06,96.11 v2(171.07,96.11)
  IN1 w0.097: v2(155.78,82.8) 156.95,82.8 158.69,84.54 161.99,84.54 163.27,85.81 167.52,85.81 168.13,86.43 168.13,89.03 169.14,90.03 169.94,90.03 170.63,90.72 170.63,92.23 171.88,93.48 171.88,95.67 171.45,96.11 v2(171.07,96.11)
  BOTTOM w0.102: v2(128.92,17.39) 129.28,17.75 129.28,18.94 130.48,20.13 136.5,20.13 156.49,40.12 156.49,64.84 154.09,67.24 154.09,71.96 155.3,73.17 158.8,73.17 159.73,74.09 161.41,74.09 162.91,75.59 164.6,75.59 164.88,75.87 164.88,79.51 163.87,80.53 163.87,81.34 161.77,83.44 156.95,83.44 156.31,82.8 v2(155.78,82.8) 153.83,82.8 153.41,83.21 150.45,83.21 146.7,86.96 144.04,86.96 143.28,86.2 138.75,86.2 137.12,84.57 135.42,84.57 134.72,83.87 134.72,79 RC87.1
SYS_PWROK_R: length 30.5
  TOP w0.102: v2(135.61,70.67) 135.61,70.77 v5(135.18,71.2)
  IN3 w0.076: 135.42,69.84 135.42,68.78 134.85,68.21 134.38,68.21 134,68.6 130.43,68.6 129.41,67.58 125.31,67.58 124.94,67.95 124.94,68.83 124.55,69.22 123.88,69.22 123.35,68.7 121.66,68.7 v2(121.28,68.32)
  IN3 w0.102: v2(135.61,70.67) 135.42,70.48 135.42,69.84
  BOTTOM w0.076: v2(121.28,68.32) 121.61,67.99 121.61,67.45 121.55,67.4 121.55,66.87 UC1.AG2
  BOTTOM w0.102: RC87.2 135.17,77.26 135.17,76.76 134.78,76.38 134.78,74.87 135.11,74.54 136.45,74.54 RC84.2 137.01,73.91 136.5,73.4 136.5,71.56 v2(135.61,70.67)
SYS_PWROK_XDP: length 4.7
  TOP w0.102: JXDP1.47 v1(137.15,14.1) 137.15,14.99 CC48.1 RC110.2 RC102.1
SYS_RESET#: length 76
  TOP w0.102: JAPS1.13 158.19,70.16 158.28,70.25 158.28,72.69 157.83,73.13 v2(157.83,73.57)
  IN1 w0.097: v2(118.21,68.32) 117.7,68.82 117.7,70.51 117.58,70.63 117.58,73.09 117.61,73.11 117.61,75.17 115.9,76.88 v2(115.9,77.52)
  IN3 w0.076: v2(118.21,68.32) 118.95,68.32 119.92,67.34 129.43,67.34 130.52,68.43 133.93,68.43 134.31,68.05 134.92,68.05 135.58,68.71 135.58,69.52 135.9,69.84
  IN3 w0.102: v2(115.9,77.52) 115.31,78.12 114.78,78.12 114.68,78.22 v2(109.9,78.22) ; 135.9,69.84 135.9,70.26 137.87,72.23 142,72.23 142.3,72.53 153.03,72.53 153.82,73.32 157.58,73.32 v2(157.83,73.57)
  BOTTOM w0.076: UC1.AC3 119.29,66.17 119.29,66.69 119.06,66.92 118.88,66.92 118.71,67.09 118.71,67.34 118.84,67.46 118.84,67.82 118.34,68.32 v2(118.21,68.32)
  BOTTOM w0.102: UC2.4 106.87,81.18 107.54,80.51 108.32,80.51 RC72.2 109.9,79.94 v2(109.9,78.22)
SYSTEM_ID: length 9.9
  TOP w0.102: C369.1 R386.2 143.6,92.84 v2(142.79,93.65) ; U38.A10 145.89,97.5 145.46,97.07 v2(145.34,97.07)
  IN1 w0.097: v2(145.34,97.07) 145.79,96.62 145.79,95.77 144.02,93.99 143.13,93.99 v2(142.79,93.65)
  BOTTOM w0.102: v2(142.79,93.65) v1(142.79,94.21)
TAA_CLK32: length 13
  BOTTOM w0.102: JTAA1.9 21.91,25.68 21.82,25.77 21.82,26.08 21.36,26.54 v1(21.36,26.85) 21.36,27.11 21.23,27.23 20.88,27.23 20.75,27.11 20.75,26.27 20.88,26.14 20.99,26.14 21.12,26.01 21.12,25.76 20.99,25.63 20.88,25.63 20.75,25.51 20.75,25.29 20.86,25.18 21.5,25.18 21.63,25.05 21.63,22.32 21.5,22.2 21.03,22.2 20.9,22.07 20.9,21.82 21.03,21.69 21.5,21.69 21.63,21.56 21.63,21.26 21.5,21.14 21.04,21.14 R18.2
TAA_CLK64: length 13.2
  BOTTOM w0.102: JTAA1.7 22.15,25.18 21.88,24.92 21.88,23.35 22.01,23.22 25.69,23.22 25.82,23.09 25.82,22.74 25.69,22.61 22.01,22.61 21.88,22.48 21.88,21.09 R13.2
TAA_CS0#_R: length 13.6
  BOTTOM w0.102: JTAA1.11 22.04,26.18 21.69,26.53 21.69,27.24 21.44,27.5 20.75,27.5 20.52,27.26 20.52,25.16 20.73,24.95 21.25,24.95 21.37,24.82 21.37,22.94 20.67,22.24 20.67,21.2 20.55,21.07 20.29,21.07 20.17,21.2 v1(20.17,21.58) 20.17,21.84 20.04,21.96 19.79,21.96 19.66,21.84 R10.2
TAA_CS1#_R: length 13.7
  BOTTOM w0.102: R17.2 18.77,21.1 18.87,21.2 19.24,21.2 19.34,21.31 19.34,21.52 19.21,21.64 18.9,21.64 18.77,21.77 v1(18.77,21.96) 18.77,22.09 18.88,22.2 20.31,22.2 21.12,23.01 21.12,24.59 20.99,24.72 20.54,24.72 20.29,24.97 20.29,27.36 20.66,27.72 21.69,27.72 21.94,27.47 21.94,26.81 22.07,26.68 JTAA1.13
TAA_DIN32: length 13.6
  BOTTOM w0.102: R41.2 16.99,21.64 v1(17.18,21.84) 18.01,22.66 20.12,22.66 20.46,22.99 20.46,24.08 20.28,24.26 20.07,24.26 19.83,24.5 19.83,27.66 20.55,28.38 21.82,28.38 22.01,28.18 JTAA1.19
TAA_DIN64: length 13.6
  BOTTOM w0.102: R22.2 17.88,21.26 18.01,21.39 18.26,21.39 18.39,21.52 18.39,21.77 18.26,21.9 18.13,21.9 18.01,22.03 18.01,22.3 18.13,22.43 20.22,22.43 20.79,23 v1(20.79,23.74) 20.79,24.42 20.71,24.49 20.31,24.49 20.06,24.74 20.06,27.45 20.67,28.06 21.71,28.06 22.09,27.68 JTAA1.17
TAA_DO2_32: length 12.9
  BOTTOM w0.102: R59.1 36.17,20.82 v1(34.96,22.03) 32.68,24.31 32.36,24.31 31.88,23.83 31.7,23.83 31.4,24.13 31.4,24.31 31.66,24.57 31.66,24.69 31.13,25.23 31.13,25.37 31.39,25.64 31.39,25.78 31.18,26 31.04,26 30.77,25.73 30.62,25.73 30.41,25.95 30.41,26.09 30.68,26.36 30.68,26.56 30.52,26.72 30.32,26.72 30.05,26.45 29.9,26.45 29.67,26.68 JTAA1.14
TAA_DO2_64: length 12.8
  BOTTOM w0.102: R58.1 34.21,21.71 34.07,21.71 33.82,21.45 33.69,21.45 33.43,21.72 33.43,21.86 33.97,22.4 33.97,22.58 33.79,22.76 33.61,22.76 33.07,22.22 32.93,22.22 32.71,22.44 32.71,22.58 33.25,23.12 33.25,23.3 33.07,23.48 32.89,23.48 v1(32.69,23.28) 32.35,22.94 32.21,22.94 31.15,23.99 31.15,24.82 29.79,26.18 JTAA1.12
TAA_DO3_32: length 13.5
  BOTTOM w0.102: JTAA1.10 29.78,25.68 v1(30.61,24.85) 30.9,24.57 30.9,21.33 31.03,21.2 31.28,21.2 31.39,21.3 31.39,22.6 31.51,22.72 31.77,22.72 31.89,22.6 31.89,21.3 32,21.2 32.3,21.2 32.4,21.3 32.4,21.86 32.5,21.96 32.81,21.96 32.91,21.86 32.91,21.3 33.01,21.2 33.77,21.2 R48.1
TAA_DO3_64: length 14.3
  BOTTOM w0.102: JTAA1.8 29.78,25.18 30.64,24.31 30.64,22.58 30.52,22.45 30.01,22.45 29.88,22.33 29.88,22.07 30.01,21.95 30.52,21.95 30.64,21.82 30.64,21.57 30.52,21.44 30.01,21.44 29.88,21.31 29.88,20.35 30.01,20.22 30.4,20.22 30.5,20.33 v1(30.5,20.5) 30.5,20.84 30.61,20.95 30.91,20.95 31.01,20.84 31.01,20.33 31.11,20.22 31.42,20.22 31.52,20.33 31.52,20.84 31.62,20.95 31.93,20.95 32.03,20.84 32.03,20.33 32.13,20.22 33.18,20.22 33.31,20.35 R43.1
TAA_DO32: length 12.8
  BOTTOM w0.102: R12.2 27.73,18.74 27.85,18.86 v1(27.85,19.42) 27.85,24.05 27.73,24.18 27.35,24.18 27.22,24.05 27.22,23.33 27.12,23.23 26.82,23.23 26.72,23.33 26.72,24.05 26.59,24.18 JTAA1.3
TAA_DO64: length 13.2
  BOTTOM w0.102: R11.2 25.88,19.17 26.01,19.3 v2(26.36,19.3) 27.22,19.3 27.34,19.42 27.34,19.68 27.22,19.81 26.44,19.81 26.31,19.94 26.31,20.27 26.44,20.4 27.22,20.4 27.34,20.53 27.34,22.72 27.22,22.85 26.58,22.85 26.45,22.98 26.45,23.82 26.33,23.95 25.94,23.95 25.82,23.82 25.82,23.68 25.69,23.55 25.44,23.55 25.31,23.68 25.31,23.82 25.18,23.95 24.93,23.95 24.8,23.82 24.8,23.71 24.67,23.58 24.29,23.58 24.19,23.68 JTAA1.1
TDI_IREF: length 7.9
  BOTTOM w0.076: 100.94,60.58 101.28,60.58 101.43,60.74 102.16,60.74 102.27,60.62 104.36,60.62 105.24,59.75 UC1.B12
  BOTTOM w0.102: v1(99.97,60.09) 100.47,60.58 RC236.2 100.94,60.58
TDI_XDP: length 39.4
  TOP w0.102: v2(103.28,17.74) 106.94,17.74 v1(108.89,15.79) 109.83,14.85 111.87,14.85 112.78,13.94 114.95,13.94 115.1,14.09 127.35,14.09 131.44,9.99 131.44,9.17 132.57,8.04 134.83,8.04 135.15,7.71 JXDP1.56
  BOTTOM w0.102: RC96.2 103.07,17.74 v2(103.28,17.74) 103.5,17.74 RC103.1
TDI_XDP_R: length 4.5
  BOTTOM w0.102: UC6.5 106.37,16.44 105.61,17.2 RC104.1 RC103.2 104.83,18.3 v1(104.01,19.12)
TDO_XDP: length 44.2
  TOP w0.102: JXDP1.52 136.15,5.05 RC280.2 133.45,2.35 131.8,2.35 v1(131.51,2.64) 128.3,5.85 124.24,5.85 121.08,9.02 116.88,9.02 113.23,12.66 110.73,12.66 109.73,11.66 109.08,11.66 105.07,15.67 v2(105.07,16.06)
  BOTTOM w0.102: v2(105.07,16.06) 104.83,15.82 RC95.2 104.82,15.42 RC123.1 105.49,14.48 105.95,14.94 UC6.2
TESTB: length 2.5
  TOP w0.102: R2633.2 300.99,173.12 v1(300.99,172.91) 300.99,172.75 300.7,172.46 U83.14
THERMATRIP2#: length 12.9
  TOP w0.102: Q12.1 152.68,115.5 v1(153.22,114.95) 153.57,114.61 R402.2 C371.1 152.96,112.58 152.28,111.9 152.28,111.75 150.85,110.32 150.85,108.64 150.02,107.81 U38.B34
THERMATRIP3#: length 155.2
  TOP w0.102: v2(142.15,95.94) 142.49,95.94 v1(142.82,96.27) ; v2(142.15,95.94) 142.21,96 142.21,96.77 141.77,97.21 141.77,97.91 141.89,98.03 U38.A2 ; v2(142.15,95.94) 141.83,95.94 141.63,96.14 RP17.1
  IN2 w0.102: v2(77.63,90.22) 77.63,83.02 78.24,82.41 78.24,80.39 79.04,79.59 80.85,79.59 81.7,78.75 81.7,73.14 81.32,72.76 81.32,71.81 80.49,70.98 80.49,66.03 79.73,65.27 79.73,60.76 81.36,59.14 81.36,40.29 78.55,37.48 64.97,37.48 62.58,39.87 61.82,39.87 v2(61.82,39.86)
  IN3 w0.102: v2(142.15,95.94) 141.52,95.3 138.15,95.3 136.31,93.46 130.15,93.46 129.48,92.79 125.21,92.79 123.23,94.77 116.89,94.77 116.31,94.19 116.31,92.28 115.27,91.24 114.32,91.24 113.48,90.4 110.35,90.4 108.1,92.65 102.67,92.65 101.83,91.81 94.14,91.81 93.19,92.76 85.89,92.76 83.1,89.97 77.89,89.97 v2(77.63,90.22)
  BOTTOM w0.102: v2(77.63,90.22) 77.62,90.24 77.62,90.78 78.28,91.45 QC6.6
  BOTTOM w0.254: v2(61.82,39.86) PD601.1
THSEL_STRAP: length 10.2
  TOP w0.102: U38.B29 149.18,105.31 v2(149.08,105.41) ; R383.1 153.2,109.91 152.51,110.6 v1(152.25,110.6) 151.94,110.6 151.42,110.07 v2(151.42,109.91)
  IN3 w0.102: v2(151.42,109.91) 150.15,109.91 149.26,109.02 149.26,108.08 149.72,107.62 149.72,105.91 149.22,105.41 v2(149.08,105.41)
TMDS_CLK: length 184.6
  IN3 w0.102: v2(104.56,35) 104.56,34.16 103.7,33.3 100.75,33.3 99.17,34.88 99.17,40.88 97.03,43.02 93.93,43.02 92.37,41.46 85.44,41.46 80.27,36.29 66.69,36.29 65.95,35.55 65.95,29.15 63.82,27.02 52.34,27.02 51.76,27.59 43.31,27.59 42,26.28 30.47,26.28 28.21,28.54 28.21,39.01 34.81,45.62 34.81,55.34 33.73,56.42 29.03,56.42 21.16,64.29 21.16,70.81 19.95,72.01 19.95,76.6 20.73,77.37 20.73,95.85 22.62,97.75 v2(22.62,98.16)
  BOTTOM w0.076: UC1.B53 107.19,34.89 107.13,34.83 106.86,34.83 106.82,34.88 106.82,35.08 106.55,35.35 106.21,35.35 105.43,34.57 104.45,34.57 104.33,34.69 104.33,34.95 104.4,35.03 104.53,35.03 v2(104.56,35)
  BOTTOM w0.102: v2(22.62,98.16) 22.54,98.24 22.18,98.24 C103.2
TMDS_CLK#: length 184.9
  IN3 w0.102: v2(22.62,98.74) 22.99,98.37 23.13,98.37 23.33,98.17 23.33,97.78 22.96,97.41 22.59,97.41 20.94,95.76 20.94,77.28 20.17,76.51 20.17,72.1 21.37,70.9 21.37,64.38 29.12,56.63 33.82,56.63 35.03,55.43 35.03,45.53 28.42,38.92 28.42,28.63 30.56,26.5 41.91,26.5 43.22,27.8 51.85,27.8 52.42,27.23 63.73,27.23 65.73,29.24 65.73,35.64 66.6,36.5 80.18,36.5 85.35,41.67 92.28,41.67 93.84,43.23 97.12,43.23 99.39,40.97 99.39,34.97 100.84,33.52 103.61,33.52 104.34,34.25 104.34,34.69 104.03,35 v2(103.97,35)
  BOTTOM w0.076: v2(103.97,35) 104.16,34.81 104.16,34.63 104.38,34.41 105.5,34.41 106.25,35.16 106.46,35.16 106.54,35.09 UC1.A53
  BOTTOM w0.102: C191.2 21.92,98.68 22.15,98.45 22.34,98.45 v2(22.62,98.74)
TMDS_DDC_SCL: length 130.5
  TOP w0.102: Q122.1 18.15,102.72 v2(18.07,102.64) ; v2(98.17,65.85) 98.7,65.85 99.08,65.47 v3(99.94,65.47) 100.36,65.47 100.59,65.24 100.8,65.24 101.58,64.46 101.9,64.46 102.74,63.62 105.51,63.62 v2(107.79,61.33)
  IN3 w0.102: v2(18.07,102.64) 18.16,102.73 22,102.73 24.73,100.01 24.73,90.03 23.68,88.99 23.68,78.95 25.68,76.96 25.68,75.44 27.76,73.35 27.76,67.19 28.77,66.18 36.96,66.18 37.8,67.02 72.89,67.02 73.79,66.12 78.05,66.12 78.65,65.52 95.01,65.52 95.53,66.03 98,66.03 v2(98.17,65.85)
  BOTTOM w0.076: v2(107.79,61.33) 108.32,61.86 UC1.D9
  BOTTOM w0.102: v2(98.17,65.85) 98.11,65.92 97.31,65.92 97.19,66.03 96.81,66.03 96.68,65.9 RP1.6
TMDS_DDC_SCL_R: length 9.8
  TOP w0.102: Q122.6 15.72,102.72 R471.1 14.81,101.81 v3(14.45,101.81) 14.1,101.81 13.58,101.3 12.63,101.3 11.59,100.26 11.59,97.97 JHDMI1.15
TMDS_DDC_SDA: length 131.6
  TOP w0.102: v2(98.17,66.44) 98.53,66.08 98.8,66.08 99.18,65.7 100.46,65.7 100.69,65.47 100.89,65.47 100.94,65.42 101.67,64.68 102,64.68 102.84,63.85 105.6,63.85 107.74,61.71 107.99,61.71 108.34,61.36 v2(108.81,61.36) ; Q122.4 17.49,104.02 18.07,103.43 v2(18.07,103.24)
  IN3 w0.102: v2(98.17,66.44) 98,66.26 95.43,66.26 94.92,65.75 78.75,65.75 78.14,66.35 73.89,66.35 72.99,67.25 37.71,67.25 36.87,66.41 28.87,66.41 27.99,67.29 27.99,73.45 25.91,75.53 25.91,77.05 23.91,79.05 23.91,88.89 24.95,89.93 24.95,100.11 22.1,102.96 18.35,102.96 v2(18.07,103.24)
  BOTTOM w0.076: UC1.D11 108.81,61.36 v2(108.81,61.36)
  BOTTOM w0.102: RP1.5 96.69,66.4 96.83,66.26 97.29,66.26 97.41,66.13 97.87,66.13 v2(98.17,66.44)
TMDS_DDC_SDA_R: length 14.8
  TOP w0.102: JHDMI1.16 11.82,98.46 11.82,100.17 12.72,101.07 13.68,101.07 14.19,101.58 14.95,101.58 15.59,102.23 19.96,102.23 20.29,102.56 v1(20.29,102.8) 20.28,102.81 R470.1 20.26,104.02 Q122.3
TMDS_HPD: length 130.4
  TOP w0.102: QZ22.1 24.12,93.74 23.99,93.87 23.99,94.41 R475.1 23.99,99.42 v1(23.6,99.81) 23.6,101.53 23.98,101.91 25.18,101.91 v2(25.56,101.53)
  IN2 w0.102: v2(99.04,85.55) 99.04,84.32 97.19,82.47 97.19,70.35 99.14,68.41 99.14,66.84 100.96,65.02 103.47,65.02 v2(103.91,64.58)
  IN3 w0.102: v2(101.07,92.38) 100.68,92.76 93.52,92.76 87.55,98.73 84.17,98.73 80.43,102.48 78.59,102.48 77.91,103.15 75.19,103.15 74.84,103.5 74.84,104.13 74.4,104.58 69.51,104.58 69.19,104.26 63.41,104.26 61.63,102.48 60.43,102.48 59.35,101.4 29.06,101.4 28.55,101.91 26.26,101.91 25.88,101.53 v2(25.56,101.53)
  BOTTOM w0.076: v2(103.91,64.58) 104.33,64.58 106.23,62.68 UC1.A8
  BOTTOM w0.102: v2(99.04,85.55) 99.04,89.09 101.07,91.11 v2(101.07,92.38)
TMDS_N0: length 184.2
  IN3 w0.102: v2(105.18,36.97) 105,37.15 105,38.42 104.6,38.82 102.35,38.82 101.86,39.31 101.86,42.05 97.64,46.28 95.26,46.28 94.16,47.39 84.4,47.39 83.54,46.52 83.54,43.16 79.01,38.62 65.61,38.62 63.64,36.66 63.64,30.18 63,29.54 58.88,29.54 58.46,29.96 42.28,29.96 40.91,28.59 31.57,28.59 30.64,29.52 30.64,38.17 37.18,44.71 37.18,57.14 35.19,59.14 33.08,59.14 28.98,63.24 26.01,63.24 23.47,65.78 23.47,71.84 22.29,73.02 22.29,75.39 23.08,76.18 23.08,89.44 24.04,90.4 24.04,99.79 23.01,100.82 22.83,100.82 v2(22.62,101.03)
  BOTTOM w0.076: v2(105.18,36.97) 105.38,36.77 105.75,36.77 106.14,37.16 107.37,37.16 107.66,37.46 UC1.C49
  BOTTOM w0.102: C209.2 22.22,100.84 22.44,100.84 v2(22.62,101.03)
TMDS_N1: length 183.1
  IN3 w0.102: v2(102.61,35) 102.55,34.95 102.55,34.37 102.25,34.07 100.97,34.07 99.87,35.17 99.87,41.19 96.5,44.57 93.88,44.57 92.71,43.4 86.23,43.4 79.84,37.01 66.39,37.01 65.25,35.87 65.25,29.47 63.69,27.91 57.86,27.91 57.45,28.31 43.03,28.31 41.69,26.98 30.78,26.98 28.9,28.86 28.9,38.72 35.51,45.33 35.51,56.04 34.43,57.12 29.48,57.12 21.86,64.73 21.86,71.15 20.67,72.33 20.67,76.24 21.46,77.03 21.46,94.7 22.69,95.93 22.69,96.3 22.74,96.35 v2(22.74,96.89)
  BOTTOM w0.076: UC1.C53 107.58,34.95 107.3,34.67 106.03,34.67 105.52,34.15 102.94,34.15 102.56,34.54 102.56,34.96 v2(102.61,35)
  BOTTOM w0.102: C270.2 22.21,96.28 22.72,96.28 22.95,96.51 22.95,96.69 v2(22.74,96.89)
TMDS_N2: length 178.3
  IN3 w0.102: v2(22.25,94.16) 22.27,94.16 22.49,93.93 22.8,93.93 23.06,93.67 23.06,90.57 22.38,89.88 22.38,76.56 21.59,75.77 21.59,72.72 22.77,71.54 22.77,65.28 25.65,62.4 28.33,62.4 32.3,58.44 34.56,58.44 36.42,56.57 36.42,44.95 29.88,38.41 29.88,29.2 31.19,27.89 41.22,27.89 42.56,29.23 58.11,29.23 58.5,28.85 63.31,28.85 64.34,29.87 64.34,36.28 65.99,37.93 79.31,37.93 86.78,45.39 90.09,45.39 90.85,46.16 92.67,46.16 93.34,45.48 96.88,45.48 100.82,41.54 100.82,36.02 101.09,35.75 102.21,35.75 102.3,35.84 102.3,36.07 102.1,36.27 v2(101.96,36.27)
  BOTTOM w0.076: UC1.C51 107.45,35.94 107.41,35.91 107.26,35.87 107.07,35.87 107.04,35.88 106.92,35.93 106.81,35.93 106.64,35.87 106.59,35.87 106.58,35.86 106.56,35.87 106.52,35.87 106.51,35.89 104.85,35.89 104.55,35.58 102.59,35.58 102.41,35.75 102.38,35.75 102.3,35.83
  BOTTOM w0.102: v2(101.96,36.27) 102.07,36.27 102.3,36.05 102.3,35.83 102.3,35.83 ; v2(22.25,94.16) 22.11,94.02 22.02,93.92 21.88,93.92 21.6,94.2 C272.2
TMDS_P0: length 184.1
  IN3 w0.102: v2(104.61,36.96) 104.78,37.14 104.78,38.34 104.51,38.61 102.26,38.61 101.65,39.22 101.65,41.96 97.55,46.07 95.17,46.07 94.07,47.17 84.49,47.17 83.76,46.44 83.76,43.07 79.09,38.41 65.7,38.41 63.85,36.57 63.85,30.09 63.09,29.33 58.79,29.33 58.37,29.75 42.37,29.75 40.99,28.38 31.48,28.38 30.43,29.43 30.43,38.26 36.97,44.8 36.97,57.05 35.1,58.92 32.99,58.92 28.89,63.02 25.92,63.02 23.25,65.69 23.25,71.75 22.07,72.93 22.07,75.48 22.86,76.27 22.86,89.53 23.82,90.49 23.82,99.7 22.92,100.6 22.78,100.6 v2(22.62,100.44)
  BOTTOM w0.076: UC1.B50 107.43,36.97 106.22,36.97 105.83,36.58 104.99,36.58 v2(104.61,36.96)
  BOTTOM w0.102: C199.2 22.29,100.63 22.44,100.63 v2(22.62,100.44)
TMDS_P1: length 183.2
  IN3 w0.102: v2(23.33,96.89) 23.13,96.69 23.13,96.42 22.91,96.21 22.91,95.84 21.68,94.61 21.68,76.94 20.89,76.15 20.89,72.42 22.07,71.24 22.07,64.82 29.56,57.33 34.52,57.33 35.72,56.13 35.72,45.24 29.12,38.63 29.12,28.95 30.87,27.19 41.6,27.19 42.94,28.53 57.54,28.53 57.95,28.12 63.6,28.12 65.04,29.56 65.04,35.96 66.31,37.23 79.76,37.23 86.14,43.62 92.62,43.62 93.79,44.78 96.59,44.78 100.09,41.28 100.09,35.26 101.06,34.28 102.16,34.28 102.33,34.46 102.33,34.76 102.09,35 v2(101.96,35)
  BOTTOM w0.076: UC1.B54 107.39,34.51 106.1,34.51 105.58,33.99 102.88,33.99 102.4,34.47 102.4,34.71 102.1,35 v2(101.96,35)
  BOTTOM w0.102: v2(23.33,96.89) 23.16,96.73 23.16,96.42 22.81,96.07 22.3,96.07 C269.2
TMDS_P2: length 178.3
  IN3 w0.102: v2(22.25,93.57) 22.4,93.72 22.71,93.72 22.85,93.58 22.85,90.66 22.16,89.97 22.16,76.65 21.37,75.86 21.37,72.63 22.55,71.45 22.55,65.19 25.56,62.18 28.24,62.18 32.21,58.22 34.47,58.22 36.21,56.48 36.21,45.04 29.67,38.5 29.67,29.11 31.1,27.68 41.31,27.68 42.65,29.01 58.02,29.01 58.41,28.63 63.4,28.63 64.55,29.78 64.55,36.19 66.08,37.71 79.4,37.71 86.87,45.18 90.18,45.18 90.94,45.94 92.58,45.94 93.25,45.27 96.79,45.27 100.61,41.45 100.61,35.93 101,35.54 102.3,35.54 102.51,35.75 102.51,36.18 v2(102.61,36.27)
  BOTTOM w0.076: UC1.C50 107.72,36.62 107.54,36.45 107.54,36.27 107.34,36.07 107.23,36.04 107.1,36.04 107.04,36.06 107.03,36.07 106.95,36.1 106.73,36.1 106.61,36.04 106.59,36.04 106.58,36.05 104.79,36.05 104.48,35.74 102.66,35.74 102.52,35.88 102.52,35.91
  BOTTOM w0.102: 102.52,35.91 102.51,35.92 102.51,36.18 v2(102.61,36.27) ; C271.2 21.86,93.7 22.12,93.7 v2(22.25,93.57)
TMDS_RP_CLK: length 4.5
  BOTTOM w0.102: L9.1 17.4,97.72 L10.1 17.84,97.8 18.21,98.17 18.54,98.17 R464.1 19.06,98.31 20.67,98.31 C103.1
TMDS_RP_CLK#: length 4.5
  BOTTOM w0.102: L11.1 17.4,98.73 L10.4 17.84,98.65 18.08,98.4 18.29,98.4 R466.1 19.06,98.52 20.67,98.52 C191.1
TMDS_RP_N0: length 4.6
  BOTTOM w0.102: C209.1 20.67,100.81 20.01,100.81 R463.1 19.18,100.63 18.27,100.63 17.96,100.94 L13.4 17.4,101.02 L14.1
TMDS_RP_N1: length 4.5
  BOTTOM w0.102: L17.1 17.4,96.51 L16.4 17.9,96.43 18.13,96.19 19.07,96.19 19.44,96.56 R469.1 19.82,96.56 20.15,96.24 20.67,96.24 C270.1
TMDS_RP_N2: length 4.2
  BOTTOM w0.102: L20.1 17.4,93.91 L19.4 17.86,93.82 18.15,93.54 18.25,93.54 R468.1 19.19,94.09 19.29,93.98 20.33,93.98 C272.1
TMDS_RP_P0: length 4.4
  BOTTOM w0.102: C199.1 20.67,100.59 20.01,100.59 R462.1 19.39,100.27 19.25,100.41 18.24,100.41 17.91,100.09 L13.1 17.4,100 L12.1
TMDS_RP_P1: length 4.5
  BOTTOM w0.102: L15.1 17.4,95.5 L16.1 17.89,95.58 18.27,95.97 v3(18.72,95.97) 19.15,95.97 19.42,95.7 R467.1 19.8,95.7 20.12,96.02 20.67,96.02 C269.1
TMDS_RP_P2: length 4.1
  BOTTOM w0.102: C271.1 20.37,93.77 19.91,93.77 R465.1 18.55,93.54 18.34,93.32 18.2,93.32 17.85,92.97 L19.1 17.4,92.89 L18.1
TMDSB_CON_CLK: length 6.4
  BOTTOM w0.102: L9.2 15.87,97.72 L10.2 15.38,97.8 15.05,98.14 14.96,98.14 14.94,98.12 14.41,98.12 14.4,98.14 14.17,98.14 13.39,97.35 13.39,95.55 13.08,95.24 12.76,95.24 12.48,94.96 JHDMI1.10
TMDSB_CON_CLK#: length 6.3
  BOTTOM w0.102: JHDMI1.12 12.82,95.46 12.99,95.46 13.17,95.64 13.17,97.44 14.08,98.35 v3(14.68,98.35) 15.06,98.35 15.36,98.65 L10.3 15.87,98.73 L11.2
TMDSB_CON_N0: length 11.4
  BOTTOM w0.102: L14.2 15.87,101.02 L13.3 15.27,100.94 14.95,100.61 v3(14.62,100.61) 12.84,100.61 11.56,99.33 11.56,94.01 11.49,93.95 11.28,93.95 JHDMI1.9
TMDSB_CON_N1: length 7
  BOTTOM w0.102: JHDMI1.6 12.9,92.38 13.19,92.38 13.41,92.6 13.41,93.54 13.89,94.02 13.89,95.55 14.5,96.16 v3(14.71,96.16) 15.06,96.16 15.33,96.43 L16.3 15.87,96.51 L17.2
TMDSB_CON_N2: length 8.1
  BOTTOM w0.102: JHDMI1.3 11.46,90.77 11.59,90.77 12.15,90.21 12.78,90.21 14.39,91.82 14.39,92.22 14.37,92.23 14.37,92.76 14.39,92.77 14.39,93.28 14.62,93.51 15.07,93.51 15.38,93.82 L19.3 15.87,93.91 L20.2
TMDSB_CON_P0: length 11.5
  BOTTOM w0.102: L12.2 15.87,100 L13.2 15.28,100.09 14.99,100.38 14.35,100.38 14.34,100.4 12.93,100.4 11.77,99.24 11.77,93.92 11.58,93.73 11.36,93.73 JHDMI1.7
TMDSB_CON_P1: length 7
  BOTTOM w0.102: L15.2 15.87,95.5 L16.2 15.35,95.58 15,95.93 14.58,95.93 14.11,95.46 14.11,93.93 13.63,93.45 13.63,92.51 13.28,92.17 12.85,92.17 JHDMI1.4
TMDSB_CON_P2: length 8
  BOTTOM w0.102: L18.2 15.87,92.89 L19.2 15.33,92.97 15.01,93.3 14.71,93.3 14.6,93.19 v3(14.6,92.49) 14.6,91.73 12.87,90 12.06,90 11.5,90.55 11.18,90.55 JHDMI1.1
TMS_XDP: length 38.4
  TOP w0.102: JXDP1.58 134.65,4.07 133.3,2.72 131.96,2.72 v1(130.45,4.23) 128.47,6.21 v2(128.47,6.29)
  IN1 w0.097: v2(111.23,17.2) 112.69,15.74 119.25,15.74 121.19,13.8 121.19,9.2 123.8,6.6 123.81,6.6 124.61,5.79 127.98,5.79 v2(128.47,6.29)
  BOTTOM w0.102: UC6.9 109.64,16.94 109.9,17.2 v2(111.23,17.2) 111.28,17.15 RC101.2
TOUCH_PANEL_INTR#: length 75.7
  TOP w0.102: v2(114.03,70.94) 113.96,70.87 RC315.1 ; JTS1.6 80.21,96.92 79.86,96.57 79.86,94.96 v2(79.69,94.8)
  IN2 w0.102: v2(79.69,94.8) 79.69,94.71 79.7,94.71 79.7,85.05 82.6,82.15 82.6,72.42 v2(82.24,72.07)
  IN3 w0.102: v2(114.03,70.94) 113.78,70.94 112.41,72.32 110.71,72.32 109.3,70.9 103.86,70.9 103.27,71.49 102.41,71.49 101.39,72.52 v2(100.21,72.52) 99.63,73.11 93.62,73.11 92.58,74.15 90,74.15 89.34,73.49 89.34,73.04 88.42,72.12 87.54,72.12 86.89,72.77 82.95,72.77 v2(82.24,72.07)
  BOTTOM w0.076: UC1.P3 114.54,65.97 114.8,66.22 114.8,66.77 114.65,66.92 114.38,66.92 114.23,67.08 114.23,67.42 114.36,67.55 114.36,69.44 114.18,69.62 114.18,69.84
  BOTTOM w0.102: 114.18,69.84 114.18,70.78 v2(114.03,70.94) ; v2(79.69,94.8) v5(79.69,95.4) ; RC324.2 98,70.93 99.59,72.52 v2(100.21,72.52)
TOUCH_RST_N_GYRO_INT1: length 8
  BOTTOM w0.076: 112.49,69.84 112.49,69.54 112.52,69.52 112.52,68.64 113.13,68.02 113.13,67.34 UC1.L1
  BOTTOM w0.102: 112.49,69.84 v1(112.49,72.07) 112.49,72.13 113.89,73.52 RP9.6
TOUCHPAD_INTR#: length 40.9
  TOP w0.102: v2(107.12,85.14) 107.8,84.47 RC140.2 v1(108.93,84.33)
  IN2 w0.076: v2(115.23,62.86) 114.97,62.6 114.02,62.6 113.76,62.86 113.76,64.96 113.35,65.37 113.35,66.14 113.15,66.35
  IN2 w0.102: 113.15,66.35 111.98,66.35 111.35,66.99 109.9,66.99 106.74,70.15 101.87,70.15 99.62,72.39 99.62,74.28 100.45,75.11 100.45,79 101.89,80.45 103.03,80.45 107.12,84.54 v2(107.12,85.14)
  BOTTOM w0.076: UC1.U7 115.41,62.95 115.32,62.95 v2(115.23,62.86)
TP_CLK: length 68.2
  TOP w0.102: v2(182.95,104.88) 182.77,104.71 182.6,104.71 182.52,104.78 182.52,106.3 181.98,106.85 181.41,106.85 181.3,106.96 D22.2 180.44,106.84 180.37,106.84 180.22,106.84 179.96,106.58 179.96,105.11 180.4,104.67 180.4,104.4 C380.1 180.14,103.19 L45.1 ; JTP1.7 153.18,94.38 153.04,94.25 153.04,93.88 152.75,93.59 152.52,93.59 v2(152.34,93.41)
  IN3 w0.102: v2(168.15,82.16) 168.33,82.34 168.56,82.34 168.82,82.6 168.82,83.9 170.9,85.98 170.9,88.05 172.2,89.34 174.3,89.34 175.85,90.89 176.76,90.89 177.44,91.58 179.14,91.58 180.33,92.76 180.33,97.55 181.56,98.78 181.56,101.86 183.63,103.92 183.63,104.36 183.31,104.68 183.16,104.68 v2(182.95,104.88)
  BOTTOM w0.102: v2(152.34,93.41) 152.52,93.59 152.62,93.59 152.97,93.24 152.97,92.98 153.54,92.42 158.45,92.42 159.07,91.8 161.87,91.8 162.5,91.17 162.5,89.95 163.83,88.61 163.83,87.46 164.39,86.9 165.75,86.9 167.42,85.23 167.42,82.74 167.8,82.35 167.97,82.35 v2(168.15,82.16)
TP_DATA: length 66.6
  TOP w0.102: JTP1.6 152.68,94.38 152.82,94.25 152.82,93.97 152.66,93.82 152.52,93.82 v2(152.34,94) ; L44.1 181,103.13 C379.1 180.63,104.5 180.63,104.77 180.19,105.21 180.19,106.48 180.31,106.61 180.46,106.61 D22.3 181.3,106.51 181.41,106.62 181.88,106.62 182.29,106.21 182.29,104.69 182.5,104.48 182.77,104.48 v2(182.95,104.3)
  IN3 w0.102: v2(168.15,82.75) 168.33,82.57 168.46,82.57 168.59,82.7 168.59,83.99 170.67,86.08 170.67,88.14 172.1,89.57 174.2,89.57 175.75,91.12 176.66,91.12 177.35,91.81 179.05,91.81 180.1,92.86 180.1,97.64 181.33,98.88 181.33,101.95 183.4,104.02 183.4,104.26 183.21,104.45 183.1,104.45 v2(182.95,104.3)
  BOTTOM w0.102: v2(152.34,94) 152.52,93.82 152.72,93.82 153.2,93.34 153.2,93.08 153.63,92.65 158.54,92.65 159.16,92.03 161.96,92.03 162.72,91.27 162.72,90.04 164.06,88.71 164.06,87.56 164.49,87.13 165.85,87.13 167.64,85.33 v3(167.64,84.72) 167.64,82.83 167.84,82.64 168.05,82.64 v2(168.15,82.75)
TP_DC_TEST_B2: length 5.1
  BOTTOM w0.254: RC139.1 105.94,68.58 106.59,67.94 106.59,67.16 UC1.B2
TP_LAN_JTAG_TCK: length 3.6
  TOP w0.102: U21.35 176.9,142.42 176.4,142.92 175.83,142.92 v1(175.63,143.13) 175.63,143.75 R172.2
TP_LAN_JTAG_TDI: length 2.5
  TOP w0.102: U21.32 178.1,144.01 T92.1
TP_LAN_JTAG_TDO: length 1.6
  TOP w0.102: T93.1 177.3,142.74 U21.34
TP_LAN_JTAG_TMS: length 4.6
  TOP w0.102: U21.33 177.7,143.5 R171.2 177.01,144.19 177.6,144.77 177.6,145.01 v1(178.05,145.47)
TPM_ID0: length 25.3
  TOP w0.102: RC284.2 100.81,81.2 100.04,81.97 v2(99.57,81.97)
  IN2 w0.102: v2(108.77,65.44) 108.15,65.44 104.38,69.21 101.35,69.21 98.7,71.85 98.7,79.83 99.03,80.16 99.03,81.4 99.57,81.93 v2(99.57,81.97)
  BOTTOM w0.076: 108.95,65.26 v2(108.77,65.44)
  BOTTOM w0.089: UC1.E4 108.95,65.26
TPM_ID1: length 6.9
  BOTTOM w0.076: UC1.C3 107.84,66.05 107.46,66.43 107.44,66.45 107.44,66.87 107.02,67.29
  BOTTOM w0.102: 107.02,67.29 107.02,68.13 105.63,69.52 RC285.2
TRIP_+VDDRP: length 3.4
  BOTTOM w0.102: PR702.2 v1(32.81,28.32)
  BOTTOM w0.254: PR702.2 33.02,29.33 34.23,30.54 PU700.2
TRST#_XDP: length 31.8
  TOP w0.102: JXDP1.54 135.65,7.93 135.31,8.27 132.67,8.27 131.67,9.26 131.67,10.09 127.44,14.33 114.89,14.33 114.76,14.19 113.04,14.19 v1(112.75,14.48) 112.06,15.17 110.59,15.17 110.05,15.71 v2(110.05,15.71)
  BOTTOM w0.102: v2(110.05,15.71) 109.78,15.44 UC6.12
U2_BOOT1:
  vias: v1(59.68,38.5)
U2_BOOT2: length 4.1
  BOTTOM w0.254: PU600.18 54.16,36.55 53.95,36.76 53.95,37.77
  BOTTOM w0.508: PR631.1 53.19,39.17 53.95,38.41 53.95,37.77
U2_LGATE1: length 11.7
  TOP w1.016: 57.7,39.87 59.22,41.39 66.97,41.39 67.22,41.65
  BOTTOM w0.102: v1(69.39,40.64) 69.39,40.81 68.93,41.27 PQ601.4
  vias: v2(57.38,38.92) v2(57.38,38.28) v2(68.24,42.22) v2(68.24,41.58) v2(73.82,42.22) v2(73.82,41.58)
U2_LGATE2: length 4.7
  TOP w1.016: 54.71,42.92 54.71,41.33 55.79,40.25 55.79,39.62
  BOTTOM w0.254: v2(55.66,38.22) 55.74,38.14 PU600.20
  vias: v1(54.9,43.98) v2(50.39,44.19) v2(50.39,43.55) v2(55.66,38.85) v2(56.11,44.19) v2(56.11,43.55)
U2_PHASE1: length 14.4
  IN1 w1.016: 60.17,38.85 62.97,38.85 64.53,40.42 64.53,43.45 69.01,47.93
  vias: v1(74.84,49.39) v2(58.33,38.98) v2(58.33,38.35) v2(69.57,48.95) v2(70.2,48.95)
U2_PHASE2: length 9.6
  TOP w1.016: 51.47,46.85 52.23,46.09 52.23,40.89 53.82,39.3
  BOTTOM w0.254: PU600.19 55.24,37.69 54.96,37.96 v2(54.96,38.22)
  vias: v1(50.58,53.9) v2(50.52,48) v2(50.52,47.36) v2(54.96,38.85)
U2_UGATE1: length 23.5
  IN1 w1.016: 75.19,52.16 74.95,52.16 65.8,43.01 65.8,39.97 62.78,36.95 61,36.95
  BOTTOM w0.254: v2(59.54,36.38) 59.21,36.05 PU600.2
  vias: v1(59.94,36.68) v2(59.54,37.01) v2(75.73,53.27) v2(76.24,53.59)
U2_UGATE2: length 27
  TOP w1.016: 51.92,38.28 49.06,41.14 49.06,47.93 56.87,55.74 60.17,55.74
  BOTTOM w0.254: v2(53.31,36.95) 53.5,36.76 53.5,36.38 53.83,36.05 PU600.17
  vias: v1(53.02,38) v2(53.31,37.58) v2(61.19,55.74) v2(61.82,55.74)
UG_3V: length 12.1
  TOP w0.102: PQ51.4 204.73,141.34 v1(205.07,141.67)
  IN3 w1.016: 192.7,140.39 202.09,140.39 202.92,141.22
  vias: v2(191.81,140.66) v2(191.81,140.07) v2(203.43,142.04) v2(204.06,142.04)
UG_5V: length 14.8
  TOP w0.102: v1(192.46,145.66) 192.28,145.48 v2(191.73,145.48)
  IN3 w1.016: 202.28,145.72 201.4,146.61 201.4,148.01 199.15,150.25 196.27,150.25 192.51,146.49
  vias: v2(191.73,144.9) v2(203.43,145.6) v2(204.06,145.6)
UG_+VDDRP: length 11.1
  TOP w1.016: 45.88,35.68 45.88,31.23 44.8,30.15 40.3,30.15
  BOTTOM w0.102: v2(46.14,37.77) 46.14,38.18 v1(45.96,38.36)
  vias: v2(38.65,30.47) v2(39.24,30.45) v2(46.14,37.14)
UIM_CLK: length 39.7
  TOP w0.102: v2(232.42,160.76) 232.17,161.01 U28.3 231.71,161.84 C264.1 230.85,160.98 230.1,160.98 229.45,160.33 229.45,155.55 230.89,154.12 230.89,148.17 226.99,144.27 v3(226.99,142.9) 226.99,141.28 221.84,136.14 221.84,133.7 v2(221.8,133.66)
  BOTTOM w0.102: v2(232.42,160.76) 232.89,160.28 JSIM1.5 ; v2(221.8,133.66) 221.65,133.5 JMINI2.12
UIM_DATA: length 40.1
  TOP w0.102: v2(222.39,133.66) 222.45,133.72 222.45,135.88 v3(223.38,136.81) 227.6,141.02 227.6,144.01 231.49,147.91 231.49,154.38 230.06,155.81 230.06,160.07 230.35,160.37 230.82,160.37 C267.1 231.16,160.02 231.16,159.98 231.8,159.34 U28.4 232.17,160.29 v2(231.79,160.67)
  BOTTOM w0.102: JSIM1.4 232.19,160.26 v2(231.79,160.67) ; v2(222.39,133.66) 222.39,133.24 222.04,132.89 220.75,132.89 220.55,132.7 JMINI2.10
UIM_RESET: length 41.7
  TOP w0.102: v2(234.72,160.64) 234.07,161.29 U28.1 234.65,161.84 C265.1 236.33,160.16 236.33,150.14 229.53,143.34 v1(229.53,142.65) 229.53,140.07 v2(223.81,134.36)
  BOTTOM w0.102: JSIM1.7 234.29,160.22 v2(234.72,160.64) ; JMINI2.14 220.71,134.3 221.25,134.85 223.32,134.85 v2(223.81,134.36)
UIM_VPP: length 39.5
  TOP w0.102: v2(233.98,160.64) 234.07,160.56 U28.6 234.65,159.34 C266.1 236.1,159.53 236.1,150.24 229.07,143.2 v1(229.07,140.77) 229.07,140.25 v2(223.81,134.99)
  BOTTOM w0.102: JSIM1.6 233.59,160.25 v2(233.98,160.64) ; v2(223.81,134.99) 223.7,135.1 JMINI2.16
USB3RN0: length 104.6
  IN3 w0.089: 108.14,55.71 108.15,55.72 108.15,55.73 108.2,55.77 108.2,55.78 108.41,56 110.28,56 110.34,55.94 110.34,55.83 v2(110.13,55.62)
  IN3 w0.102: 108.14,55.71 107.4,54.97 101.76,54.97 100.44,56.29 92.29,56.29 91.65,56.93 84.85,56.93 83.48,58.3 82.51,58.3 78.78,62.03 77.53,62.03 76.03,63.53 72.78,63.53 71.52,64.79 39.48,64.79 35.97,61.27 33.83,61.27 30.55,64.55 27.57,64.55 25.79,66.32 25.79,72.86 24.94,73.71 23.88,73.71 v2(23.59,73.42)
  BOTTOM w0.076: v2(110.13,55.62) 110.45,55.94 UC1.G20
  BOTTOM w0.102: R246.1 22.1,73.29 L40.1 22.73,73.29 23.1,73.66 23.34,73.66 v2(23.59,73.42)
USB3RN0_D-: length 9.1
  BOTTOM w0.102: JUSB1.5 13.74,72.62 13.85,72.74 14.29,72.74 14.99,73.44 16.13,73.44 16.57,73.88 17.31,73.88 17.46,73.73 D17.1 D17.10 19.32,73.73 19.47,73.88 19.63,73.88 19.91,73.61 20.21,73.61 20.52,73.29 L40.2 21.15,73.29 R246.2
USB3RN1: length 290.1
  TOP w0.102: v2(293.48,168.02) 293.48,168.03 293.78,168.33 293.98,168.33 294.35,167.96 C2966.1
  IN1 w0.097: v2(293.48,168.02) 293.11,168.39 292.59,168.39 292.52,168.32 292.52,166.93 293.43,166.02 293.43,158.4 291.45,156.42 276.12,156.42 274.65,157.9 269.19,157.9 267.73,159.36 264.52,159.36 261.26,162.62 261.26,164.05 260.96,164.35 258.44,164.35 257.76,163.67 246.06,163.67 245.49,163.1 238.86,163.1 237.74,161.98 231.22,161.98 228.05,158.8 201.5,158.8 200.3,157.6 199.03,157.6 195.7,154.28 191.73,154.28 190.16,152.71 178.6,152.71 177.2,151.31 169.71,151.31 164.04,145.64 157.41,145.64 155.19,143.41 155.19,142.33 154.81,141.95 154.81,140.87 153.35,139.41 153.35,135.18 148.73,130.56 147.61,130.56 143.48,126.43 140.19,126.43 134.39,120.63 134.39,118.92 132.9,117.43 132.9,113.76 132.43,113.29 132.43,108.53 132.33,108.43 132.33,104.47 131.04,103.18 131.04,102.61 130.38,101.95 130.38,97.57 130.52,97.43 130.52,92.94 124.46,86.88 121.54,86.88 121.34,86.69 121.34,86.31 120.87,85.84 118.7,85.84 117.61,84.74 116.9,84.74 116.2,84.04 112.28,84.04 109.18,80.93 106.82,80.93 102.91,77.02 102.91,74.01 106.8,70.12 106.8,66.96 106.34,66.49 106.34,60.05 108.33,58.06 108.33,56.44 108.59,56.18 109.6,56.18 109.8,56.38 109.8,56.72 109.69,56.84 109.52,56.84 109.41,56.72 v2(109.41,56.57)
  BOTTOM w0.076: UC1.E18 109.32,56.99 109.43,56.88 109.43,56.59 v2(109.41,56.57)
  BOTTOM w0.102: R2647.2 294.35,167.96 293.98,168.33 293.78,168.33 293.48,168.03 v2(293.48,168.02)
USB3RN1_C: length 3.2
  TOP w0.102: U83.23 v3(296.72,169.03) 296.43,169.03 C2966.2
USB3RN1_R: length 16.7
  TOP w0.102: R2655.1 305.38,169.3 305.6,169.3 v2(305.78,169.11)
  IN1 w0.097: v2(308.89,161.54) 308.71,161.72 308.71,162.05 307.25,163.5 307.25,166.91 305.3,168.86 305.3,169.19 305.41,169.3 305.59,169.3 v2(305.78,169.11)
  BOTTOM w0.102: v2(305.78,169.11) 305.6,169.3 305.37,169.3 R2651.1 ; v2(308.89,161.54) 308.83,161.54 308.7,161.41 308.7,161.31 308.53,161.14 308.53,159.48 308.99,159.02 309.4,158.62 309.66,158.62 309.74,158.69 309.74,158.82 309.82,158.9 JIO1.36
USB3RN1_R_CL: length 9.6
  BOTTOM w0.102: R2651.2 303.79,169.3 302.25,169.3 301.19,168.24 v3(300.32,168.24) 297.62,168.24 297.61,168.23 297.08,168.23 297.07,168.24 295.62,168.24 R2647.1
USB3RN1_RC: length 2.5
  TOP w0.102: R2655.2 303.78,169.31 303.46,169.31 303.45,169.3 302.86,169.3 302.59,169.03 U83.8
USB3RN4: length 151.9
  TOP w0.102: R274.1 167.89,167.28 L55.4 167.89,166.72 168.22,166.38 168.22,163.4 167.8,162.97 167.8,162.37 169,161.17 169,161.16 169.58,160.58 169.58,150.31 v2(169.38,150.11)
  IN1 w0.076: v2(109.48,58.46) 109.7,58.69 109.7,58.76 109.57,58.88 108.31,58.88 106.69,60.5 106.69,65.04 106.67,65.07 106.67,65.08
  IN1 w0.097: 106.67,65.08 106.67,66.24 107.65,67.22 107.65,73.34 108.83,74.52 108.83,78.47 109.24,78.88 109.24,80.28 112.47,83.51 117.42,83.51 119.27,85.36 122.68,85.36 123.61,86.29 124.6,86.29 131,92.69 131,97.63 130.86,97.77 130.86,101.71 132.81,103.66 132.81,108.18 132.92,108.3 132.92,113.06 133.38,113.52 133.38,117.23 135.31,119.16 135.31,120.31 137.22,122.22 137.52,122.22 137.98,122.69 137.98,123.37 140.56,125.95 143.67,125.95 145.22,127.5 146.59,127.5 153.96,134.87 153.96,139.31 155.72,141.07 155.72,143.02 157.28,144.58 164.01,144.58 167.46,148.03 168.65,148.03 169.58,148.96 169.58,149.9 v2(169.38,150.11)
  BOTTOM w0.089: UC1.F15 109.8,58.86 109.48,58.53 v2(109.48,58.46)
USB3RN4_D-: length 4.6
  TOP w0.102: v2(168.91,170.6) 169.09,170.42 169.09,170.19 168.76,169.85 168.51,169.85 168.2,169.54 168.2,169.24 167.89,168.93 L55.3 167.89,168.36 R274.2
  BOTTOM w0.102: v2(168.91,170.6) 169.09,170.78 169.09,170.92 168.95,171.06 JDOCK1.84
USB3RP0: length 104.7
  IN3 w0.089: v2(110.78,55.62) 110.54,55.86 110.54,56.02 110.36,56.2 108.33,56.2 107.99,55.86
  IN3 w0.102: v2(23.59,74.01) 23.66,73.93 25.03,73.93 26.01,72.95 26.01,66.41 27.66,64.76 30.64,64.76 33.92,61.48 35.88,61.48 39.39,65 71.61,65 72.87,63.75 76.12,63.75 77.62,62.25 78.87,62.25 82.6,58.51 83.57,58.51 84.94,57.14 91.74,57.14 92.38,56.51 100.53,56.51 101.85,55.19 107.31,55.19 107.99,55.86
  BOTTOM w0.076: v2(110.78,55.62) 110.78,55.64 111.11,55.97 UC1.H20
  BOTTOM w0.102: v2(23.59,74.01) 23.46,73.88 23.01,73.88 22.75,74.14 L40.4 22.1,74.14 R247.1
USB3RP0_D+: length 9.1
  BOTTOM w0.102: R247.2 21.15,74.14 L40.3 20.52,74.14 20.21,73.82 20,73.82 19.72,74.1 19.47,74.1 19.33,74.23 D17.9 D17.2 17.44,74.23 17.31,74.1 16.48,74.1 16.04,73.65 14.9,73.65 14.2,72.95 13.85,72.95 13.74,73.07 JUSB1.6
USB3RP1: length 289.6
  TOP w0.102: C2967.1 294.08,168.55 293.54,168.55 v2(293.48,168.6)
  IN1 w0.097: v2(293.48,168.6) 292.5,168.6 292.31,168.4 292.31,166.85 293.22,165.94 293.22,158.49 291.37,156.64 276.21,156.64 274.74,158.11 269.28,158.11 267.82,159.57 264.61,159.57 261.47,162.71 261.47,164.14 261.04,164.56 258.35,164.56 257.68,163.88 245.97,163.88 245.4,163.31 238.77,163.31 237.65,162.19 231.13,162.19 227.96,159.02 201.42,159.02 200.21,157.81 198.94,157.81 195.62,154.49 191.64,154.49 190.07,152.92 178.51,152.92 177.11,151.52 169.62,151.52 163.95,145.85 157.33,145.85 154.98,143.5 154.98,142.42 154.6,142.04 154.6,140.96 153.14,139.5 153.14,135.26 148.65,130.78 147.52,130.78 143.39,126.64 140.11,126.64 134.18,120.72 134.18,119 132.69,117.51 132.69,113.85 132.22,113.38 132.22,108.62 132.12,108.51 132.12,104.56 130.83,103.27 130.83,102.69 130.17,102.04 130.17,97.48 130.31,97.34 130.31,93.03 124.37,87.09 121.45,87.09 121.13,86.78 121.13,86.4 120.78,86.05 118.62,86.05 117.53,84.95 116.81,84.95 116.12,84.26 112.2,84.26 109.09,81.14 106.74,81.14 102.7,77.11 102.7,73.92 106.59,70.03 106.59,67.05 106.13,66.58 106.13,59.96 108.15,57.94 108.15,56.37 108.52,56 109.72,56 110.01,56.29 110.01,56.38 v2(110.19,56.56)
  BOTTOM w0.076: v2(110.19,56.56) 109.8,56.95 UC1.F18
  BOTTOM w0.102: R2646.2 294.12,168.55 293.54,168.55 v2(293.48,168.6)
USB3RP1_C: length 3.2
  TOP w0.102: U83.22 297.35,169.53 297.08,169.26 296.35,169.26 295.69,168.6 295.48,168.6 C2967.2
USB3RP1_R: length 17
  TOP w0.102: v2(305.78,169.7) 305.6,169.52 305.38,169.52 R2654.1
  IN1 w0.097: v2(305.78,169.7) 305.59,169.51 305.32,169.51 305.09,169.28 305.09,168.77 307.04,166.83 307.04,163.42 308.5,161.96 308.5,161.72 v2(308.31,161.54)
  BOTTOM w0.102: v2(308.31,161.54) 308.31,159.39 309.12,158.59 309.3,158.4 JIO1.38 ; R2650.1 305.38,169.51 305.59,169.51 v2(305.78,169.7)
USB3RP1_R_CL: length 9.6
  BOTTOM w0.102: R2646.1 295.58,168.46 v3(297.34,168.46) 300.04,168.46 300.05,168.47 300.58,168.47 300.59,168.46 301.1,168.46 302.16,169.52 303.79,169.52 R2650.2
USB3RP1_RC: length 2.3
  TOP w0.102: R2654.2 303.8,169.53 v3(303.11,169.53) U83.9
USB3RP4: length 151.9
  TOP w0.102: R276.1 168.74,167.28 L55.1 168.74,166.72 168.44,166.42 168.44,163.31 168.01,162.89 168.01,162.47 v3(169.33,161.15) 169.8,160.69 169.8,150.27 v2(169.96,150.11)
  IN1 w0.076: v2(110.13,58.46) 109.86,58.73 109.86,58.82 109.64,59.05 108.38,59.05 106.86,60.57 106.86,65.05 106.88,65.07 106.88,65.08
  IN1 w0.097: v2(169.96,150.11) 169.79,149.93 169.79,148.87 168.74,147.82 167.55,147.82 164.1,144.37 157.37,144.37 155.93,142.93 155.93,140.98 154.17,139.22 154.17,134.78 146.68,127.29 145.3,127.29 143.76,125.74 140.65,125.74 138.19,123.29 138.19,122.6 137.6,122.01 137.31,122.01 135.52,120.22 135.52,119.07 133.59,117.14 133.59,113.43 133.13,112.97 133.13,108.21 133.02,108.1 133.02,103.57 131.07,101.62 131.07,97.85 131.21,97.72 131.21,92.6 124.69,86.08 123.7,86.08 122.76,85.14 119.35,85.14 117.51,83.3 112.56,83.3 109.45,80.19 109.45,78.79 109.04,78.38 109.04,74.43 107.86,73.25 107.86,67.17 106.88,66.19 106.88,65.08
  BOTTOM w0.089: v2(110.13,58.46) 110.45,58.79 UC1.G15
USB3RP4_D+: length 4.6
  TOP w0.102: R276.2 168.74,168.36 L55.2 168.74,168.93 168.42,169.24 168.42,169.45 168.6,169.64 168.85,169.64 169.31,170.1 169.31,170.42 v2(169.49,170.6)
  BOTTOM w0.102: JDOCK1.86 169.45,171.02 169.31,170.88 169.31,170.78 v2(169.49,170.6)
USB3TN0: length 111.7
  IN3 w0.102: v2(103.53,46.16) 103.69,46.16 103.78,46.07 103.78,45.99 103.92,45.85 103.92,45.63 103.74,45.46 100.2,45.46 98.55,47.11 95.58,47.11 94.72,47.97 94.72,50.64 93.2,52.15 90.56,52.15 87.03,55.68 84.37,55.68 82.96,57.09 82,57.09 78.33,60.76 77.06,60.76 75.48,62.35 72.11,62.35 71.13,63.33 39.88,63.33 36.42,59.87 33.44,59.87 29.31,64 26.34,64 24.17,66.17 24.17,72.15 23.09,73.23 23.09,74.93 23.76,75.6 24.69,75.6 24.87,75.42 24.98,75.42 25.06,75.34 v2(25.06,75.23)
  BOTTOM w0.076: v2(103.53,46.16) 103.66,46.29 103.66,46.55 103.92,46.82 104.24,46.82 104.47,46.59 105.36,46.59 105.96,47.19 107.3,47.19 107.38,47.27 107.62,47.27 UC1.C33
  BOTTOM w0.102: v2(25.06,75.23) 24.81,75.48 24.38,75.48 24.31,75.4 C292.2
USB3TN0_C: length 1.9
  BOTTOM w0.102: R248.1 21.85,75.07 L41.1 22.41,75.07 22.77,75.43 23.01,75.43 C292.1
USB3TN0_D-: length 10.6
  BOTTOM w0.102: R248.2 20.9,75.07 L41.2 20.27,75.07 19.93,75.4 19.53,75.4 19.36,75.23 D17.7 D17.4 17.37,75.23 17.23,75.37 16.79,75.37 16.36,75.81 16.36,77.41 15.76,78.01 14.93,78.01 14.21,78.73 13.84,78.73 13.74,78.63 JUSB1.8
USB3TN1: length 302.9
  TOP w0.102: C2968.1 294.35,170.08 294.19,170.23 293.8,170.23 v2(293.52,169.95)
  IN1 w0.097: v2(293.52,169.95) 293.25,170.22 292.63,170.22 291.68,169.27 291.68,166.31 292.2,165.79 292.2,158.5 290.81,157.11 276.45,157.11 274.65,158.91 269.19,158.91 267.98,160.12 264.73,160.12 261.95,162.9 261.95,164.33 261.24,165.04 249.49,165.04 248.82,164.37 239.13,164.37 237.42,162.67 230.14,162.67 226.98,159.5 201.23,159.5 200.02,158.3 198.52,158.3 195.26,155.04 191.51,155.04 189.87,153.4 170.78,153.4 163.72,146.34 156.97,146.34 154.43,143.79 154.43,142.59 153.92,142.08 153.92,141 152.65,139.73 152.65,136.24 147.66,131.25 147.21,131.25 143.08,127.13 139.92,127.13 133.7,120.92 133.7,120.16 132.21,118.67 132.21,114.15 131.26,113.19 131.26,104.41 130.28,103.43 130.28,102.86 129.69,102.28 129.69,99.68 129.3,99.28 129.3,97.68 129.83,97.15 129.83,93.23 129.49,92.89 128.16,92.89 127.82,92.55 127.82,92.13 126.4,90.71 126.4,90.01 123.96,87.57 121.14,87.57 120.5,86.92 118.19,86.92 116.84,85.57 116.52,85.57 115.69,84.74 111.97,84.74 109.13,81.91 106.78,81.91 102.22,77.34 102.22,73.64 106.1,69.76 106.1,67.07 105.79,66.75 105.79,59.36 107.7,57.44 107.7,54.18 107.29,53.76 107.29,49.59 105.76,48.06 104.62,48.06 104.47,47.91 104.47,47.79 v2(104.67,47.59)
  BOTTOM w0.076: UC1.B33 106.95,47.49 106.66,47.78 106.02,47.78 105.33,47.09 104.79,47.09 104.67,47.21 v2(104.67,47.59)
  BOTTOM w0.102: v2(293.52,169.95) 293.7,170.13 294.01,170.13 R2652.1
USB3TN1_C: length 3
  TOP w0.102: C2968.2 296.02,170.53 296.3,170.53 296.32,170.51 296.85,170.51 296.86,170.53 U83.20
USB3TN1_RP: length 24.9
  TOP w0.102: v2(304.17,173.08) 303.9,172.8 303.9,172.65 304.27,172.28 R2657.2
  IN1 w0.097: v2(312.51,157.44) 312.31,157.24 311.48,157.24 311.12,157.6 311.12,166.81 307.31,170.62 305.98,170.62 303.99,172.61 303.99,172.9 v2(304.17,173.08)
  BOTTOM w0.102: v2(312.51,157.44) 312.33,157.26 311.49,157.26 311.34,157.4 JIO1.42 ; v2(304.17,173.08) 304.01,172.92 304.01,172.6 R2649.2
USB3TN1_RP_C: length 2.9
  TOP w0.102: U83.11 303.73,170.53 304.09,170.88 304.09,171.12 R2657.1
USB3TN1_RP_CL: length 10.4
  BOTTOM w0.102: R2652.2 295.6,170.13 296.16,170.13 296.73,170.7 297.07,170.7 297.08,170.68 297.61,170.68 297.62,170.7 297.98,170.7 298.48,171.19 v3(300.25,171.19) 301.8,171.19 302.4,170.59 303.8,170.59 303.99,170.79 303.99,171.03 R2649.1
USB3TN4: length 171
  TOP w0.102: v2(170.32,156.66) 170.69,157.02 170.69,159.41 170.98,159.69 170.98,160.91 170.96,160.93 170.96,161.46 170.98,161.47 170.98,163.1 170.83,163.25 170.83,165.13 170.17,165.78 170.17,166.34 169.86,166.65 L56.4 169.86,167.28 R275.1
  IN1 w0.097: v2(170.32,156.66) 170.66,156.32 170.66,154.61 163.3,147.25 156.56,147.25 154.47,145.15 153.33,145.15 152.25,144.07 152.25,141.02 151.66,140.43 151.66,136.7 149,134.05 148.32,134.05 144.65,130.38 143.09,130.38 140.88,128.17 139.68,128.17 132.81,121.29 132.81,120.57 131.31,119.08 131.31,114.56 130.36,113.61 130.36,104.83 129.3,103.77 129.3,103.2 128.8,102.69 128.8,100.16 124.67,96.03 124.67,89.55 123.58,88.47 117.62,88.47 115.8,86.65 111.48,86.65 108.28,83.45 106.88,83.45 101.32,77.89 101.32,72.46 105,68.78 105,58.82 106.53,57.3 106.53,56.38 106.24,56.09 106.24,50.4 104.83,48.99 103.13,48.99 v2(102.97,49.15)
  BOTTOM w0.076: UC1.B31 107.09,48.96 107.09,49.15 106.88,49.36 106.08,49.36 105.69,48.96
  BOTTOM w0.102: 105.69,48.96 103.15,48.96 v2(102.97,49.15)
USB3TN4_D-: length 4.3
  TOP w0.102: R275.2 169.86,168.36 L56.3 169.86,168.92 170.17,169.24 170.17,169.48 170.62,169.92 170.62,170.05 v2(170.43,170.23)
  BOTTOM w0.102: v2(170.43,170.23) 170.62,170.42 170.62,170.92 170.45,171.09 JDOCK1.90
USB3TP0: length 111.9
  IN3 w0.102: v2(25.06,75.82) 23.67,75.82 22.87,75.02 22.87,73.14 23.95,72.06 23.95,66.08 26.25,63.78 29.22,63.78 33.35,59.66 36.51,59.66 39.97,63.11 71.04,63.11 72.02,62.13 75.39,62.13 76.97,60.54 78.24,60.54 81.91,56.87 82.87,56.87 84.28,55.46 86.94,55.46 90.47,51.93 93.11,51.93 94.5,50.55 94.5,47.88 95.49,46.89 98.46,46.89 100.11,45.24 103.83,45.24 104.14,45.54 v2(104.14,46.16)
  BOTTOM w0.076: UC1.B34 107.51,46.72 107.45,46.66 107.28,46.66 107.21,46.73 107.21,46.95 107.15,47 106.04,47 105.47,46.43 104.4,46.43 104.17,46.65 103.99,46.65 103.82,46.49 103.82,46.37 104.04,46.16 v2(104.14,46.16)
  BOTTOM w0.102: C293.2 24.55,75.7 24.94,75.7 v2(25.06,75.82)
USB3TP0_C: length 1.8
  BOTTOM w0.102: R250.1 21.85,75.92 L41.4 22.47,75.92 22.74,75.65 23.1,75.65 C293.1
USB3TP0_D+: length 10.6
  BOTTOM w0.102: JUSB1.9 13.74,79.06 13.85,78.95 14.3,78.95 15.02,78.22 15.85,78.22 16.57,77.5 16.57,75.9 16.88,75.59 17.23,75.59 17.37,75.73 D17.5 D17.6 19.34,75.73 19.45,75.62 19.97,75.62 20.27,75.92 L41.3 20.9,75.92 R250.2
USB3TP1: length 302.7
  TOP w0.102: C2969.1 294.08,170.45 293.6,170.45 v2(293.52,170.53)
  IN1 w0.097: v2(104.03,47.59) 104.26,47.82 104.26,48 104.53,48.27 105.68,48.27 107.08,49.67 107.08,53.85 107.49,54.26 107.49,57.35 105.57,59.27 105.57,66.84 105.89,67.15 105.89,69.67 102.01,73.55 102.01,77.43 106.69,82.12 109.04,82.12 111.88,84.95 115.61,84.95 116.43,85.78 116.75,85.78 118.1,87.13 120.41,87.13 121.06,87.78 123.87,87.78 126.19,90.1 126.19,90.8 127.61,92.22 127.61,92.64 128.07,93.1 129.41,93.1 129.62,93.32 129.62,97.06 129.09,97.59 129.09,99.37 129.48,99.76 129.48,102.37 130.07,102.95 130.07,103.52 131.05,104.5 131.05,113.28 132,114.23 132,118.75 133.49,120.25 133.49,121 139.83,127.34 143,127.34 147.12,131.46 147.58,131.46 152.44,136.33 152.44,139.82 153.71,141.09 153.71,142.17 154.22,142.68 154.22,143.88 156.88,146.55 163.63,146.55 170.69,153.61 189.79,153.61 191.43,155.25 195.17,155.25 198.43,158.51 199.93,158.51 201.14,159.71 226.89,159.71 230.05,162.88 237.34,162.88 239.04,164.58 248.73,164.58 249.4,165.25 261.33,165.25 262.17,164.41 262.17,162.98 264.82,160.33 268.07,160.33 269.28,159.12 274.74,159.12 276.54,157.32 290.72,157.32 291.99,158.59 291.99,165.7 291.47,166.22 291.47,169.36 292.54,170.43 293.42,170.43 v2(293.52,170.53)
  BOTTOM w0.076: v2(104.03,47.59) 104.17,47.59 104.48,47.28 104.48,47.13 104.71,46.9 105.41,46.9 106.1,47.59 106.43,47.59 UC1.A33
  BOTTOM w0.102: R2653.1 294.01,170.34 293.71,170.34 v2(293.52,170.53)
USB3TP1_C: length 3
  TOP w0.102: U83.19 297.4,171.03 297.12,170.74 v3(296.58,170.74) 295.93,170.74 295.67,170.48 295.5,170.48 C2969.2
USB3TP1_RP: length 25.1
  TOP w0.102: v2(303.59,173.08) 303.68,172.99 303.68,172.52 R2656.2
  IN1 w0.097: v2(303.59,173.08) 303.78,172.9 303.78,172.52 305.89,170.4 307.23,170.4 310.91,166.72 310.91,157.51 311.4,157.03 312.34,157.03 v2(312.51,156.86)
  BOTTOM w0.102: v2(303.59,173.08) 303.8,172.88 303.8,172.63 R2648.2 ; JIO1.44 311.34,156.9 311.49,157.04 312.33,157.04 v2(312.51,156.86)
USB3TP1_RP_C: length 2.9
  TOP w0.102: U83.12 302.52,171.03 302.8,170.74 303.64,170.74 303.87,170.97 303.87,171.26 303.77,171.36 R2656.1
USB3TP1_RP_CL: length 10
  BOTTOM w0.102: R2648.1 303.78,171.03 303.78,170.88 303.71,170.81 302.49,170.81 301.89,171.4 300.53,171.4 300.52,171.42 299.99,171.42 299.97,171.4 298.39,171.4 297.89,170.91 v3(297.34,170.91) 296.64,170.91 296.07,170.34 295.6,170.34 R2653.2
USB3TP4: length 171.1
  TOP w0.102: R277.1 170.71,167.34 L56.1 170.71,166.65 170.39,166.34 170.39,165.87 171.04,165.22 171.04,163.34 171.19,163.19 v3(171.19,161.19) 171.19,159.6 170.91,159.32 v2(170.91,156.66)
  IN1 w0.097: v2(102.97,48.56) 103.19,48.78 104.92,48.78 106.45,50.31 106.45,56 106.74,56.29 106.74,57.39 105.21,58.91 105.21,68.87 101.53,72.55 101.53,77.8 106.97,83.24 108.37,83.24 111.57,86.44 115.89,86.44 117.71,88.26 123.67,88.26 124.88,89.47 124.88,95.94 129.01,100.07 129.01,102.61 129.51,103.12 129.51,103.69 130.57,104.74 130.57,113.52 131.53,114.48 131.53,119 133.02,120.49 133.02,121.2 139.77,127.96 140.97,127.96 143.18,130.17 144.73,130.17 148.4,133.84 149.09,133.84 151.87,136.61 151.87,140.35 152.46,140.94 152.46,143.99 153.41,144.94 154.56,144.94 156.65,147.04 163.38,147.04 170.87,154.53 170.87,156.62 v2(170.91,156.66)
  BOTTOM w0.076: 105.97,48.92 106.22,49.17 106.8,49.17 106.9,49.07 106.9,48.96 106.8,48.87 UC1.A31
  BOTTOM w0.102: 105.97,48.92 105.8,48.75 103.15,48.75 v2(102.97,48.56)
