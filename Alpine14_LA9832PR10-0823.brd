# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPC_LANE_P0_C: length 1.1
  BOTTOM w0.089: R259.1 C302.1
DPC_LANE_P1: length 83.4
  TOP w0.089: v2(115.32,103.75) 115.32,104.09 115.53,104.3 116.8,104.3 116.92,104.42 117.48,104.42 U6.B8
  IN1 w0.089: v2(115.32,103.75) 115.32,103.25 115.05,102.98 113.37,102.98 112.46,103.89 112.46,107.37 113.01,107.93 113.01,108.97 113.89,109.84 113.89,116.57 114.81,117.49 114.81,126.16 119.42,130.78 120.89,130.78 121.23,131.12 121.23,132.12 127.79,138.67 127.79,140.3 128.41,140.93 128.41,142.22 132.72,146.52 138.91,146.52 141.82,149.43 141.82,151.19 143.43,152.8 145.89,152.8 146.75,153.67 147.29,153.67 149.31,155.69 149.31,156.05 149.63,156.36 v2(150.17,156.36)
  BOTTOM w0.089: v2(150.17,156.36) 150.51,156.36 150.78,156.63 150.78,157.59 C297.2
DPC_LANE_P1_C: length 1.1
  BOTTOM w0.089: R253.1 C297.1
DPC_LANE_P2: length 80
  TOP w0.089: v2(115.92,105.45) 116.3,105.07 117.48,105.07 U6.B9
  IN1 w0.089: v2(153.73,156.04) 153.6,156.17 152.05,156.17 148.29,152.41 147.27,152.41 145.86,150.99 144.12,150.99 143.1,149.98 143.1,148.9 139.43,145.23 135.96,145.23 131.11,140.38 129.64,140.38 129.2,139.94 129.2,138.3 123.33,132.43 123.33,131.92 122.5,131.1 122.5,130.17 116.62,124.29 116.62,115.1 115.14,113.62 115.14,109.32 114.27,108.44 114.27,106.23 114.07,106.03 114.07,105.2 114.45,104.83 115.7,104.83 115.92,105.05 v2(115.92,105.45)
  BOTTOM w0.089: C304.2 152.71,157.57 152.71,156.56 153.23,156.04 v2(153.73,156.04)
DPC_LANE_P2_C: length 1.1
  BOTTOM w0.089: R257.1 C304.1
DPC_LANE_P3: length 78.4
  TOP w0.089: v2(115.26,105.46) 115.07,105.65 115.07,105.76 115.45,106.15 115.94,106.15 116.24,105.85 116.71,105.85 116.84,105.72 117.48,105.72 U6.B10
  IN1 w0.089: v2(115.26,105.46) 115.2,105.52 115.2,108.06 116.12,108.98 116.12,112.98 117.59,114.46 117.59,123.95 123.45,129.8 123.45,130.73 124.26,131.54 124.26,131.92 124.89,132.55 125.28,132.55 128.12,135.39 128.12,135.91 136.51,144.3 140.6,144.3 143,146.7 143.34,146.7 146.79,150.15 146.79,150.61 147.41,151.24 148.66,151.24 152.13,154.7 153.83,154.7 155.03,155.9 155.5,155.9 v2(155.63,155.78)
  BOTTOM w0.089: C300.2 154.67,157.51 154.67,156.17 155.07,155.78 v2(155.63,155.78)
DPC_LANE_P3_C: length 1.1
  BOTTOM w0.089: R265.1 C300.1
DQMA0: length 27.6
  IN3 w0.114: v2(38.92,92.82) 39.47,92.82 39.8,93.15 41.78,93.15 41.9,93.02 41.9,92.44 42.03,92.32 42.27,92.32 42.39,92.44 42.39,93.02 42.51,93.15 42.76,93.15 42.88,93.02 42.88,92.44 43,92.32 43.25,92.32 43.37,92.44 43.37,93.02 43.49,93.15 43.73,93.15 43.85,93.02 43.85,92.44 43.98,92.32 47.01,92.32 51.51,96.82 55.29,96.82 56.08,96.03 56.08,95.38 57.5,93.95 v4(57.5,93.15)
  BOTTOM w0.102: UV4.E7 38.46,93.28 v2(38.92,92.82) ; v4(57.5,93.15) 57.85,92.8 UV1.D19
DQMA1: length 37.8
  TOP w0.102: UV5.E7 38.49,90.11 v2(38.89,90.5)
  IN1 w0.114: v4(61.56,92.34) 60.97,92.34 60.3,93.02 60.3,93.31 60.06,93.55 59.77,93.55 59.42,93.9 59.42,94.28 56.49,97.21 47.39,97.21 47.27,97.08 47.27,96.35 47.14,96.22 46.94,96.22 46.81,96.35 46.81,97.08 46.68,97.21 46.48,97.21 46.35,97.08 46.35,96.35 46.22,96.22 46.02,96.22 45.89,96.35 45.89,97.08 45.77,97.21 45.54,97.21 45.41,97.08 45.41,96.27 45.3,96.15 45.07,96.15 44.95,96.27 44.95,96.45 44.83,96.57 44.62,96.57 44.5,96.45 44.5,96.27 44.38,96.15 44.17,96.15 43.96,95.94 43.8,95.94 43.52,96.22 43.34,96.22 43.2,96.08 43.2,95.9 43.47,95.62 43.47,95.46 43.31,95.3 43.15,95.3 42.25,96.19 42.07,96.19 41.93,96.05 41.93,95.87 42.83,94.97 42.83,94.81 41.44,93.42 41.44,92.28 39.66,90.5 v2(38.89,90.5)
  BOTTOM w0.122: v4(61.56,92.34) UV1.D14
DQMA2: length 34.8
  TOP w0.102: v4(59.9,93.96) 60.29,94.35 60.84,94.35 61.11,94.62 61.11,95.01 60.4,95.73
  TOP w0.122: 60.4,95.73 60.4,97.17 59.58,97.99 59.58,98.16 59.86,98.45 59.86,98.62 59.69,98.79 59.52,98.79 59.23,98.5 59.06,98.5 58.89,98.68 58.89,98.85 59.17,99.14 59.17,99.31 59,99.48 58.83,99.48 58.54,99.19 58.37,99.19 57.88,99.69 48.76,99.69 45.75,96.67 v1(45.75,96.13) 45.75,94.75 44.1,93.1 42.64,93.1 41.74,92.21 41.44,91.91 41.32,91.79 39.67,91.79 39.48,91.98 39.48,93.09 UV5.D3
  BOTTOM w0.122: v4(59.9,93.96) UV1.C17
DQMA3: length 22.7
  BOTTOM w0.122: UV1.C22 54.94,93.98 54.94,94.51 54.74,94.71 54.74,95.83 53,97.57 48.05,97.57 v1(46.19,95.7) 42.36,91.88 39.56,91.88 39.28,91.59 39.28,90.13 UV4.D3
DQMA4: length 26.9
  IN1 w0.114: v2(38.94,77.07) 39.58,77.07 40.07,77.55 42.86,77.55 42.98,77.44 42.98,76.79 43.1,76.66 43.31,76.66 43.43,76.79 43.43,77.44 43.55,77.55 43.78,77.55 43.89,77.44 43.89,76.79 44.02,76.66 44.22,76.66 44.35,76.79 44.35,77.44 44.46,77.55 44.69,77.55 44.8,77.44 44.8,76.79 44.93,76.66 45.13,76.66 45.26,76.79 45.26,77.35 45.39,77.48 46.03,77.48 46.19,77.64 46.19,77.64 50.07,81.51 50.07,82.19 50.81,82.93 50.97,82.93 51.34,82.57 51.5,82.57 51.66,82.73 51.66,82.89 51.3,83.25 51.3,83.41 51.46,83.58 51.62,83.58 51.98,83.21 52.14,83.21 52.31,83.37 52.31,83.54 51.94,83.9 51.94,84.06 52.33,84.45 UV1.P24 v4(54.07,84.05)
  BOTTOM w0.102: v2(38.94,77.07) 38.47,77.53 UV6.E7
  BOTTOM w0.122: v4(54.07,84.05) UV1.P24
DQMA5: length 19.8
  TOP w0.122: v4(53.27,80.73) 53.27,80.72 52.82,80.26 48.74,80.26 46.24,77.77 46.24,77.6 v1(46.37,77.47) 46.52,77.32 46.52,77.14 46.36,76.97 46.18,76.97 45.9,77.25 45.73,77.25 45.55,77.08 45.55,76.91 45.83,76.63 45.83,76.45 45.67,76.28 45.49,76.28 45.21,76.56 45.04,76.56 44.33,75.86 40.06,75.86 39.6,76.32 39.6,77.24 UV7.D3
  BOTTOM w0.122: UV1.W24 53.67,80.33 v4(53.27,80.73)
DQMA6: length 19.8
  TOP w0.102: v2(38.9,74.75) 38.5,74.36 UV7.E7
  IN3 w0.114: v2(38.9,74.75) 39.52,75.38 43.13,75.38 43.65,75.9 43.82,75.9 44.19,75.54 44.37,75.54 44.53,75.7 44.53,75.88 44.17,76.25 44.17,76.42 44.34,76.59 44.51,76.59 44.86,76.25 45.04,76.25 45.21,76.41 45.21,76.59 44.81,76.99 44.81,77.17 45.03,77.4 45.21,77.4 45.77,76.84 45.97,76.84 46.52,77.38 50.76,77.38 51.08,77.06 51.92,77.06 52.04,77.18 52.04,77.83 v4(52.47,78.26)
  BOTTOM w0.122: v4(52.47,78.26) 52.86,78.65 UV1.AA25
DQMA7: length 19
  BOTTOM w0.122: UV1.U25 52.45,81.55 50.18,81.55 49.95,81.78 49.39,81.78 48.03,80.42 48.03,77.4 46.34,75.7 v1(44.55,75.7) 43.09,75.7 42.98,75.81 40.38,75.81 39.41,74.84 39.41,74.49 UV6.D3
DSCHRG_MOSFET_GC: length 1.9
  TOP w0.254: PU701.29 118.31,140.17 PR559.1
DSWODVREN: length 15
  BOTTOM w0.076: UC1.AW7 128.81,63.39 130.14,63.39 131.33,64.58 131.33,67.04 131.22,67.15
  BOTTOM w0.102: RC73.1 135.19,73.98 RC78.2 134.34,72.7 132.55,70.91 v1(132.55,70.6) 132.55,70.08 132.05,69.59 132.05,69 131.22,68.16 131.22,67.15
DYN_TUR_CURRNT_SET#: length 51.4
  TOP w0.102: v2(112.11,118.29) 112.06,118.29 111.81,118.04 v1(111.66,118.04) ; U38.A35 147.89,109.62 148.35,110.08 148.35,111.64 R363.2 147.61,112.38 147.61,113.21 147.8,113.4 v2(148.07,113.4)
  TOP w0.254: v2(112.11,118.29) 112.37,118.04 112.37,115.61 PQ410.2
  BOTTOM w0.102: v2(148.07,113.4) 147.36,113.4 146.82,113.94 145.13,113.94 144.5,114.57 142.76,114.57 142.12,113.94 135.33,113.94 133.9,115.37 133.9,117.83 133.03,118.69 132.3,118.69 131.23,117.62 127.82,117.62 127.15,118.29 126.34,118.29 124.68,119.94 123.99,119.94 121.64,117.59 119.58,117.59 119.4,117.77 112.64,117.77 v2(112.11,118.29)
EC5048_TX: length 57.9
  TOP w0.102: v2(171.87,129.21) 171.72,129.37 156.88,129.37 156.08,130.16 152.65,130.16 152.31,129.82 149.59,129.82 R397.2 R406.2 ; v2(171.42,101.46) 170.98,101.9 U37.B2
  IN3 w0.102: v2(171.87,129.21) 172.82,128.26 172.82,116.39 173.35,115.86 173.35,110.88 172.5,110.04 170.76,110.04 170.26,109.53 170.26,105.2 169.94,104.88 169.94,103.53 171.42,102.04 v2(171.42,101.46)
EC_32KHZ_ECE5048: length 35.7
  TOP w0.102: v2(137.36,98.37) 137.01,98.72 R379.1 ; U37.B35 163.48,92.64 163.13,92.29 162.59,92.29 161.4,91.1 v2(161.4,90.67)
  BOTTOM w0.102: v2(161.4,90.67) v1(160.52,89.78) 159.14,88.4 152.54,88.4 151.22,89.72 150.75,89.72 149.6,90.87 147.59,90.87 147.09,91.37 145.5,91.37 145.03,90.9 143.31,90.9 142.84,91.37 141.3,91.37 139.76,92.91 139.76,95.71 137.36,98.11 v2(137.36,98.37)
EC_32KHZ_ECE5048_R: length 8.6
  TOP w0.102: v2(137.36,99.27) 137,99.64 R379.2 ; U38.B62 141.44,102.81 v2(141.96,102.29)
  BOTTOM w0.102: v2(141.96,102.29) 141.52,101.85 139.61,101.85 v1(138.11,100.34) 137.36,99.6 v2(137.36,99.27)
EC_WAKE#: length 73.4
  TOP w0.102: U38.B23 149.11,102.31 v2(149.01,102.22) ; v2(136.31,73.83) 135.88,73.83 135.28,74.43 RC211.2 135.01,75 RC206.1 134.4,75.8 v1(134.16,76.04)
  IN2 w0.076: v2(124.91,64.8) 124.91,64.93 125.57,65.59 125.57,66.41 125.77,66.6 127.89,66.6 129.91,68.62 129.91,69.84
  IN2 w0.102: v2(154.09,86.17) 154.09,85.53 153.52,84.95 153.52,83.02 155.73,80.81 155.73,80.41 155.75,80.38 155.75,76.78 153.44,74.46 141.83,74.46 141.2,73.83 138.23,73.83 137.77,74.29 136.77,74.29 v2(136.31,73.83) 136.31,73.54 135.55,72.77 132.92,72.77 132.82,72.67 131.69,72.67 129.91,70.9 129.91,69.84
  IN3 w0.102: v2(149.01,102.22) 149.15,102.22 151.18,100.19 152.37,100.19 152.71,99.86 152.71,98.75 152.06,98.1 152.06,95.58 153.01,94.63 153.01,91.86 154.05,90.82 154.05,88.57 154.09,88.53 v2(154.09,86.17)
  BOTTOM w0.089: UC1.AN5 124.61,64.5 v2(124.91,64.8)
EDID_CLK: length 17.6
  TOP w0.102: R2582.1 97.85,109.96 97.85,111.17 98.02,111.33 98.17,111.33 v2(98.29,111.2) 98.46,111.37 U52.46 ; R2600.2 89.94,115.54 89.94,115.32 v2(90.12,115.14)
  IN3 w0.102: v2(90.12,115.14) 89.94,115.32 89.94,115.68 90.27,116.01 95.48,116.01 97.09,114.39 97.09,112.09 97.8,111.38 98.12,111.38 v2(98.29,111.2)
EDID_CLK_LCD: length 11
  TOP w0.102: R2600.1 89.93,117.12 89.93,117.63 91.89,119.59 92.72,119.59 93.38,120.25 93.38,122.83 93.89,123.33 94.68,123.33 95.09,122.92 JLVDS1.36
EDID_DATA: length 18.5
  TOP w0.102: v2(89.53,115.14) 89.71,115.32 89.71,115.54 R2599.2 ; R2584.1 97.62,109.91 97.62,111.26 97.92,111.56 98.07,111.56 v2(98.29,111.79) 98.49,111.6 99.51,111.6 99.68,111.77 U52.45
  IN3 w0.102: v2(98.29,111.79) 98.12,111.61 97.89,111.61 97.32,112.18 97.32,114.49 95.57,116.23 90.18,116.23 89.71,115.77 89.71,115.32 v2(89.53,115.14)
EDID_DATA_LCD: length 11.3
  TOP w0.102: R2599.1 89.7,117.1 89.7,117.72 v3(90.49,118.51) 91.79,119.82 92.62,119.82 93.15,120.35 93.15,122.92 93.8,123.56 94.78,123.56 94.92,123.42 JLVDS1.35
EDP_BIA_PWM: length 80.6
  TOP w0.102: v2(100.11,67.81) v1(100.11,67.11) 100.11,66.91 101.66,65.36 102.47,65.36 v2(103.24,64.58) ; v2(106.65,103.69) 106.92,103.95 R2577.2 RC33.2
  IN2 w0.102: v2(87.41,66.68) 87.34,66.68 86.46,67.56 86.46,69.14 85.95,69.65 85.95,70.03 87.16,71.24 87.16,79.24 87.48,79.56 87.48,85.72 90.72,88.95 93.26,88.95 94.78,90.48 v2(102.59,90.48)
  IN3 w0.102: v2(100.11,67.81) 98.25,67.81 97.8,67.36 95.67,67.36 94.67,66.35 87.74,66.35 v2(87.41,66.68)
  BOTTOM w0.076: UC1.B8 107.12,62.39 106.29,62.39 104.49,64.19 103.63,64.19 v2(103.24,64.58)
  BOTTOM w0.102: v2(102.59,90.48) 104.43,92.32 104.43,97.97 102.44,99.97 102.44,102.26 103.19,103.01 105.98,103.01 v2(106.65,103.69)
EDP_BIA_PWM_R: length 13.9
  TOP w0.102: v1(108,106.85) 107.8,107.05 v2(107.29,107.05) 107.35,106.99 RC33.1 ; v2(107.86,115.46) 107.86,115.44 107.19,114.76 107.19,114.29 106.66,113.77 U52.21
  BOTTOM w0.102: v2(107.29,107.05) 107.29,107.88 106.72,108.45 106.72,114.35 107.82,115.46 v2(107.86,115.46)
EDP_COMP: length 4
  TOP w0.508: RC134.2 109.52,54.67 v1(109.45,54.74) 108.81,55.38 v2(108.81,55.61)
  BOTTOM w0.254: UC1.D20 108.32,56.09 v2(108.81,55.61)
EDP_CPU_AUX: length 81.6
  TOP w0.102: v2(102.18,103.89) 101.91,104.17 v3(101.91,105.05) 101.91,106.23 C449.2
  IN1 w0.097: v2(104.24,39.45) 104.03,39.66 104.03,39.87 96.28,47.62 95.2,47.62 94.7,48.12 94.7,54.46 95.41,55.17 95.41,58.6 94.53,59.49 94.53,62.86 93.11,64.27 93.11,73.6 92.06,74.65 92.06,76.29 92.46,76.69 92.46,86.02 96.56,90.12 96.56,92.26 101.99,97.69 101.99,103.71 v2(102.18,103.89)
  BOTTOM w0.076: v2(104.24,39.45) 104.1,39.59 104.1,39.71 104.21,39.82 104.54,39.82 104.69,39.67 106.66,39.67 106.95,39.96 UC1.B45
EDP_CPU_AUX#: length 81.5
  TOP w0.102: C450.2 101.69,106.41 101.69,105.32 101.68,105.31 101.68,104.78 101.69,104.77 101.69,103.99 v2(101.6,103.89)
  IN1 w0.097: v2(103.59,39.45) 103.82,39.68 103.82,39.78 96.19,47.41 95.11,47.41 94.49,48.03 94.49,54.54 95.2,55.26 95.2,58.51 94.31,59.4 94.31,62.77 92.9,64.18 92.9,73.51 91.85,74.57 91.85,76.37 92.25,76.77 92.25,86.11 96.35,90.21 96.35,92.35 101.78,97.78 101.78,103.71 v2(101.6,103.89)
  BOTTOM w0.076: UC1.A45 106.54,40.12 106.45,40.2 106.32,40.2 105.98,39.86 104.77,39.86 104.62,40.01 104.13,40.01 103.91,39.79 103.91,39.63 103.73,39.45 v2(103.59,39.45)
EDP_CPU_AUX#_C: length 2.4
  TOP w0.102: U52.3 101.76,109.24 101.85,109.15 101.85,108.83 101.84,108.81 101.84,108.31 101.85,108.3 101.85,107.98 C450.1
EDP_CPU_AUX_C: length 2.4
  TOP w0.102: C449.1 102.07,107.84 v3(102.07,108.58) 102.07,109.15 102.16,109.24 U52.4
EDP_CPU_HPD: length 58.1
  TOP w0.102: v2(99.22,109.47) 99.8,109.47 100.05,109.21 100.81,109.21 100.96,109.36 U52.1
  IN3 w0.102: v2(99.22,109.47) 99.61,109.47 99.8,109.27 99.8,108.26 98.91,107.37 98.91,105.25 98.07,104.41 98.07,101.83 100.02,99.88 v2(100.49,99.88)
  BOTTOM w0.076: UC1.D6 108.02,64.14 108.02,64.56 107.85,64.73 106.98,64.73 106.73,64.99 106.4,64.99 106.19,65.19 106.19,65.35 105.43,66.11 105.39,66.11
  BOTTOM w0.102: 105.39,66.11 104.26,67.24 102.84,67.24 102.75,67.33 102.75,68.15 101.38,69.52 RC158.1 101.02,74.45 v1(101.1,74.54) 101.34,74.77 101.34,80.76 101.14,80.95 101.14,83.1 99.99,84.26 99.99,89.15 102.84,92 102.84,95.38 101.32,96.9 101.32,99.05 v2(100.49,99.88)
EDP_CPU_LANE_N0: length 86.9
  TOP w0.102: v2(103.58,103.89) 103.39,104.08 103.39,104.42 C446.2
  IN1 w0.097: v2(103.4,38.05) 103.62,38.27 103.62,38.41 103.52,38.52 103.07,38.52 102.38,39.21 102.38,40.22 95.91,46.69 94.83,46.69 93.45,48.08 93.45,54.52 94.44,55.51 94.44,58.26 93.11,59.59 93.11,62.9 92.21,63.79 92.21,71.61 91.58,72.25 91.58,73.5 91.16,73.92 91.16,85.99 95.66,90.49 95.66,92.67 99.84,96.85 99.84,103.11 101.37,104.64 103.1,104.64 103.39,104.35 103.39,104.08 v2(103.58,103.89)
  BOTTOM w0.076: UC1.C45 107.57,39.69 107.33,39.69 107.14,39.51 105.63,39.51 104.79,38.67 103.83,38.67 103.57,38.41 103.57,38.22 v2(103.4,38.05)
EDP_CPU_LANE_N0_C: length 4.4
  TOP w0.102: C446.1 103.39,106 103.39,107.63 103.64,107.88 v3(103.64,108.58) 103.64,109 103.76,109.11 U52.8
EDP_CPU_LANE_N1: length 90.1
  TOP w0.102: C448.2 104.79,106.32 104.79,105.09 v2(104.98,104.91)
  IN1 w0.097: v2(104.98,104.91) 104.79,105.1 104.79,105.36 104.52,105.63 103.15,105.63 102.85,105.33 101.05,105.33 99.08,103.35 99.08,97.11 94.97,93 94.97,90.78 90.47,86.28 90.47,73.63 90.88,73.21 90.88,71.34 90.64,71.1 90.64,66.28 91.24,65.69 91.24,63.75 92.28,62.71 92.28,59.34 92.73,58.89 92.73,47.8 94.73,45.81 95.82,45.81 101.7,39.92 101.7,38.25 v2(101.5,38.05)
  BOTTOM w0.076: UC1.A47 106.38,38.68 106.27,38.68 106.21,38.74 106.21,38.87 106.14,38.94 106.03,38.94 104.43,37.34 102.07,37.34 101.78,37.63 101.78,37.95 101.67,38.05 v2(101.5,38.05)
EDP_CPU_LANE_N1_C: length 2.5
  TOP w0.102: C448.1 104.8,107.9 104.8,108.21 104.56,108.45 U52.10
EDP_CPU_LANE_P0: length 86.2
  TOP w0.102: C445.2 103.18,104.42 103.18,104.08 v2(102.99,103.89)
  IN1 w0.097: v2(104.04,38.05) 103.83,38.25 103.83,38.5 103.6,38.73 103.16,38.73 102.59,39.3 102.59,40.31 95.99,46.9 94.92,46.9 93.66,48.17 93.66,54.43 94.65,55.43 94.65,58.35 93.32,59.68 93.32,62.98 92.42,63.88 92.42,71.7 91.79,72.34 91.79,73.58 91.37,74 91.37,85.9 95.87,90.41 95.87,92.59 100.05,96.77 100.05,103.02 101.46,104.43 103.01,104.43 103.18,104.26 103.18,104.08 v2(102.99,103.89)
  BOTTOM w0.076: UC1.B46 107.64,39.27 107.64,39.06 107.57,39 107.44,39 107.12,39.32 105.7,39.32 104.86,38.47 103.91,38.47 103.76,38.33 103.76,38.13 103.84,38.05 v2(104.04,38.05)
EDP_CPU_LANE_P0_C: length 4.4
  TOP w0.102: C445.1 103.18,106 103.18,107.72 103.43,107.97 103.43,108.3 103.42,108.31 103.42,108.77 103.43,108.78 103.43,109.04 103.36,109.11 U52.7
EDP_CPU_LANE_P1: length 89.5
  TOP w0.102: C447.2 104.58,106.32 104.58,105.09 v2(104.39,104.91)
  IN1 w0.097: v2(104.39,104.91) 104.58,105.1 104.58,105.27 104.44,105.42 103.24,105.42 102.94,105.12 101.14,105.12 99.29,103.27 99.29,97.02 95.18,92.91 95.18,90.69 90.68,86.19 90.68,73.71 91.09,73.3 91.09,71.26 90.86,71.02 90.86,66.37 91.45,65.78 91.45,63.84 92.49,62.79 92.49,59.43 92.95,58.97 92.95,47.89 94.82,46.02 95.9,46.02 101.91,40.01 101.91,38.27 v2(102.13,38.05)
  BOTTOM w0.076: UC1.B47 106.95,38.84 106.66,39.13 105.95,39.13 104.35,37.54 102.15,37.54 101.97,37.71 101.97,37.89 v2(102.13,38.05)
EDP_CPU_LANE_P1_C: length 2.5
  TOP w0.102: C447.1 104.58,107.92 104.58,108.12 104.34,108.36 104.34,109.03 104.16,109.21 U52.9
EN: length 11.5
  TOP w0.102: PR65.2 188.26,148.8 v1(187.92,149.14)
  TOP w0.203: PU51.6 189.67,141.15 189.48,140.96 v2(189.01,140.96) ; v2(188.51,144.9) 188.89,145.28 189.36,145.28 189.67,144.96 PU51.20
  TOP w0.254: v2(188.51,144.9) 188.51,146.05 188.25,146.31 PC70.1 188.26,147.01 PR65.2
  IN2 w0.508: v2(189.01,140.96) 189.01,144.39 v2(188.51,144.9)
EN_1.5VRUN: length 7
  BOTTOM w0.102: v1(271.58,163.63) 271.17,164.04 PC206.1
  BOTTOM w0.254: PU200.5 269.32,168.27 269.49,168.43 270.97,168.43 271.17,168.23 PR206.2 PR203.2 PR205.1 PC206.1
EN_+V1.05SP: length 4.4
  TOP w0.102: v1(150.67,75.77) 151.29,75.77 v2(151.29,75.76)
  TOP w0.254: PR153.2 PR154.2 PC157.1 151.36,75.7 v2(151.29,75.76)
  BOTTOM w0.203: v2(151.29,75.76) 151.51,75.98 PU150.28
EN_+VDDRP: length 4
  BOTTOM w0.254: PU700.3 33.98,31.04 v2(33.62,31.41) 33.03,31.99 PC708.1 PR703.2 PR704.2
EN_DK_PWRBAR: length 3.4
  TOP w0.254: PU701.17 126.57,140.17 126.95,140.55 v1(127.24,140.55) 128.06,140.55 PR552.1 PR556.1
EN_DOCK_PWR_BAR: length 90.8
  TOP w0.102: U37.B37 164.48,93.32 164.56,93.4 164.56,93.85 v2(164.97,94.27) ; v2(156.5,139.56) 156.5,139.98 v1(156.9,140.38)
  TOP w0.254: v2(129.96,141.34) 129.96,141.2 129.15,140.39 PR552.2
  IN3 w0.102: v2(164.97,94.27) 164.57,93.86 164.57,93.28 163.12,91.84 158.96,91.84 158.15,92.64 158.15,98.33 157.97,98.51 157.97,99.09 156.77,100.3 156.77,106.22 155.68,107.31 155.1,107.31 154.2,108.21 154.2,111.7 153.58,112.32 153.58,114.35 152.67,115.26 152.67,119.41 153.14,119.88 153.14,124.26 153.77,124.9 153.77,131.12 154.28,131.63 154.28,136.66 156.5,138.89 v2(156.5,139.56)
  BOTTOM w0.102: v2(129.96,141.34) 141.99,141.34 143.99,139.34 156.28,139.34 v2(156.5,139.56)
EN_I2S_NB_CODEC#: length 132.4
  TOP w0.102: v2(164.06,93.65) 163.98,93.58 U37.B36
  IN2 w0.102: v2(164.06,93.65) 164.25,93.65 164.53,93.93 164.53,94.39 165.05,94.91 170.89,94.91 171.03,94.77 171.77,94.77 172.22,95.22 172.22,97.37 173.08,98.23 174.32,98.23 178,101.91 178,102.33 180.38,104.7 180.38,107.88 183.3,110.8 183.3,112.51 184.89,114.11 184.89,120.71 191.71,127.52 196.67,127.52 197.2,126.99 197.2,125.85 197.71,125.34 207.36,125.34 208.69,126.66 210.51,126.66 217.58,133.72 218.79,133.72 225.25,140.17 225.76,140.17 226.32,140.74 226.32,141.27 227.3,142.25 227.3,143.56 237.37,153.63 237.37,154.23 239.03,155.89 239.03,158.17 239.79,158.93 240.98,158.93 242.12,157.79 249.66,157.79 250.84,156.6 v2(250.84,155.59)
  BOTTOM w0.102: v2(164.06,93.65) 164.12,93.65 v1(164.76,93.02) ; v2(250.84,155.59) 250.97,155.46 U17.48
EN_INVPWR: length 149.8
  TOP w0.102: U38.A25 151.28,104.06 151.78,104.57 151.78,105.06 152.33,105.61 v2(152.79,105.61) 152.79,105.85 152.16,106.48 152.16,107.41 152.88,108.13 R371.2
  IN3 w0.102: v2(152.79,105.61) 152.29,105.1 152.29,104.24 151.8,103.75 151.5,103.75 151.43,103.81 149.83,103.81 149.51,104.13 147.93,104.13 146.98,103.18 144.82,103.18 143.99,102.35 143.99,99.11 142.91,98.04 142.91,97.41 142.65,97.15 141.07,97.15 140.75,97.46 137.64,97.46 136.24,98.86 133.32,98.86 131.36,96.89 125,96.89 123.98,95.88 115.35,95.88 114.13,94.65 114.13,93.38 113.38,92.64 113.38,91.6 113.1,91.32 110.96,91.32 103.62,98.66 102.73,98.66 99.41,101.97 99.41,107.12 100.37,108.07 100.37,114.47 97.45,117.4 97.45,122.1 95.22,124.32 95.22,124.32 94.02,125.53 94.02,140.33 88.42,145.92 88.42,152.54 86.52,154.44 84.12,154.44 83.29,155.28 83.29,159.82 v2(82.02,161.09)
  BOTTOM w0.102: Q125.5 85.86,161.22 85.62,161.46 v1(85.13,161.46) 82.38,161.46 v2(82.02,161.09)
EN_LCDPWR: length 6.9
  TOP w0.102: U33.4 92.81,99.43 93.32,98.92 93.32,97.01 R2678.1 93.03,95.92 D76.1 92.47,95.18 v1(92.01,94.72)
ENVDD_PCH: length 122.8
  TOP w0.102: U86.2 97.76,93.97 98.02,93.72 v2(98.72,93.72) ; v2(165.01,93.65) 164.98,93.63 U37.B38
  IN2 w0.102: v2(104.07,65.74) 103.71,66.1 100.59,66.1 99.59,67.09 99.59,68.75 98.02,70.33 98.02,80.11 98.35,80.44 98.35,81.68 98.64,81.97 v2(98.64,82.67) 100.28,84.31 101.5,84.31 103.29,86.1 105.38,86.1 108.61,89.32 117.49,89.32 118.28,90.11 139.92,90.11 140.12,89.91 147.4,89.91 150.16,92.67 150.16,94.45 150.57,94.86 155.8,94.86 156.97,96.03 v2(156.97,96.42)
  IN3 w0.102: v2(156.97,96.42) 157.9,95.49 157.9,92.57 158.89,91.58 163.32,91.58 165.01,93.27 v2(165.01,93.65)
  BOTTOM w0.076: v2(104.07,65.74) 104.34,65.74 105.9,64.18 106.08,64 106.86,64 107.06,63.8 107.37,63.8 UC1.C6
  BOTTOM w0.102: RC152.2 v1(103.15,66.15) 103.66,66.15 v2(104.07,65.74) ; v2(98.72,93.72) 98.72,90.29 98.02,89.59 98.02,84.19 98.64,83.57 v2(98.64,82.67)
ERC1: length 2.6
  TOP w0.254: PU701.3 122.03,135.03 122.15,134.92 122.15,133.85 PC512.1
ERC2: length 2.5
  TOP w0.254: PC514.1 127.44,137.72 v1(127.3,137.86) 126.99,138.17 PU701.13
ERC3: length 3.9
  TOP w0.102: PC513.1 127.99,136.45 128.49,135.96 v1(128.49,135.37)
  TOP w0.254: PC513.1 126.89,137.67 PU701.12
EXP_PRX_EXPTX_N6: length 103
  TOP w0.102: R2659.2 157.96,132.66 157.96,132.8 v2(158.13,132.96) 158.13,133.43 R60.2
  IN1 w0.097: v2(158.13,132.96) 157.94,132.77 157.94,131.87 152.62,126.56 150.86,126.56 148.77,124.47 148.77,123.33 147.32,121.88 144.35,121.88 138.76,116.29 137.9,116.29 137.21,115.6 137.21,111.44 139.35,109.3 139.35,107.32 138.89,106.86 138.02,106.86 137.39,106.23 137.39,103.37 136.98,102.96 136.98,100.4 135.04,98.46 133.97,98.46 133.35,97.84 133.35,91.64 126.05,84.35 126.05,83.81 125.37,83.13 124.45,83.13 123.96,82.64 120.49,82.64 119.95,82.09 119.95,81.72 118.73,80.51 114.34,80.51 112.81,78.98 112.81,75.85 113.04,75.62 113.04,74.28 110.91,72.15 110.91,70.96 110.53,70.57 110.53,65.4 110.06,64.93 109.46,64.93 109.27,64.74 109.27,64.35 109.41,64.22 v2(109.48,64.22)
  BOTTOM w0.076: UC1.F5 109.48,64.29 v2(109.48,64.22)
EXP_PRX_EXPTX_N6_CL: length 15
  TOP w0.102: R2663.2 168.74,132.29 168.74,132.46 168.85,132.57 169.25,132.57 169.38,132.44 169.44,132.38 169.44,131.56 168.76,130.88 v3(166.33,130.88) 160.81,130.88 160.79,130.9 160.26,130.9 160.25,130.88 158.01,130.88 157.85,131.04 157.85,131.56 157.91,131.63 158.08,131.63 R2659.1
EXP_PRX_EXPTX_N6_M: length 3.8
  TOP w0.102: U91.7 159.99,134.56 159.8,134.75 v3(159.26,134.75) 158.95,134.75 158.68,135.02 157.91,135.02 157.85,134.95 157.85,134.57 157.92,134.5 R60.1
EXP_PRX_EXPTX_P6: length 103
  TOP w0.102: R2658.2 157.75,132.69 157.75,132.76 v2(157.54,132.96) 157.54,133.43 R56.2
  IN1 w0.097: v2(108.82,64.22) 109.06,64.46 109.06,64.83 109.37,65.14 109.98,65.14 110.32,65.48 110.32,70.66 110.7,71.04 110.7,72.24 112.83,74.37 112.83,75.54 112.6,75.77 112.6,79.07 114.25,80.72 118.64,80.72 119.73,81.81 119.73,82.18 120.4,82.85 123.87,82.85 124.36,83.34 125.28,83.34 125.84,83.9 125.84,84.43 133.14,91.73 133.14,97.93 133.88,98.67 134.95,98.67 136.77,100.49 136.77,103.05 137.18,103.46 137.18,106.32 137.93,107.07 138.8,107.07 139.14,107.41 139.14,109.22 137,111.36 137,115.69 137.81,116.5 138.67,116.5 144.27,122.09 147.24,122.09 148.56,123.42 148.56,124.56 150.78,126.77 152.53,126.77 157.73,131.96 157.73,132.78 v2(157.54,132.96)
  BOTTOM w0.076: UC1.E5 109.15,64.55 v2(108.82,64.22)
EXP_PRX_EXPTX_P6_CL: length 15
  TOP w0.102: R2658.1 157.63,131.18 157.63,130.95 157.92,130.67 v3(160.53,130.67) 166.05,130.67 166.07,130.65 166.6,130.65 166.61,130.67 168.85,130.67 169.66,131.47 169.66,132.46 169.53,132.59 169.34,132.78 169.14,132.78 R2662.2
EXP_PRX_EXPTX_P6_M: length 3.8
  TOP w0.102: U91.6 160,135.06 159.9,134.97 159.54,134.97 159.52,134.98 159.03,134.98 158.77,135.23 157.82,135.23 157.63,135.04 157.63,134.74 R56.1
EXP_PTX_EXPRX_N6: length 127.9
  TOP w0.102: R2661.2 156.43,136.05 156.61,136.05 v2(156.76,135.91) 156.9,136.05 157.08,136.05 R51.2
  IN1 w0.097: v2(102.31,58.66) 102.4,58.66 102.71,58.96 102.71,59.14 102.2,59.64 102.2,60.54 103.29,61.63 103.29,63.03 104.43,64.17 104.43,68.23 100.63,72.03 100.63,78.79 106.19,84.34 108.19,84.34 111.2,87.35 115.48,87.35 117.29,89.16 121.75,89.16 123.97,91.37 123.97,96.3 128.1,100.43 128.1,103.01 128.61,103.53 128.61,104.1 129.67,105.16 129.67,114.74 130.6,115.67 130.6,119.5 132.02,120.93 132.02,121.49 139.94,129.41 140.42,129.41 142.67,131.66 144.02,131.66 148.77,136.41 149.42,136.41 v2(149.59,136.59)
  BOTTOM w0.076: v2(102.31,58.66) 102.31,58.02 102.55,57.78 103.4,57.78 103.59,57.59 105.17,57.59 105.38,57.8 106.65,57.8 106.99,57.46 107.3,57.46 107.6,57.16 107.8,57.16 107.85,57.21 107.85,57.4 UC1.C17
  BOTTOM w0.102: v2(156.76,135.91) 156.93,136.08 157.12,136.08 157.36,135.84 157.36,135.34 156.5,134.48 152.07,134.48 150.33,136.22 149.96,136.22 v2(149.59,136.59)
EXP_PTX_EXPRX_N6_CL: length 26.5
  TOP w0.102: R2664.2 168.63,134.18 168.63,134.28 168.69,134.34 169.51,134.34 170.14,133.71 170.14,131.16 169.09,130.1 164.63,130.1 164.62,130.12 164.08,130.12 164.07,130.1 v3(158.66,130.1) 157.57,130.1 155.94,131.73 155.94,134.14 154.53,135.55 154.53,135.96 154.76,136.19 155.4,136.19 155.47,136.11 155.47,136.01 R2661.1
EXP_PTX_EXPRX_N6_M: length 2.6
  TOP w0.102: R51.1 158.55,136.01 158.91,136.01 159.21,135.72 159.73,135.72 159.89,135.56 U91.5
EXP_PTX_EXPRX_P6: length 127.7
  TOP w0.102: R2660.2 156.29,136.49 v2(156.76,136.49) 157.23,136.49 R50.2
  IN1 w0.097: v2(149.59,136) 149.39,136.2 148.86,136.2 144.11,131.45 142.76,131.45 140.51,129.2 140.03,129.2 132.23,121.4 132.23,120.84 130.81,119.42 130.81,115.59 129.88,114.66 129.88,105.07 128.83,104.01 128.83,103.44 128.31,102.92 128.31,100.34 124.18,96.22 124.18,91.29 121.84,88.95 117.38,88.95 115.57,87.13 111.29,87.13 108.28,84.13 106.27,84.13 100.84,78.7 100.84,72.12 104.64,68.32 104.64,64.08 103.5,62.95 103.5,61.54 102.41,60.45 102.41,59.73 102.92,59.22 v2(102.92,58.66)
  BOTTOM w0.076: v2(102.92,58.66) 102.81,58.66 102.47,58.32 102.47,58.09 102.62,57.94 103.47,57.94 103.66,57.75 105.1,57.75 105.34,57.99 106.69,57.99 107.06,57.62 107.39,57.62 107.59,57.82 108.24,57.82 UC1.D17
  BOTTOM w0.102: v2(156.76,136.49) 156.95,136.3 157.21,136.3 157.58,135.93 157.58,135.25 156.59,134.26 151.98,134.26 150.24,136 v2(149.59,136)
EXP_PTX_EXPRX_P6_CL: length 26.6
  TOP w0.102: R2660.1 154.98,136.4 154.67,136.4 154.32,136.05 154.32,135.46 155.73,134.05 155.73,131.64 157.48,129.89 158.38,129.89 158.39,129.87 158.93,129.87 158.94,129.89 v3(164.35,129.89) 169.18,129.89 170.36,131.07 170.36,133.8 169.6,134.56 169.14,134.56 R2665.2
EXP_PTX_EXPRX_P6_M: length 2.6
  TOP w0.102: R50.1 158.71,136.22 159,136.22 159.3,135.93 159.74,135.93 159.87,136.06 U91.4
EXPCLK_REQ#: length 253.1
  TOP w0.076: v2(116.2,64.61) 116.2,64.79 116.72,65.32 116.72,69.8 116.69,69.84
  TOP w0.102: 116.69,69.84 116.69,69.86 RC187.2 ; v2(93.65,22.62) 93.55,22.72 90.88,22.72 90.56,23.05 JEXP1.31 90.56,24.33 90.08,24.81 90.08,25.76 CE20.1 ; v2(160.69,82.48) 160.69,82.1 v1(160.89,81.9)
  IN2 w0.076: v2(116.2,64.61) 116.2,64.7 116.21,64.71 116.21,66.5 115.77,66.94 115.44,66.94 114.56,67.82 114.56,69.56 114.29,69.84
  IN2 w0.102: v2(146.47,85.93) 146.47,86 145.15,87.32 141.95,87.32 141.11,88.15 135.21,88.15 134.63,87.57 130.86,87.57 130.1,88.33 125.37,88.33 124.45,87.42 121.23,87.42 120.52,88.13 119.48,88.13 119.16,87.81 119.16,87.49 118.6,86.92 117.45,86.92 117.33,87.04 116.84,87.04 116.11,86.31 114.04,86.31 113.77,86.04 113.77,85.28 111.15,82.66 111.15,78.79 111.12,78.76 111.12,77.89 110.99,77.76 110.99,76.48 113.44,74.04 113.44,72.48 113.6,72.32 113.6,70.53 114.29,69.84 ; v2(160.69,82.48) 160.69,81.59 159.33,80.23 159.33,76.43 158.6,75.69 158.6,72.68 155.9,69.99 155.9,69 156.41,68.49 156.41,51.45 155.28,50.32 155.28,19.17 151.92,15.8 131.63,15.8 128.41,19.02 120.43,19.02 118.67,17.26 116.15,17.26 115.01,18.41 111.86,18.41 111.16,19.1 110.15,19.1 109.64,18.6 109.64,18.03 109.08,17.46 106.38,17.46 105.34,18.5 103.9,18.5 103.7,18.7 103.18,18.7 102.72,19.16 102.72,20.17 100.79,22.1 97.52,22.1 97.13,21.71 94.29,21.71 93.65,22.35 v2(93.65,22.62)
  BOTTOM w0.102: R488.1 104.01,4.75 R170.2 103.33,5.41 102.35,6.38 U93.3 102.35,7.9 v2(101.4,8.86) 99.45,10.8 99.45,18.47 97.74,20.18 97.74,22.58 96.91,23.41 94.44,23.41 v2(93.65,22.62) ; v2(146.47,85.93) 149.9,82.5 153.11,82.5 153.58,82.03 156.58,82.03 157.2,82.66 160.51,82.66 v2(160.69,82.48)
EXPRCRD_STBY_R#: length 2.3
  TOP w0.102: JEXP1.29 91.06,24.33 90.77,24.62 v1(90.77,24.86) 90.77,25.49 R734.2
EXPRESS_DET#: length 224.3
  TOP w0.102: v2(163.87,104.49) 163.87,104.64 163.31,105.2 R419.2 ; JEXP1.27 91.56,24.55 v2(91.35,24.76) 91.35,25.12 CE22.1 ; U37.B15 164.48,101.67 164.82,101.34 v2(165.2,101.34) ; v1(162.13,141.06) 161.77,140.71 v2(161.77,140.26) 161.31,139.81 161.31,139.63 R37.2
  IN1 w0.097: v2(101.65,6.25) 101.65,6.41 100.97,7.09 100.97,10.98 99.97,11.97 v2(99.97,14.58) ; v2(161.9,85.21) 164.23,87.54 164.23,91.54 165.64,92.95 165.64,94.74 165.23,95.15 165.23,99.97 165.71,100.45 165.71,101.08 165.45,101.34 v2(165.2,101.34) 165.07,101.34 164.69,101.72 164.69,103.66 v2(163.87,104.49)
  IN2 w0.102: v2(91.35,24.76) 91.35,24 94.15,21.2 96.51,21.2 99.59,18.12 99.59,14.97 v2(99.97,14.58) 100.22,14.34 102.55,14.34 103.48,15.27 111.59,15.27 111.73,15.42 121.04,15.42 121.93,16.31 129.2,16.31 130.34,15.17 138.98,15.17 140.06,14.09 150.85,14.09 155.74,18.98 155.74,50.13 156.87,51.26 156.87,64.45 158.15,65.74 158.15,70.73 159.05,71.63 159.05,75.5 159.79,76.24 159.79,79.65 161.58,81.44 161.58,84.89 v2(161.9,85.21)
  IN3 w0.102: v2(161.77,140.26) 160.79,140.26 160.17,139.64 160.17,131.64 162.91,128.9 162.91,125.76 162.7,125.54 162.7,121.37 163.09,120.97 163.09,118.61 165.96,115.74 165.96,107.56 165.83,107.43 165.84,107.43 165.61,107.21 165.61,106.63 165.37,106.39 165.06,106.39 163.87,105.2 v2(163.87,104.49)
  BOTTOM w0.102: v2(101.65,6.25) 101.05,5.65 U93.6
EXPRESS_DET#_M: length 4.6
  TOP w0.102: U91.3 159.38,136.56 159.04,136.9 v1(159.04,138.38) 159.04,139.13 R37.1
F-IMAX: length 5.2
  BOTTOM w0.203: PR308.1 54.58,13.84 v1(53.69,14.73) 53.19,15.23 52.36,15.23 51.84,15.76 PU300.10
  BOTTOM w0.254: PR308.1 PR303.2
FAN1_PWM: length 105.3
  TOP w0.102: U38.A24 151.11,103.56 v2(151.28,103.39) 152.06,104.16 152.06,104.96 152.28,105.19 152.98,105.19 153,105.2 153.01,105.2 153.07,105.26 153.07,105.26 153.25,105.44 153.25,105.44 153.58,105.77 R408.2 ; v2(75.4,104.24) 75.27,104.24 74.97,103.94 74.97,103.12 74.52,102.67 73.95,102.67 73.31,102.03 JFAN1.3
  IN3 w0.102: v2(75.4,104.24) 75.75,103.89 78.07,103.89 78.84,103.12 81.57,103.12 85.38,99.31 89.45,99.31 93.89,94.86 99.8,94.86 99.99,94.67 102.21,94.67 102.84,95.3 106.59,95.3 110.8,91.09 113.2,91.09 113.61,91.51 113.61,92.48 114.36,93.23 114.36,94.39 115.44,95.47 123.9,95.47 125.07,96.64 131.48,96.64 133.48,98.63 136.09,98.63 138.14,96.59 141.27,96.59 141.58,96.89 142.72,96.89 143.17,97.34 143.17,97.91 144.25,98.99 144.25,102.23 144.94,102.92 147.08,102.92 148.06,103.91 149.41,103.91 149.93,103.39 v2(151.28,103.39)
  BOTTOM w0.102: v1(75.93,104.5) 75.67,104.24 v2(75.4,104.24)
FAN1_TACH: length 105.8
  TOP w0.102: v2(148.42,101.19) 148.42,101.34 148.9,101.81 149.36,101.81 U38.B22 ; v2(151.73,99.42) 151.73,99.07 152.95,97.85 152.95,97.34 153.2,97.08 R376.2 ; v2(75.41,103.62) 75.41,103.05 74.78,102.42 74.16,102.42 72.51,100.78 JFAN1.2
  IN3 w0.102: v2(151.73,99.42) 151.31,99.84 151.21,99.84 149.48,101.57 148.8,101.57 v2(148.42,101.19) 145.11,101.19 144.75,100.83 144.75,98.42 144.5,98.16 144.5,96.89 143.87,96.26 142.85,96.26 142.76,96.35 141.79,96.35 141.01,95.56 138.02,95.56 136.18,93.72 130.09,93.72 129.39,93.02 125.51,93.02 123.52,95.01 115.63,95.01 114.82,94.2 114.82,92.93 114.07,92.18 114.07,91.32 113.39,90.63 110.5,90.63 107.35,93.78 103.86,93.78 103.1,93.02 93.58,93.02 87.62,98.99 84.3,98.99 80.49,102.8 78.78,102.8 77.95,103.62 v2(75.41,103.62)
  BOTTOM w0.102: v2(75.41,103.62) 75.41,103.09 v1(75.2,102.87)
FB_+VDDRP: length 4.6
  BOTTOM w0.102: v1(32.81,34.79) PR707.1
  BOTTOM w0.254: PR707.1 PR708.1 33.3,32.88 33.43,32.76 33.43,32.35 34.23,31.54 PU700.4
FB_VREF: length 1.2
  TOP w0.102: T171.1 54.46,92.76 v4(54.09,93.13)
  BOTTOM w0.134: UV1.D23 54.47,92.75 v4(54.09,93.13)
FBA_CLK0_C: length 3
  BOTTOM w0.102: v1(36.92,100.42) 36.49,99.99 RV2707.1 RV2708.1 35.42,99.69 CV2901.1
FBA_CLK1_C: length 3.1
  TOP w0.102: v1(35.67,67.07) 36.42,67.82 RV2719.1 RV2718.1 CV2944.1
FBA_CMD0: length 39.6
  TOP w0.102: UV5.L2 33.66,93.94 33.31,93.59 33.31,93.02 33.95,92.38 33.95,91.81 v2(33.56,91.43)
  IN3 w0.091: v2(33.56,91.43) 33.56,91.28 33.12,90.84 33.12,87.55 33.47,87.19 v2(33.47,87.13)
  BOTTOM w0.102: UV1.C27 51.09,93.37 50.94,93.37 50.2,92.64 ; v2(33.56,91.43) 33.25,91.11 33.25,89.84 33.66,89.43 UV4.L2
  BOTTOM w0.122: 50.2,92.64 50.19,92.63 v1(47.98,92.63) 47.74,92.63 42.72,87.6 29.58,87.6 29.45,87.47 29.45,86.77 29.58,86.65 32.99,86.65 v2(33.47,87.13)
FBA_CMD2: length 46.3
  TOP w0.102: 34.13,96.51 34.13,95.24 UV5.K1 34.14,94.59 34.14,93.98 34.33,93.79 34.63,93.79 34.85,93.57 34.85,93.16 35.58,92.42 35.58,92.03 v2(35.18,91.62)
  TOP w0.122: 34.13,96.51 v2(34.13,97.08)
  IN1 w0.114: v4(53.27,91.5) 47.02,91.5 46.49,90.96 46.33,90.96 45.6,91.68 45.42,91.68 45.28,91.54 45.28,91.36 46,90.64 46,90.48 45.84,90.32 45.68,90.32 44.94,91.05 44.76,91.05 44.62,90.9 44.62,90.73 45.36,89.99 45.36,89.83 45.19,89.67 45.03,89.67 44.23,90.47 44.05,90.47 43.9,90.33 43.9,90.15 44.71,89.35 44.71,89.18 44.55,89.02 44.38,89.02 44.14,89.27 43.98,89.27 43.81,89.11 43.81,88.95 44.06,88.7 44.06,88.54 41.57,86.05 35.68,86.05 v2(34.97,86.76)
  IN3 w0.091: v2(34.97,86.76) 34.97,86.79 34.85,86.92 34.85,88.06 34.01,88.9 34.01,90.06 35.18,91.23 v2(35.18,91.62)
  BOTTOM w0.102: UV4.K1 34.14,88.83 34.14,90.24 35.18,91.29 v2(35.18,91.62)
  BOTTOM w0.122: v2(34.13,97.08) 33.63,97.59 RV2440.1 ; UV1.E24 53.67,91.9 v4(53.27,91.5)
FBA_CMD3: length 43.9
  TOP w0.102: UV5.K9 34.4,88.57 34.4,88.92 34.14,89.18 34.14,90.76 34.32,90.95 34.6,90.95 34.87,91.23 35.34,91.23 35.58,91.47 v2(36.02,91.47)
  IN1 w0.114: v4(54.07,91.47) 53.91,91.47 53.5,91.88 51.6,91.88 51.19,92.28 44.53,92.28 43.56,91.31 43.56,90.31 43.43,90.19 42.77,90.19 42.65,90.06 42.65,89.81 42.77,89.68 43.33,89.68 43.46,89.55 43.46,89.35 43.33,89.22 42.71,89.22 42.64,89.15 42.64,88.89 42.76,88.77 43.35,88.77 43.47,88.64 43.47,88.43 43.35,88.31 42.76,88.31 42.64,88.18 42.64,87.6 41.43,86.39 36.27,86.39 v2(35.87,86.79)
  IN3 w0.091: v2(36.02,91.47) 36.01,91.47 36.01,91.46 35.32,90.76 35.32,89.15 35.28,89.11 35.28,87.88 35.87,87.29 v2(35.87,86.79)
  BOTTOM w0.102: UV4.K9 34.14,94.59 34.14,93.18 34.66,92.65 35.35,92.65 35.61,92.39 35.61,92.05 36.02,91.65 v2(36.02,91.47)
  BOTTOM w0.122: RV2438.1 34.58,96.76 34.46,96.64 UV4.K9 ; UV1.F24 53.67,91.07 54.07,91.47 v4(54.07,91.47)
FBA_CMD4: length 55.2
  TOP w0.102: UV7.T7 29.05,74.98 28.05,74.98 27.68,75.35 27.68,75.91 28.06,76.29 v2(28.06,76.35) ; UV5.T7 29.04,90.73 28.04,90.73 27.67,91.1 27.67,91.66 28.05,92.04 v2(28.05,92.1)
  IN3 w0.091: v2(28.06,76.35) 28.06,76.7 27.76,77 27.76,83.42 27.38,83.8 27.38,84.79 v2(27.47,84.88) 27.47,84.97 27.86,85.36 27.86,86.12 27.38,86.61 27.38,90.64 27.65,90.91 27.65,91.7 v2(28.05,92.1)
  BOTTOM w0.102: UV4.T7 29.26,93.31 v2(28.05,92.1) ; v2(28.06,76.35) 29.27,77.56 UV6.T7
  BOTTOM w0.122: v2(27.47,84.88) 27.47,84.99 28.29,85.81 33.54,85.81 34,86.27 35.94,86.27 36.54,86.86 43.04,86.86 v1(45.95,89.77) 48.03,91.85 50.04,91.85 50.52,92.32 50.84,92.32 UV1.D27
FBA_CMD5: length 66.4
  TOP w0.102: v2(26.44,91.46) 26.83,91.85 26.83,92.45 27.41,93.02 28.57,93.02 UV5.T2 ; v2(26.45,75.71) 26.85,76.1 26.85,76.7 27.42,77.27 28.58,77.27 UV7.T2
  IN3 w0.091: v2(26.45,75.71) 26.54,75.71 26.83,76 26.83,77.52 26.77,77.59 26.77,80.67 26.24,81.2 26.24,83.98 26.31,84.05 v2(26.31,84.76) 26.31,85.89 26.21,86 25.91,86 25.81,86.1 25.81,86.4 25.91,86.5 26.21,86.5 26.31,86.6 26.31,86.91 26.21,87.01 25.91,87.01 25.81,87.11 25.81,87.42 25.91,87.52 26.21,87.52 26.31,87.62 26.31,91.33 v2(26.44,91.46)
  BOTTOM w0.102: UV6.T2 27.57,73.56 26.45,74.68 v2(26.45,75.71) ; UV4.T2 27.56,89.31 26.44,90.43 v2(26.44,91.46)
  BOTTOM w0.122: UV1.D26 51.68,93.14 51.02,93.14 50.12,92.24 47.88,92.24 v1(44.32,88.68) 43.81,88.17 42.89,87.24 34.9,87.24 34.3,86.64 33.84,86.64 33.39,86.19 27.11,86.19 RV2447.1 26.31,85.44 v2(26.31,84.76)
FBA_CMD6: length 60.4
  TOP w0.102: UV7.R3 30.37,77.56 29.84,77.03 29.37,77.03 29.1,76.76 28.69,76.76 28.47,76.54 28.47,76.16 28.06,75.76 v2(28.06,75.63) ; UV5.R3 30.36,93.31 29.83,92.78 29.35,92.78 29.09,92.51 28.68,92.51 28.46,92.29 28.46,91.91 28.05,91.51 v2(28.05,91.38)
  IN3 w0.091: v2(28.05,91.38) 28.05,90.68 28.18,90.56 28.37,90.56 28.49,90.44 28.49,90.28 28.37,90.16 27.71,90.16 27.58,90.03 27.58,89.86 27.71,89.73 28.55,89.73 28.68,89.6 28.68,89.41 28.55,89.28 27.79,89.28 27.71,89.21 27.71,86.73 28.19,86.25 28.19,85.11 v2(28.12,85.03) 28.12,84.65 27.71,84.24 27.71,83.94 28.09,83.56 28.09,77.03 28.47,76.65 28.47,76.04 v2(28.06,75.63)
  BOTTOM w0.102: v2(28.06,75.63) 28.94,74.75 30.28,74.75 30.47,74.56 UV6.R3 ; v2(28.05,91.38) 28.93,90.5 30.26,90.5 30.46,90.31 UV4.R3
  BOTTOM w0.122: UV1.F25 52.71,91.05 52.25,91.51 51.83,91.51 51.64,91.7 51.03,91.7 50.77,91.44 48.15,91.44 43.19,86.48 36.69,86.48 36.1,85.89 34.16,85.89 33.7,85.43 v1(28.8,85.43) 28.52,85.43 v2(28.12,85.03)
FBA_CMD7: length 68.4
  TOP w0.102: v2(26.45,76.32) 26.45,76.75 27.29,77.59 28.37,77.59 29.58,78.79 30.04,78.79 UV7.R2 ; v2(26.44,92.07) 26.44,92.5 27.28,93.34 28.36,93.34 29.56,94.54 30.03,94.54 UV5.R2
  IN3 w0.091: v2(26.45,76.32) 26.44,76.33 26.44,80.54 25.87,81.1 v2(25.87,84.32) 25.48,84.71 25.48,87.55 25.98,88.06 25.98,91.61 v2(26.44,92.07)
  BOTTOM w0.102: v2(26.44,92.07) 26.86,91.65 26.86,90.64 27.79,89.72 30.14,89.72 30.46,89.39 UV4.R2 ; UV6.R2 30.47,73.64 30.15,73.97 27.8,73.97 26.87,74.89 26.87,75.9 v2(26.45,76.32)
  BOTTOM w0.122: UV1.F26 51.94,91.05 51.55,91.44 51.11,91.44 50.88,91.21 50.2,91.21 50.06,91.07 48.31,91.07 v1(48.01,90.77) 43.35,86.11 36.85,86.11 36.25,85.51 34.31,85.51 33.82,85.02 31.61,85.02 31.09,84.5 27.84,84.5 27.66,84.32 v2(25.87,84.32)
FBA_CMD8: length 56
  TOP w0.102: UV5.P3 30.52,92.57 30.2,92.57 30.01,92.38 30.01,91.85 29.63,91.46 v2(29.63,91.43) ; UV7.P3 30.53,76.82 30.21,76.82 30.02,76.63 30.02,76.1 29.64,75.71 v2(29.64,75.68)
  IN1 w0.114: v2(29.7,84.03) 30.12,84.45 31.04,84.45 31.96,85.36 41.86,85.36 47.22,90.73 52.9,90.73 53.38,90.25 54.51,90.25 v2(54.91,90.65)
  IN3 w0.091: v2(29.64,75.68) 30.02,76.06 30.02,77.28 29.16,78.15 29.16,80.08 29.57,80.5 29.57,83.9 v2(29.7,84.03) 29.49,84.24 29.49,87.53 29.89,87.93 29.89,90.72 29.63,90.99 v2(29.63,91.43)
  BOTTOM w0.102: UV4.P3 31.26,90.37 30.72,90.91 30.15,90.91 v2(29.63,91.43) ; v2(29.64,75.68) 30.16,75.16 30.73,75.16 31.27,74.62 UV6.P3
  BOTTOM w0.122: UV1.F23 54.52,91.05 54.91,90.66 v2(54.91,90.65)
FBA_CMD9: length 52.1
  TOP w0.102: UV7.N3 31.61,77.1 31.61,76.19 31.21,75.79 v2(31.21,75.72) ; UV5.N3 31.6,92.85 31.6,91.94 31.2,91.54 v2(31.2,91.47)
  IN1 w0.114: v4(54.89,89.84) 54.46,89.41 52.09,89.41 51.56,89.94 47.41,89.94 42.14,84.68 32.82,84.68 v2(32.29,84.15)
  IN3 w0.091: v2(31.21,75.72) 31.62,76.13 31.62,76.83 30.1,78.36 30.1,79.86 30.59,80.35 30.68,80.35 31.15,80.82 31.15,81.95 32.29,83.09 v2(32.29,84.15) 32.29,85.01 30.91,86.39 30.91,87.57 31.29,87.95 31.29,91.38 v2(31.2,91.47)
  BOTTOM w0.102: UV4.N3 32.06,90.61 v2(31.2,91.47) ; v2(31.21,75.72) 32.07,74.86 UV6.N3
  BOTTOM w0.122: UV1.G22 55.31,90.25 54.9,89.84 v4(54.89,89.84)
FBA_CMD10: length 55.3
  TOP w0.102: UV7.P8 31.61,73.9 31.61,74.54 30.83,75.31 30.83,75.92 31.21,76.3 v2(31.21,76.37) ; v2(31.2,92.12) 31.2,92.05 30.82,91.67 30.82,91.06 31.6,90.29 31.6,89.65 UV5.P8
  IN1 w0.114: v2(54.07,90.66) 53.45,90.66 53.02,91.09 47.09,91.09 41.72,85.71 31.71,85.71 v2(31.02,85.02)
  IN3 w0.091: v2(31.2,92.12) 30.82,91.74 30.82,89.49 30.5,89.17 30.5,86.33 31.02,85.81 v2(31.02,85.02) 31.14,84.9 31.14,83.61 31.32,83.43 31.32,82.59 30.73,82.01 30.73,80.9 30.63,80.8 30.63,80.69 29.89,79.96 29.89,78.27 31.21,76.95 v2(31.21,76.37)
  BOTTOM w0.102: UV6.P8 31.61,78.02 31.61,76.77 v2(31.21,76.37) ; UV4.P8 31.6,93.77 31.6,92.52 v2(31.2,92.12)
  BOTTOM w0.122: UV1.G23 54.47,90.26 v2(54.07,90.66)
FBA_CMD11: length 52.1
  TOP w0.102: v2(30.41,92.13) 30.41,91.96 30.03,91.58 30.03,91.22 30.49,90.76 30.6,90.76 UV5.P7 ; UV7.P7 30.62,75.01 30.5,75.01 30.05,75.47 30.05,75.83 30.43,76.21 v2(30.43,76.38)
  IN1 w0.114: v2(30.29,84.03) 31.13,84.03 32.12,85.02 42,85.02 47.35,90.37 52.75,90.37 v4(53.28,89.84)
  IN3 w0.091: v2(30.41,92.13) 30.01,91.72 30.01,91.06 30.1,90.97 30.1,87.83 29.81,87.54 29.81,84.5 30.29,84.03 v2(30.29,84.03) 29.9,83.64 29.9,80.54 29.36,80 29.36,78.23 30.43,77.17 v2(30.43,76.38)
  BOTTOM w0.102: v2(30.43,76.38) 31.27,77.22 UV6.P7 ; UV4.P7 31.26,92.97 v2(30.41,92.13)
  BOTTOM w0.122: v4(53.28,89.84) 53.29,89.84 53.67,90.22 UV1.G24
FBA_CMD12: length 50.8
  TOP w0.102: v2(32,75.66) 32,75.73 32.38,76.11 32.38,77.22 32.5,77.33 32.5,77.99 UV7.M2 ; v2(31.99,91.41) 31.99,91.48 32.37,91.86 32.37,92.97 32.49,93.08 32.49,93.74 UV5.M2
  IN3 w0.091: v2(32,75.66) 32.41,76.06 32.41,76.62 30.5,78.53 30.5,79.66 30.78,79.94 31.03,79.94 31.81,80.72 31.81,81.68 33.46,83.33 v2(33.46,84.13) 33.46,84.77 31.57,86.66 31.57,87.57 31.7,87.7 31.7,89.55 31.99,89.84 v2(31.99,91.41)
  BOTTOM w0.102: v2(32,75.66) 32.43,75.22 32.43,74.03 32.87,73.59 UV6.M2 ; UV4.M2 32.86,89.34 32.42,89.78 32.42,90.97 v2(31.99,91.41)
  BOTTOM w0.122: v2(33.46,84.13) 34.43,85.1 v1(35.03,85.1) 36.37,85.1 37.01,85.73 43.51,85.73 48.47,90.69 50,90.69 50.28,90.97 51.19,90.97 UV1.F27
FBA_CMD13: length 46.7
  TOP w0.102: v2(34.36,75.62) 34.76,76.01 34.76,76.66 33.86,77.56 UV7.L3 ; UV5.L3 34.43,92.54 34.44,92.54 34.73,92.24 34.73,91.91 34.35,91.52 v2(34.35,91.37)
  IN3 w0.091: v2(34.36,75.62) 34.77,76.02 34.77,76.9 33.73,77.94 33.73,79.3 34.89,80.46 34.89,81.41 35.49,82.01 v2(35.49,84.27) 35.49,85.13 34.23,86.4 34.23,88.11 33.53,88.81 33.53,90.45 34.35,91.27 v2(34.35,91.37)
  BOTTOM w0.102: UV6.L3 33.67,74.52 34.36,75.21 v2(34.36,75.62) ; v2(34.35,91.37) 33.66,90.68 UV4.L3
  BOTTOM w0.122: v2(35.49,84.27) 35.95,84.72 36.53,84.72 37.16,85.36 v1(37.95,85.36) 43.66,85.36 48.62,90.32 50.1,90.32 50.43,90.64 52.48,90.64 UV1.G25
FBA_CMD14: length 44.6
  TOP w0.102: v2(33.58,76.32) 33.58,76.25 33.17,75.85 33.17,75.34 32.87,75.04 UV7.M7 ; v2(33.56,92.07) 33.56,92 33.16,91.6 33.16,91.09 32.86,90.79 UV5.M7
  IN3 w0.091: v2(33.58,76.32) 33.58,77 33.12,77.46 33.12,79.56 33.69,80.13 33.69,82.16 34.68,83.14 v2(34.68,84.26) 34.68,84.96 33.09,86.54 33.09,87.28 32.92,87.46 32.92,91.01 33.18,91.28 33.18,91.68 v2(33.56,92.07)
  BOTTOM w0.102: v2(33.58,76.32) 32.87,77.02 UV6.M7 ; v2(33.56,92.07) 32.86,92.77 UV4.M7
  BOTTOM w0.122: v2(34.68,84.26) 35.08,83.85 35.66,83.85 36.16,84.35 36.75,84.35 37.38,84.98 v1(40.17,84.98) 43.82,84.98 48.74,89.91 50.27,89.91 50.61,90.25 UV1.G27
FBA_CMD15: length 45.6
  TOP w0.102: UV5.K3 34.46,92.99 v2(35.19,92.26) ; v2(35.2,76.51) 34.47,77.24 UV7.K3
  IN3 w0.091: v2(35.19,92.26) 34.8,91.86 34.8,91.14 33.73,90.07 33.73,88.89 34.56,88.06 34.56,86.56 36.22,84.91 v2(36.22,83.81) 36.22,82.52 35.94,82.25 35.94,81.99 35.24,81.3 35.24,80.51 33.94,79.2 33.94,78.02 35.2,76.76 v2(35.2,76.51)
  BOTTOM w0.102: UV4.K3 34.46,90.18 35.57,91.29 35.57,91.8 35.19,92.18 v2(35.19,92.26) ; v2(35.2,76.51) 35.2,76.43 35.58,76.05 35.58,75.54 34.47,74.43 UV6.K3
  BOTTOM w0.122: v2(36.22,83.81) 36.35,83.94 36.88,83.94 37.54,84.61 v1(42.65,84.61) 43.97,84.61 48.78,89.41 50.19,89.41 50.63,89.85 51.67,89.85 UV1.G26
FBA_CMD16: length 45.2
  TOP w0.102: UV7.L2 33.67,78.19 33.32,77.84 33.32,77.27 33.96,76.63 33.96,76.06 v2(33.58,75.68)
  IN1 w0.114: v4(54.06,86.53) 54.46,86.93 54.46,87.49 54.22,87.73 48.38,87.73 48.07,87.42 47.9,87.42 47.58,87.75 47.4,87.75 47.25,87.6 47.25,87.42 47.58,87.1 47.58,86.93 47.42,86.77 47.26,86.77 46.81,87.22 46.63,87.22 46.48,87.08 46.48,86.9 46.93,86.45 46.93,86.29 46.77,86.13 46.61,86.13 46.16,86.58 45.98,86.58 45.84,86.43 45.84,86.25 46.29,85.8 46.29,85.64 46.13,85.48 45.96,85.48 45.51,85.93 45.33,85.93 45.19,85.78 45.19,85.61 45.64,85.16 45.64,84.99 45.48,84.83 45.32,84.83 44.87,85.28 44.69,85.28 44.54,85.14 44.54,84.96 44.99,84.51 44.99,84.35 44.83,84.19 44.67,84.19 44.22,84.64 44.04,84.64 43.9,84.49 43.9,84.31 44.35,83.86 44.35,83.7 43.04,82.39 35.68,82.39 34.31,81.03 v2(34.1,81.03)
  IN3 w0.091: v2(33.58,75.68) 33.96,76.06 33.96,77.05 33.33,77.68 33.33,79.48 34.1,80.25 v2(34.1,81.03)
  BOTTOM w0.102: UV6.L2 33.67,73.68 33.26,74.09 33.26,75.36 v2(33.58,75.68)
  BOTTOM w0.122: UV1.M24 53.67,86.11 54.06,86.5 v4(54.06,86.53)
FBA_CMD18: length 46.6
  TOP w0.102: v2(35.19,75.87) 35.6,76.28 35.6,76.67 34.86,77.41 34.86,77.82 34.64,78.04 34.34,78.04 34.15,78.23 34.15,78.84 UV7.K1
  IN1 w0.114: v4(53.27,87.35) 53.18,87.35 52.62,86.8 52.55,86.73 52.18,86.73 52.01,86.9 52.01,87.38 51.89,87.51 51.62,87.51 51.5,87.38 51.5,86.85 51.37,86.73 51.17,86.73 51.04,86.85 51.04,87.2 50.92,87.31 49.44,87.31 49.32,87.2 49.32,86.97 49.21,86.85 48.98,86.85 48.87,86.97 48.87,87.2 48.75,87.31 48.44,87.31 48.14,87.01 48.14,86.85 48.72,86.27 48.72,86.11 48.56,85.95 48.39,85.95 47.82,86.53 47.66,86.53 47.49,86.36 47.49,86.2 48.07,85.62 48.07,85.46 47.91,85.3 47.75,85.3 47.17,85.88 47.01,85.88 46.85,85.72 46.85,85.56 47.42,84.98 47.42,84.82 47.26,84.65 47.1,84.65 46.52,85.23 46.36,85.23 43.18,82.05 36.61,82.05 v2(35.66,81.1)
  IN3 w0.091: v2(35.66,81.1) 35.66,80.62 34.29,79.25 34.29,77.96 35.63,76.61 35.63,76.24 35.26,75.87 v2(35.19,75.87)
  BOTTOM w0.102: 34.47,71.11 UV6.K1 34.15,73.08 34.15,74.49 35.19,75.54 v2(35.19,75.87)
  BOTTOM w0.122: RV2439.1 34.47,70.32 34.47,71.11 ; v4(53.27,87.35) 53.67,87.75 UV1.K24
FBA_CMD19: length 51.4
  TOP w0.102: UV7.K9 34.41,72.82 34.41,73.17 34.15,73.43 34.15,74.55 35.05,75.45 35.28,75.45 35.33,75.5 35.38,75.5 35.59,75.72 v2(36.03,75.72)
  IN1 w0.114: v2(36.03,75.72) 35.6,75.72 35.36,75.48 34.87,75.48 33.91,74.51 33.91,71.53 v2(34.9,70.54) ; v4(54.05,87.35) 54.05,87.08 53.9,86.93 53.06,86.93 52.64,86.51 49.6,86.51 47.18,84.09 47.02,84.09 46.51,84.6 46.34,84.6 46.18,84.44 46.18,84.28 46.7,83.76 46.7,83.6 46.54,83.45 46.36,83.45 45.8,84.02 45.63,84.02 45.47,83.86 45.47,83.69 46.04,83.13 46.04,82.95 45.9,82.8 45.72,82.8 45.15,83.37 44.99,83.37 44.83,83.21 44.83,83.05 45.39,82.48 45.39,82.3 45.25,82.16 45.07,82.16 44.5,82.72 44.34,82.72 44.18,82.56 44.18,82.4 44.55,82.03 44.55,81.85 44.4,81.71 44.22,81.71 43.86,82.08 43.69,82.08 43.33,81.71 38.67,81.71 38.53,81.57 v2(38.53,81.35)
  IN3 w0.091: v2(36.03,75.72) 36.05,75.72 36.42,76.09 36.42,76.8 36.14,77.08 35.78,77.08 35.28,77.58 35.28,78.91 35.6,79.24 36.12,79.24 36.45,79.56 36.45,80.15 37.06,80.76 38.02,80.76 38.53,81.27 v2(38.53,81.35)
  BOTTOM w0.102: v2(36.03,75.72) 36.03,75.9 35.62,76.3 35.62,76.64 35.37,76.9 34.67,76.9 34.15,77.43 34.15,78.84 UV6.K9
  BOTTOM w0.122: v2(34.9,70.54) RV2437.1 ; v4(54.05,87.35) UV1.K23
FBA_CMD20: length 56.4
  TOP w0.102: v2(27.27,91.38) 27.27,91.54 27.66,91.94 27.66,92.32 28.05,92.71 28.88,92.71 29.48,93.31 UV5.T3 ; UV7.T3 29.49,77.56 28.89,76.96 28.07,76.96 27.67,76.57 27.67,76.19 27.28,75.79 v2(27.28,75.63)
  IN3 w0.091: v2(27.27,91.38) 27.27,91.1 27.05,90.88 27.05,83.67 27.28,83.44 v2(27.28,83.23) 27.43,83.08 27.43,77.82 27.48,77.77 27.48,76.93 27.68,76.72 27.68,76.04 v2(27.28,75.63)
  BOTTOM w0.102: UV6.T3 28.55,74.36 v2(27.28,75.63) ; v2(27.27,91.38) 28.54,90.11 UV4.T3
  BOTTOM w0.122: v2(27.28,83.23) v1(27.78,82.73) 28.23,82.29 33.53,82.29 35.11,80.71 38.48,80.71 39.28,81.52 44.61,81.52 49.18,86.09 UV1.M27
FBA_CMD21: length 61.4
  TOP w0.102: UV5.T8 28.52,90.45 27.56,90.45 26.82,91.19 26.82,91.54 27.27,91.99 v2(27.27,92.1) ; v2(27.28,76.35) 27.28,76.24 26.83,75.79 26.83,75.44 27.58,74.7 28.53,74.7 UV7.T8
  IN3 w0.091: v2(27.27,92.1) 27.27,91.98 26.88,91.6 26.88,91.28 26.72,91.11 26.72,83.75 26.67,83.7 v2(26.67,83.12) 27.1,82.69 27.1,77.67 27.28,77.49 v2(27.28,76.35)
  BOTTOM w0.102: v2(27.28,76.35) 29.28,78.36 UV6.T8 ; v2(27.27,92.1) 29.27,94.11 UV4.T8
  BOTTOM w0.122: v2(26.67,83.12) 26.67,83.11 27.88,81.91 v1(31.09,81.91) 33.12,81.91 33.37,81.66 33.37,81.16 34.22,80.32 38.62,80.32 39.44,81.14 44.76,81.14 49.32,85.7 51.68,85.7 UV1.M26
FBA_CMD22: length 58.6
  TOP w0.102: UV5.R8 30.83,89.69 30.83,90.25 30.52,90.56 30.4,90.56 30.17,90.8 29.69,90.8 29.25,91.24 29.25,91.59 29.63,91.97 v2(29.63,92.1) ; UV7.R8 30.85,73.94 30.85,74.5 30.53,74.81 30.41,74.81 30.18,75.05 29.7,75.05 29.26,75.49 29.26,75.84 29.64,76.22 v2(29.64,76.35)
  IN3 w0.091: v2(29.63,92.1) 29.25,91.72 29.25,90.92 29.44,90.73 29.44,88.64 29.06,88.26 29.06,87.68 29.17,87.57 29.17,82.74 v2(29.17,82.73) 29.24,82.66 29.24,80.57 28.95,80.28 28.95,77.9 29.08,77.77 29.24,77.77 29.35,77.66 29.35,77.51 29.24,77.4 29.08,77.4 28.95,77.27 28.95,77.08 29.2,76.84 29.34,76.84 29.46,76.96 29.46,77.1 29.57,77.21 29.71,77.21 29.82,77.1 29.82,76.48 29.69,76.35 v2(29.64,76.35)
  BOTTOM w0.102: v2(29.63,92.1) 29.85,92.1 30.38,92.64 30.52,92.64 30.83,92.96 30.83,93.73 UV4.R8 ; v2(29.64,76.35) 29.86,76.35 30.4,76.89 30.53,76.89 30.85,77.21 30.85,77.98 UV6.R8
  BOTTOM w0.122: UV1.M25 52.45,86.51 49.07,86.51 44.45,81.89 38.39,81.89 38.1,81.61 34.75,81.61 33.66,82.7 v1(33.37,82.7) 29.2,82.7 v2(29.17,82.73)
FBA_CMD23: length 55.5
  TOP w0.102: UV7.R7 29.99,74.84 29.62,74.84 29.23,75.24 28.75,75.24 28.47,75.52 28.47,75.84 28.85,76.22 v2(28.85,76.35) ; v2(28.84,92.1) 28.84,91.97 28.46,91.59 28.46,91.27 28.74,90.99 29.21,90.99 29.61,90.59 29.98,90.59 UV5.R7
  IN3 w0.091: v2(28.85,76.35) 28.85,76.55 28.42,76.98 28.42,78.88 28.42,78.88 28.42,83.81 v2(28.15,84.07) 28.52,84.44 28.52,86.37 28.04,86.86 28.04,88.13 28.88,88.97 28.88,90.47 28.45,90.9 28.45,91.71 v2(28.84,92.1)
  BOTTOM w0.102: UV6.R7 29.73,76.82 29.32,76.82 v2(28.85,76.35) ; UV4.R7 29.72,92.57 29.31,92.57 v2(28.84,92.1)
  BOTTOM w0.122: v2(28.15,84.07) 28.64,83.58 32.4,83.58 32.64,83.34 33.55,83.34 34.9,81.98 37.95,81.98 38.23,82.27 v1(43.09,82.27) 44.3,82.27 49.39,87.36 51.66,87.36 UV1.K26
FBA_CMD24: length 62.1
  TOP w0.102: v2(28.84,91.43) 28.84,91.53 29.22,91.91 29.22,92.36 29.44,92.57 29.91,92.57 30.12,92.78 30.44,92.78 30.9,93.24 30.9,93.75 UV5.P2 ; v2(28.85,75.68) 28.85,75.78 29.23,76.16 29.23,76.61 29.45,76.82 29.92,76.82 30.13,77.03 30.45,77.03 30.91,77.49 30.91,78 UV7.P2
  IN1 w0.114: v4(54.89,88.18) 54.49,88.58 53.88,88.58 53.46,89 49.51,89 49.5,89.01 46.96,89.01 42.29,84.33 36.14,84.33 35.66,83.85 34.91,83.85 34.44,83.38 32.47,83.38 32.27,83.58 29.23,83.58 v2(28.75,84.07)
  IN3 w0.091: v2(28.84,91.43) 28.84,90.95 29.18,90.61 29.18,88.76 28.37,87.95 28.37,86.99 28.85,86.5 28.85,84.17 v2(28.75,84.07) 28.75,76.99 29.23,76.51 29.23,76.06 v2(28.85,75.68)
  BOTTOM w0.102: v2(28.85,75.68) 29.58,74.96 30.41,74.96 30.85,74.53 30.85,74.09 31.27,73.67 UV6.P2 ; UV4.P2 31.26,89.42 30.83,89.84 30.83,90.28 30.4,90.71 29.56,90.71 v2(28.84,91.43)
  BOTTOM w0.122: UV1.K22 54.89,88.19 v4(54.89,88.18)
