# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_SMBDAT: length 101.9
  TOP w0.102: v2(142.59,107.12) 142.78,107.31 142.78,108 142.64,108.14 U38.B48 ; RP7.3 134.51,106.03 134.83,106.35 v2(134.83,106.48)
  IN1 w0.097: v2(106.54,120.79) 106.34,120.59 106.34,120.17 105.89,119.73 90.44,119.73 84.97,114.26 84.97,113.63 79.26,107.91 71.7,107.91 68.49,104.7 v2(68.3,104.7)
  BOTTOM w0.102: QC9.3 68.3,104.7 v2(68.3,104.7) ; v2(142.59,107.12) 142.79,107.31 142.79,107.8 141.25,109.34 137.13,109.34 136.37,108.58 136.37,107.05 135.58,106.26 135.05,106.26 v2(134.83,106.48) 134.62,106.7 134.62,108.41 135.17,108.96 135.17,110.1 133.96,111.31 133.96,112.32 131.67,114.61 125.55,114.61 124.47,115.69 120.24,115.69 119.99,115.94 111.35,115.94 110.53,116.77 108.75,116.77 108.43,117.09 106.34,117.09 105.64,117.78 105.64,118.67 106.36,119.4 106.36,120.61 v2(106.54,120.79)
GPU_TALERT/ISEN2: length 3.3
  BOTTOM w0.254: PR637.1 PR628.1 52.51,34.41 52.65,34.55 PU600.14
GPU_TESTMODE: length 5.7
  TOP w0.102: v5(70.43,74.72) 69.82,75.33 69.57,75.33 69.24,75.66 RV2435.1 68.26,76.91 66.87,76.91 v4(66.5,76.55)
  BOTTOM w0.1: v4(66.5,76.55) 66.1,76.15 UV1.AD9
GPU_TON: length 4.1
  BOTTOM w0.254: PU600.9 56.74,32.05 55.73,31.04 55.16,31.04 54.71,30.6 PR614.2
GPU_TSNS/ISEN3: length 24.7
  IN1 w0.254: v2(48.87,50.73) 48.23,50.09 48.23,47.65 47.87,47.28 47.87,35.54 v2(49.19,34.22)
  BOTTOM w0.254: v2(49.19,34.22) 49.19,33.72 PR623.2 49.38,33.53 PR625.1 PR624.1 PC624.1 52.93,33.53 v1(53.2,33.8) 53.45,34.05 PU600.13 ; PH302.1 49.39,50.21 v2(48.87,50.73)
GPU_VREF: length 13
  IN2 w0.254: v2(57.24,31.69) 56.74,32.19 54.52,32.19 54.33,32 v2(49.38,32)
  BOTTOM w0.254: PU600.8 v2(57.24,31.69) 57.09,31.69 v1(56.81,31.41) 56.49,31.09 PR604.1 PC613.1 ; v2(49.38,32) PR623.1
GPUHOT#: length 189.4
  TOP w0.102: QC11.6 73.43,82.23 R389.2 v1(74.61,82.24) 74.98,82.24 75.16,82.06 v2(75.16,81.84) ; R78.1 158.79,89.27 R72.1 158.79,87.43 157.91,86.55 156.37,86.55 155.26,87.66 153.97,87.66 v2(153.64,87.99)
  IN2 w0.102: v2(77,64.82) 76.3,64.82 75.54,64.06 72.87,64.06 70.75,61.94 50.52,61.94 48.74,60.16 48.74,54.28 48.3,53.84 48.3,50.6 48.55,50.35 48.55,40.82 51.03,38.35 51.03,35.81 v2(50.52,35.3)
  IN3 w0.102: v2(153.64,87.99) 153.81,88.15 153.81,90.74 152.78,91.77 152.78,94.44 150.82,96.39 150.82,96.9 148.74,98.99 145.65,98.99 144.89,98.23 144.89,96.08 144.48,95.66 143.19,95.66 143.1,95.75 142.53,95.75 141.84,95.05 138.28,95.05 136.44,93.21 130.66,93.21 129.12,91.68 125.53,91.68 122.97,94.24 117,94.24 116.77,94 116.77,92.09 115.66,90.99 114.4,90.99 113.58,90.16 110.21,90.16 108.18,92.19 103.16,92.19 102.53,91.56 94.02,91.56 93.06,92.51 86.08,92.51 83.22,89.65 79.41,89.65 76.36,86.61 76.36,83.05 v2(75.16,81.84)
  BOTTOM w0.102: v2(75.16,81.84) 75.16,81.46 75.86,80.76 75.86,72.06 77.44,70.48 77.44,68.76 77,68.32 v2(77,64.82) ; PR637.2 v2(50.52,35.3)
GREEN_CRT: length 165.5
  TOP w0.102: U39.25 157.97,154.67 v2(157.9,154.74)
  IN3 w0.102: v2(308.9,162.61) 308.78,162.49 304.7,162.49 304.2,163 292.82,163 289.68,166.14 282.44,166.14 281.94,166.64 276.11,166.64 274.57,168.18 237.44,168.18 235.98,166.72 228.42,166.72 226.54,164.84 221.13,164.84 218.64,162.35 195.35,162.35 194.03,161.03 v2(194.03,160.2)
  BOTTOM w0.102: JIO1.20 309.92,162.9 309.76,163.06 309.16,163.06 308.9,162.81 v2(308.9,162.61) ; v2(157.9,154.74) 158.79,153.85 170.47,153.85 171.22,153.1 178.11,153.1 178.31,153.31 188.4,153.31 190.09,155 190.09,157.59 190.74,158.23 191.17,158.23 192.63,159.69 v1(192.95,159.69) 193.52,159.69 v2(194.03,160.2)
GREEN_DOCK: length 10.1
  TOP w0.102: v2(162.28,158.3) 161.77,157.79 v1(160.82,157.79) 158.53,157.79 157.58,156.84 157.58,155.69 158.37,154.91 U39.24
  BOTTOM w0.102: L69.1 162.28,159.49 v2(162.28,158.3)
GREEN_DOCK_PI: length 4.6
  BOTTOM w0.102: JDOCK1.59 162.95,162.65 162.47,162.17 L69.2 v1(163.5,160.6)
H_CATERR#: length 12.1
  BOTTOM w0.076: UC1.K61 111.93,29.63 111.93,29.12 112.16,28.88 112.34,28.88 112.51,28.71 112.51,28.35 112.33,28.17 112.33,26.92 112.35,26.89 112.35,25.9
  BOTTOM w0.102: 112.35,25.9 112.35,22.48 v1(112.46,22.37) 113.26,21.58 113.26,19.37 RC113.2
H_CPU_SVIDALRT#: length 11.6
  BOTTOM w0.076: 113.72,25.9 113.72,26.65 113.26,27.1 113.26,28.71 112.97,29 UC1.L62
  BOTTOM w0.102: RC248.1 115.91,18.86 115.09,19.69 v1(115.09,20.57) 115.09,22.3 113.72,23.68 113.72,25.9
H_CPUPWRGD: length 55.5
  TOP w0.102: v2(105.56,28.95) 109.68,28.95 113.07,25.56 113.07,21.64 113.56,21.14 114.5,21.14 116.53,19.1 119.49,19.1 120.01,19.63 128.41,19.63 129.68,20.9 137.3,20.9 v5(140.44,17.76) 141.81,16.38 RC106.1
  BOTTOM w0.076: UC1.C61 107.35,30.21 107.33,30.23 106.74,30.23 106.67,30.16 106.31,30.16 105.69,29.53 105.69,29.07
  BOTTOM w0.109: RC115.1 101.38,26.39 101.89,26.39 102.23,26.74 102.23,28.4 102.78,28.95 v2(105.56,28.95) 105.69,29.07
H_PROCHOT#: length 283.4
  TOP w0.102: PQ502.3 141.85,132.39 141.93,132.3 v2(142.54,132.3) ; v2(109.57,121.15) 110.06,120.67 110.06,119.63 110.92,118.76 110.92,117.29 111.8,116.41 111.8,115.18 112.62,114.35 114.97,114.35 116.12,115.5 PR442.2 ; Q9.1 138.77,116.89 R334.2 139.04,117.66 v2(139.29,117.91)
  IN1 w0.097: v2(109.57,121.15) 109.67,121.05 109.67,120.33 107,117.66 105.02,117.66 104.77,117.9 93.65,117.9 90.2,114.45 90.2,110.71 90.46,110.46 90.46,91.22 86.38,87.13 86.38,85.43 84.65,83.71 84.65,81.81 83.89,81.04 83.89,73.48 84.52,72.84 84.52,67.44 86.78,65.18 86.78,60.38 87.14,60.01 87.14,58.08 88.06,57.17 88.06,44.77 90.89,41.94 92.07,41.94 92.49,42.35 93.69,42.35 95.72,40.33 95.72,32.05 95.29,31.61 95.29,30.16 94.83,29.71 94.83,28.3 93.44,26.91 91.94,26.91 88.42,23.39 88.42,22.23 89.22,21.43 89.22,19.07 88.44,18.29 88.44,17.57 88.85,17.16 89.18,17.16 89.64,16.7 89.64,14.6 v2(89,13.96)
  IN3 w0.102: v2(50.52,22.15) 50.52,19.93 52.6,17.85 52.6,17.15 58.33,11.42 86.46,11.42 v2(89,13.96) 92,13.96 93.09,15.05 100,15.05 100.87,15.92 103.61,15.92 104.05,15.49 106.34,15.49 107.67,16.82 108.88,16.82 110.02,17.96 110.59,17.96 111.34,18.71 111.92,18.71 v2(112.76,19.55) ; v2(139.29,117.91) 140.5,117.91 142.11,119.52 142.11,131.87 v2(142.54,132.3)
  BOTTOM w0.102: PR326.2 PC317.1 50.85,23.75 50.52,23.42 v2(50.52,22.15) ; v2(109.57,121.15) 110.94,121.15 113.13,118.96 119.57,118.96 119.91,118.63 121.27,118.63 123.56,120.91 127.17,120.91 127.69,120.39 130,120.39 130.5,119.89 133.53,119.89 136.07,117.34 138.72,117.34 v2(139.29,117.91) ; RC117.1 112.76,20.06 v2(112.76,19.55) 112.76,18.98 RC114.2
H_PROCHOT#_R: length 7.9
  BOTTOM w0.076: UC1.K63 112.09,28.46 112.09,27.9 111.87,27.68 111.87,25.9
  BOTTOM w0.102: 111.87,25.9 v1(111.87,23.84) 111.87,22.09 RC117.2
H_THERMTRIP#: length 191.1
  TOP w0.102: v2(151.17,117.34) 151.8,116.71 Q12.3
  IN1 w0.097: v2(87.35,25.85) 88.11,26.62 88.11,27.55 88.84,28.28 92.05,28.28 94.33,30.56 94.33,32.69 94.65,33.01 94.65,40 94.4,40.25 92.47,40.25 91.59,39.37 88.62,39.37 87.83,40.16 87.83,40.78 86.66,41.95 86.66,49.39 87.1,49.83 87.1,56.76 86.18,57.67 86.18,59.58 85.8,59.96 85.8,64.79 83.57,67.02 83.57,72.45 82.93,73.08 82.93,81.44 83.7,82.21 83.7,84.1 85,85.41 85,88.26 89.51,92.76 89.51,110.04 88.65,110.89 88.65,115.5 92.37,119.22 106.41,119.22 107.01,119.82 107.73,119.82 109.07,121.15 109.07,121.28 v2(109.57,121.78)
  BOTTOM w0.102: RC172.1 99.24,24.63 R24.2 98.27,24.9 97.4,25.77 v1(88.51,25.77) 87.43,25.77 v2(87.35,25.85) ; v2(151.17,117.34) 145.95,117.34 145.34,117.95 144.32,117.95 144.04,118.23 140.62,118.23 138.34,120.5 137.33,120.5 136.88,120.96 132.06,120.96 131.99,120.89 130.87,120.89 130.4,121.35 128.09,121.35 127.57,121.87 123.15,121.87 121.03,119.75 118.53,119.75 118.22,119.45 113.33,119.45 110.99,121.78 v2(109.57,121.78)
H_THERMTRIP#_R: length 17
  BOTTOM w0.076: 106.73,28.75 106.93,28.95 106.93,29.37 107.12,29.57 107.33,29.57 107.67,29.9 107.88,29.9 108.34,30.36 UC1.D60
  BOTTOM w0.102: RC172.2 100.83,24.63 101.38,25.17 101.38,25.64 101.89,26.15 102.13,26.15 102.65,26.67 102.65,27.49 102.78,27.61 103.1,27.61 103.22,27.74 v1(103.22,27.97) 103.22,28.5 103.35,28.63 103.54,28.63 103.67,28.5 103.67,27.61 103.8,27.49 103.95,27.49 104.08,27.61 104.08,28.5 104.2,28.63 104.43,28.63 104.56,28.5 104.56,27.74 104.69,27.61 105.21,27.61 105.34,27.74 105.34,28.26 105.45,28.38 105.62,28.38 105.74,28.26 105.74,27.74 105.86,27.61 106.35,27.61 106.46,27.72 106.46,27.93 106.34,28.06 106.28,28.06 106.16,28.19 106.16,28.62 106.28,28.75 106.73,28.75
H_VCCST_PWRGD: length 148.9
  TOP w0.102: UC4.4 140.2,69.21 RC243.1 141.63,68.78 v2(142.54,67.86) ; RC105.1 140.92,16.66 136.92,20.67 130.36,20.67 v2(129.88,20.18) 129.09,19.4 120.11,19.4 119.56,18.85 116.18,18.85 v1(115.69,19.34) 114.18,20.84 113.53,20.84 112.84,21.54 112.84,25.46 109.54,28.76 105.89,28.76 105.33,28.2 104.81,28.2 104.58,28.43 101.71,28.43 100.81,29.33 v2(100.37,29.33)
  IN2 w0.102: v2(129.88,20.18) 129.88,18.34 131.91,16.31 151.78,16.31 154.82,19.36 154.82,50.51 155.96,51.64 155.96,68.3 154.18,70.07 151.92,70.07 151.54,70.45 149.45,70.45 147.38,68.38 144.39,68.38 143.37,67.36 142.76,67.36 142.54,67.58 v2(142.54,67.86)
  BOTTOM w0.102: RC245.1 100.04,29 v2(100.37,29.33)
H_VCCST_PWRGD_XDP: length 4.5
  TOP w0.102: JXDP1.39 139.15,13.29 v1(139.94,14.08) 140.92,15.06 RC105.2 RC106.2
H_VR_EN: length 55.1
  IN2 w0.102: v2(84.17,22.72) 84.17,22.66 84.31,22.52 84.31,16.89 82.71,15.29 72.08,15.29 70.81,16.56 59.03,16.56 v2(58.14,15.68)
  BOTTOM w0.102: RC246.1 RC256.2 97.24,26.79 85.38,26.79 v1(84.91,26.31) 83.96,25.37 83.96,22.94 v2(84.17,22.72) ; v2(58.14,15.68) 57.5,15.04 PR312.2
H_VR_READY: length 59.2
  IN1 w0.097: v2(87.1,26.38) 86.63,26.38 85.81,25.56 85.81,22.39 83.88,20.46 83.88,17.41 82.16,15.69 72.43,15.69 70.85,17.28 57.68,17.28 v2(56.49,18.47)
  BOTTOM w0.102: RC259.2 RC255.2 ; RC255.2 99.17,25.85 98.84,25.52 98.34,25.52 97.47,26.38 v1(94.44,26.38) v2(87.1,26.38) ; RC255.2 RC256.1 RC247.1
  BOTTOM w0.254: PR317.2 55.99,18.47 v2(56.49,18.47) 56.49,18.62 56.99,19.13 57.52,19.13 57.87,19.48 PD300.2
HDD_DET#: length 108.5
  IN2 w0.102: v2(83.48,126.38) 83.03,125.93 83.03,123.24 83.6,122.67 83.6,116.04 82.4,114.84 82.4,110.35 79.22,107.18 79.22,101.21 81,99.43 81,90.04 82.36,88.68 82.36,85.18 83.73,83.81 83.73,78.49 v2(85.04,77.18)
  IN3 w0.102: v2(119.2,76.47) 117.96,76.47 117.62,76.81 115.16,76.81 114.81,76.47 113.8,76.47 113.54,76.72 112.72,76.72 112.45,76.46 112.45,74.45 111.86,73.85 109.53,73.85 107.72,72.05 104.33,72.05 101.97,74.42 100.78,74.42 96.86,78.34 93.41,78.34 92.62,77.55 85.41,77.55 v2(85.04,77.18)
  BOTTOM w0.076: 115.59,69.84 115.59,69.22 115.73,69.08 115.73,68.66 116,68.39 UC1.U1
  BOTTOM w0.102: v2(119.2,76.47) 119.58,76.09 119.58,75.62 118.64,74.68 118.64,73.97 RC11.1 119.23,73.33 118.24,72.34 118.02,72.34 117.35,71.67 116.73,71.67 115.59,70.53 115.59,69.84 ; JSATA1.12 85.03,126.38 v2(83.48,126.38)
HDD_DEVSLP: length 100
  TOP w0.102: v2(83.35,109.97) 83.58,109.74 v1(85.41,109.74) 85.6,109.74 85.7,109.85 R124.2
  IN2 w0.076: v2(111.78,69.72) 111.2,69.72 111.07,69.84
  IN2 w0.102: v2(108.58,86.28) 109.07,85.8 109.07,84.9 101.63,77.46 101.63,72.15 102.31,71.47 110.29,71.47 110.77,70.98 110.77,70.15 111.07,69.84 ; v2(103.54,99.56) 103.16,99.18 83.54,99.18 81.57,101.15 81.57,104.19 83.35,105.97 v2(83.35,109.97) 84.23,110.85 84.23,123.1 v2(83.45,123.88)
  BOTTOM w0.076: UC1.L2 112.98,66.56 112.73,66.81 112.73,67.33 112.97,67.57 112.97,67.95 112.29,68.63 112.29,69.35 111.92,69.72 v2(111.78,69.72)
  BOTTOM w0.102: v2(108.58,86.28) 108.24,86.63 108.24,94.86 v2(103.54,99.56) ; R52.1 82.59,124.74 v2(83.45,123.88)
HDD_FALL_INT: length 87.4
  TOP w0.102: v2(109.9,87.6) 110.01,87.5 R73.1 R76.1 R75.1 ; R77.1 159.18,122.49 159.18,120.84 157.26,118.93 156.69,118.93 155.99,118.22 155.99,115.26 156.51,114.73 157.15,114.73 157.68,114.2 157.68,113.08 156.06,111.46 156.06,109.21 156.46,108.8 156.46,108.03 v1(156.78,107.71) 157.05,107.45 157.05,102.91 156.54,102.4 156.54,94.38 v2(156.69,94.23)
  IN2 w0.102: v2(109.9,87.6) 109.98,87.68 111.19,87.68 112.37,88.87 117.68,88.87 118.3,89.49 121.79,89.49 122.72,88.56 123.82,88.56 125.15,89.88 132.84,89.88 133.5,89.22 134.6,89.22 135.03,89.65 147.49,89.65 151.42,93.59 151.42,94.23 151.83,94.63 156.29,94.63 v2(156.69,94.23)
HDD_LED#: length 6.5
  TOP w0.102: JLED1.5 184.13,6.85 183.36,7.61 181.76,7.61 v1(181.46,7.31) 181.18,7.03 Q26.3
HDMI_CEC: length 9.4
  TOP w0.102: R473.2 v2(14.15,102.72)
  IN1 w0.097: JHDMI1.13 11.69,97.06 11.69,99.46 14.15,101.92 v2(14.15,102.72)
  BOTTOM w0.102: v1(15.09,102.68) 14.19,102.68 v2(14.15,102.72)
HDMI_HPD_SINK: length 30.4
  TOP w0.102: QZ22.6 24.12,91 24.18,90.94 R474.1 25.56,90.42 25.69,90.54 25.69,94.35 24.62,95.42 v1(24.62,96.37) 24.62,101.05 v2(24.17,101.5)
  BOTTOM w0.102: v2(24.17,101.5) 23.75,101.5 21.42,103.83 18.01,103.83 16.52,102.34 14.86,102.34 13.65,101.13 12.52,101.13 10.93,99.54 JHDMI1.19
HDMI_OB: length 21.1
  TOP w0.508: v2(20.4,102.01) 20.34,101.96 v1(20.34,100.4) v2(20.34,99.28) v2(20.34,97.4) 20.34,95.27 v2(20.31,95.23) 20.31,94.85 18.91,93.45 v2(18.91,92.89) 18.99,92.82 22.48,92.82 22.82,93.08 QZ22.3
  BOTTOM w0.381: v2(20.4,102.01) 20.4,102.05 R463.2 ; R468.2 19.1,95 19.32,94.78 R467.2 19.86,94.78 v2(20.31,95.23) ; v2(20.34,97.4) 20.27,97.48 R469.2 19.34,97.48 18.93,97.07 R464.2 ; R466.2 19,99.76 19.4,99.36 R462.2 20.27,99.36 v2(20.34,99.28) ; v2(18.91,92.89) 19.18,92.62 R465.2
HOST_DEB_TX: length 4.8
  TOP w0.102: v1(147.27,127.65) 147.85,127.07 148.68,127.07 149.15,126.6 R400.1 150.52,125.26 JDEG1.8
HOST_DEBUG_RX: length 8.5
  TOP w0.102: U38.B46 143.64,107.77 v2(143.66,107.75) ; RP16.7 141,112.17 v2(141.17,112.01)
  IN3 w0.102: v2(141.17,112.01) 141.74,111.44 141.74,109.69 143.66,107.77 v2(143.66,107.75)
  BOTTOM w0.102: v2(141.17,112.01) 141.54,112.37 v1(142.79,112.37)
HOST_DEBUG_TX: length 23.6
  TOP w0.102: v2(145.33,124.45) 145.33,124.9 v1(145.7,125.27) 147.04,126.61 R396.2 148.26,126.61 R400.2 ; v2(144.65,107.75) 144.64,107.76 U38.B44
  IN3 w0.102: v2(144.65,107.75) 144.63,107.75 142.4,109.98 142.4,111.5 142.44,111.53 142.44,118.58 143.26,119.39 143.26,122.38 v2(145.33,124.45)
HS_IND/CFG_SEL1: length 5.1
  TOP w0.102: U90.25 v1(168.08,120.4) 166.57,120.4 166.27,120.7 R2695.2 R2691.1
HSYNC_BUF: length 166.8
  TOP w0.102: v2(160.5,156.14) 160.5,155.44 160.37,155.31 160.37,154.74 159.97,154.33 U39.20
  IN3 w0.102: v2(312.01,161.03) 311.63,161.03 311.25,160.65 304.27,160.65 303.19,161.73 292.33,161.73 289.98,164.08 280.45,164.08 279.44,165.09 275.61,165.09 273.84,166.87 266.29,166.87 265.78,166.36 237.46,166.36 236.6,165.5 228.97,165.5 227.09,163.62 221.77,163.62 219.28,161.13 196.23,161.13 v2(195.87,160.77)
  BOTTOM w0.102: v2(312.01,161.03) 311.64,161.4 JIO1.26 ; v2(195.87,160.77) 195.55,161.09 191.73,161.09 188.44,157.8 v1(188.44,156.1) 188.44,155.29 187.68,154.52 177.8,154.52 177.6,154.32 172.1,154.32 171.3,155.12 166.15,155.12 164.57,156.71 163.17,156.71 162.15,155.69 160.76,155.69 160.5,155.95 v2(160.5,156.14)
HSYNC_DOCK: length 11.8
  TOP w0.102: v2(161.14,156.14) 161.14,155.63 160.69,155.19 160.69,154.61 160.37,154.29 U39.19
  BOTTOM w0.102: v2(161.14,156.14) v1(162.25,157.25) 164.45,159.45 JDOCK1.65
HUB_USBP1+: length 35.4
  TOP w0.102: U90.2 175.91,119.9 176,119.82 178.28,119.82 179.42,120.96 184.38,120.96 188.06,117.28 192.12,117.28 194.35,115.05 194.35,110.37 v3(192.68,108.7) 190.53,106.54 190.12,106.54 190.11,106.53 189.57,106.53 189.56,106.54 188.81,106.54 L54.4 187.84,105.57 R742.1
HUB_USBP1-: length 35.1
  TOP w0.102: R741.1 187.27,106.14 L54.1 187.67,106.54 188.5,106.54 188.72,106.76 v3(189.84,106.76) 190.44,106.76 192.33,108.65 192.33,108.67 192.7,109.05 192.72,109.05 194.13,110.46 194.13,114.96 192.04,117.06 187.97,117.06 184.29,120.74 179.51,120.74 178.37,119.6 176.19,119.6 176,119.4 U90.1
HUB_USBP1_R_D+: length 10.7
  TOP w0.102: JBIO1.4 188.06,99.97 187.81,99.71 187.81,99.43 187.77,99.39 187.58,99.39 187.53,99.44 186.46,100.51 185.97,100.51 185.37,101.1 185.37,101.32 185.48,101.43 186.04,101.43 D78.2 186.23,102.51 186.04,102.7 185.41,102.7 185.25,102.86 185.25,103.4 v3(185.9,104.05) 186.3,104.45 186.71,104.45 L54.3 187.13,104.86 R742.2
HUB_USBP1_R_D-: length 10.7
  TOP w0.102: R741.2 186.56,105.43 L54.2 186.16,105.03 186.16,104.61 185.94,104.4 185.92,104.4 185.55,104.02 185.55,104 185.03,103.49 185.03,102.82 184.9,102.69 184.49,102.69 184.3,102.51 D78.3 184.49,101.43 185.06,101.43 185.16,101.32 185.16,101.01 185.88,100.3 186.37,100.3 187.38,99.29 187.49,99.18 187.87,99.18 188.08,98.97 JBIO1.3
HUB_USBP2+: length 200.2
  TOP w0.102: v2(177.2,121.02) 177.39,120.83 177.39,120.69 177.21,120.51 177.18,120.51 177.16,120.53 176.52,120.53 176.5,120.51 176.44,120.51 176.19,120.77 175.92,120.77 175.78,120.9 U90.4
  IN1 w0.097: v2(89.28,82.5) 89.48,82.3 89.69,82.3 89.95,82.03 89.95,71.3 90.15,71.1 90.15,66.06 90.75,65.46 90.75,59.84 92.25,58.33 92.25,46.93 93.9,45.28 95.1,45.28 98.73,41.66 98.73,40.72 98.07,40.06 98.07,24.3 97.53,23.76 96.54,23.76 95.81,23.03 95.81,22.47 v2(96.01,22.26)
  IN3 w0.102: v2(89.28,82.5) 89.46,82.32 90.19,82.32 91.13,83.26 97.93,83.26 98.42,83.75 112.43,83.75 113.38,84.7 117.4,84.7 118.72,86.02 123.23,86.02 123.95,85.3 125.89,85.3 126.59,84.6 127.61,84.6 128.34,85.34 134.39,85.34 134.89,84.84 136.42,84.84 137.66,86.08 140.02,86.08 140.79,85.31 143.94,85.31 144.22,85.03 149.25,85.03 150.77,83.51 153.89,83.51 155,82.39 156.54,82.39 157.17,81.75 158.91,81.75 159.08,81.59 160.39,81.59 161.15,82.35 162.93,82.35 163.92,83.34 165.93,83.34 168.69,86.11 168.69,88.22 169.9,89.42 169.9,89.78 171.68,91.56 174.09,91.56 175.11,92.57 176.1,92.57 176.63,93.11 176.63,95.8 176.41,96.02 176.41,97.82 176.25,97.98 176.25,109.13 176.94,109.82 176.94,113.68 178.41,115.15 178.41,117.59 177.37,118.63 177.37,120.86 v2(177.2,121.02)
  BOTTOM w0.102: v2(96.01,22.26) 95.83,22.08 95.83,21.63 96.28,21.18 L59.1 96.28,20.22 R487.1
HUB_USBP2+_D: length 3
  TOP w0.102: v2(96.1,17.72) 95.92,17.9 95.92,18.05 96.06,18.2 JEXP1.10
  BOTTOM w0.102: v2(96.1,17.72) 95.92,17.9 95.92,18.24 96.28,18.6 L59.2 96.28,19.26 R487.2
HUB_USBP2-: length 200.4
  TOP w0.102: U90.3 175.78,120.4 175.93,120.55 176.1,120.55 176.35,120.3 v3(176.78,120.3) 177.3,120.3 177.61,120.6 177.61,120.85 v2(177.78,121.02)
  IN1 w0.097: v2(95.43,22.26) 95.6,22.43 95.6,23.12 96.45,23.97 97.44,23.97 97.86,24.39 97.86,40.15 98.52,40.81 98.52,41.57 95.02,45.07 93.82,45.07 92.04,46.84 92.04,58.25 90.54,59.75 90.54,65.38 89.94,65.98 89.94,71.02 89.74,71.21 89.74,81.95 89.6,82.09 89.45,82.09 v2(89.28,81.92)
  IN3 w0.102: v2(89.28,81.92) 89.47,82.11 90.28,82.11 91.22,83.04 98.02,83.04 98.51,83.53 112.52,83.53 113.47,84.48 117.49,84.48 118.81,85.8 123.14,85.8 123.86,85.08 125.8,85.08 126.5,84.38 127.7,84.38 128.43,85.12 134.3,85.12 134.8,84.62 136.51,84.62 137.75,85.86 139.93,85.86 140.7,85.09 143.85,85.09 144.13,84.81 149.16,84.81 150.68,83.29 153.8,83.29 154.91,82.17 156.45,82.17 157.08,81.54 158.82,81.54 158.99,81.37 160.48,81.37 161.24,82.13 163.02,82.13 164.01,83.13 166.02,83.13 168.91,86.02 168.91,88.13 170.12,89.33 170.12,89.69 171.77,91.34 174.18,91.34 175.2,92.36 176.19,92.36 176.85,93.02 176.85,95.89 176.63,96.1 176.63,97.91 176.47,98.07 176.47,109.05 177.15,109.73 177.15,113.59 178.62,115.07 178.62,117.68 177.58,118.72 177.58,120.82 v2(177.78,121.02)
  BOTTOM w0.102: R486.1 95.43,20.22 L59.4 95.43,21.18 95.43,21.18 95.61,21.36 95.61,22.08 v2(95.43,22.26)
HUB_USBP2-_D: length 3
  TOP w0.102: JEXP1.12 95.56,18.2 95.7,18.05 95.7,17.9 v2(95.52,17.72)
  BOTTOM w0.102: R486.2 95.43,19.26 L59.3 95.43,18.58 95.7,18.31 95.7,17.91 v2(95.52,17.72)
HUB_USBP3+: length 142.4
  TOP w0.102: v2(176.76,122.67) 176.57,122.48 176.03,122.48 175.95,122.4 U90.7
  IN1 w0.097: v2(176.76,122.67) 176.94,122.48 184.14,122.48 184.97,123.31 185.93,123.31 190.35,127.73 202.22,127.73 203.26,128.78 210.2,128.78 213.44,132.02 213.44,134.13 215.54,136.22 215.54,137.49 216.93,138.89 217.23,138.89 217.78,139.44 218.94,139.44 223.16,143.65 223.16,144.44 224.56,145.85 225.35,145.85 226.26,146.75 227.2,146.75 228.49,148.05 231.38,148.05 237.38,154.05 237.38,155.4 238.45,156.47 242.49,156.47 244.68,158.66 254.65,158.66 255.1,159.11 256.11,159.11 256.85,158.37 258.34,158.37 263.05,153.66 268.9,153.66 272.88,149.68 276.09,149.68 277.72,151.31 291.69,151.31 291.95,151.06 291.95,150.77 v2(292.15,150.56)
  BOTTOM w0.102: JMINI1.38 292.26,149.73 291.97,150.03 291.97,150.38 v2(292.15,150.56)
HUB_USBP3-: length 142.2
  TOP w0.102: v2(176.76,122.08) 176.57,122.27 176.12,122.27 175.75,121.9 U90.6
  IN1 w0.097: v2(176.76,122.08) 176.95,122.27 184.23,122.27 185.06,123.1 186.01,123.1 190.44,127.52 202.31,127.52 203.35,128.57 210.29,128.57 213.65,131.93 213.65,134.04 215.75,136.14 215.75,137.41 217.02,138.68 217.32,138.68 217.87,139.23 219.03,139.23 223.37,143.56 223.37,144.35 224.65,145.64 225.44,145.64 226.34,146.54 227.28,146.54 228.58,147.84 231.47,147.84 237.59,153.96 237.59,155.31 238.54,156.26 242.57,156.26 244.77,158.45 254.74,158.45 255.18,158.9 256.03,158.9 256.76,158.16 258.26,158.16 262.97,153.45 268.81,153.45 272.79,149.47 276.18,149.47 277.81,151.1 291.61,151.1 291.74,150.97 291.74,150.73 v2(291.57,150.56)
  BOTTOM w0.102: v2(291.57,150.56) 291.75,150.38 291.75,150.03 291.46,149.73 JMINI1.36
HUB_USBP4+: length 64.8
  TOP w0.102: U90.9 175.91,123.4 176.01,123.5 177.25,123.5 v2(177.44,123.7)
  IN1 w0.097: v2(225.22,147.13) 225.02,146.93 224.67,146.93 220.04,142.3 220.04,141.68 218.53,140.17 216.88,140.17 216.25,139.54 216.25,139.24 214.84,137.83 214.84,136.56 212.74,134.46 212.74,132.31 209.92,129.49 202.26,129.49 201.24,128.46 189.83,128.46 185.69,124.32 184.59,124.32 183.51,123.25 179.05,123.25 178.79,123.51 177.63,123.51 v2(177.44,123.7)
  BOTTOM w0.102: v2(225.22,147.13) 225.04,146.96 224.75,146.96 224.44,147.26 L57.4 223.49,147.26 R483.1
HUB_USBP4+_D: length 3.3
  BOTTOM w0.102: R483.2 222.48,147.26 L57.3 221.8,147.26 221.4,146.87 220.83,146.87 220.6,147.1 JMINI2.38
HUB_USBP4-: length 64.9
  TOP w0.102: v2(177.44,123.11) 177.27,123.28 176.1,123.28 175.72,122.9 U90.8
  IN1 w0.097: v2(225.22,146.55) 225.05,146.72 224.76,146.72 220.26,142.22 220.26,141.6 218.62,139.96 216.97,139.96 216.46,139.45 216.46,139.15 215.05,137.74 215.05,136.47 212.95,134.38 212.95,132.22 210.01,129.28 202.35,129.28 201.32,128.25 189.92,128.25 185.78,124.11 184.68,124.11 183.6,123.04 178.97,123.04 178.71,123.3 177.63,123.3 v2(177.44,123.11)
  BOTTOM w0.102: v2(225.22,146.55) 225.03,146.74 224.77,146.74 224.44,146.41 L57.1 223.5,146.41 R482.1
HUB_USBP4-_D: length 3.3
  BOTTOM w0.102: JMINI2.36 220.51,146.3 220.87,146.66 221.59,146.66 221.83,146.41 L57.2 222.47,146.41 R482.2
HW_GPS_DISABLE#: length 115.7
  TOP w0.102: U37.B34 162.53,93.59 162.28,93.34 162.28,92.83 160.89,91.44 160.89,90.47 161.21,90.16 161.84,90.16 162.15,89.84 R282.2 161.64,88.9 161.64,87.62 163.55,85.72 166.09,85.72 167.08,86.71 168.95,86.71 169.29,87.05 169.96,87.05 170.51,87.59 173.88,87.59 175.25,88.95 v1(183.23,88.95) 186.66,88.95 v2(186.98,89.27)
  IN3 w0.102: v2(186.98,89.27) 187.17,89.46 187.17,93.84 187.87,94.54 187.87,95.62 188.95,96.7 188.95,103.81 189.79,104.65 189.79,112.96 190.6,113.78 190.6,114.48 191.74,115.62 191.74,122.42 192.12,122.8 192.12,125.28 193.14,126.29 193.14,127.18 197.29,131.33 207.2,131.33 208.57,132.7 208.57,134.5 210.33,136.26 210.33,150.63 v2(209.9,151.06)
  BOTTOM w0.102: v2(209.9,151.06) 209.9,152.14 210.07,152.3 JMINI2.51
I2C0_SCL: length 6.2
  BOTTOM w0.076: UC1.F3 110.05,66.21 110.29,66.45 110.29,66.68 110.11,66.86 109.81,66.86 109.59,67.08 109.59,68.11 108.93,68.77
  BOTTOM w0.102: 108.93,68.77 107.79,69.91 107.79,70.24 107.93,70.38 RP8.7
I2C0_SDA: length 5.4
  BOTTOM w0.076: 108.71,68.66 108.73,68.65 108.74,68.65 108.78,68.61 108.8,68.61 109.38,68.03 109.38,66.98 109.8,66.56 UC1.F2
  BOTTOM w0.102: RP8.8 107.43,70.38 107.56,70.24 107.56,69.81 108.71,68.66
I2C1_SCL_TCH_PAD: length 106.6
  TOP w0.102: R449.1 180.19,101.97 v2(180.27,102.06)
  IN3 w0.102: v2(180.27,102.06) 180.45,101.88 180.45,101.74 180.26,101.54 179.99,101.54 179.5,101.05 179.5,97.28 179.61,97.16 179.61,93.06 178.82,92.27 177.14,92.27 176.51,91.63 175.54,91.63 173.98,90.07 171.94,90.07 170.2,88.33 170.2,86.3 166.17,82.27 165.57,82.27 165.45,82.16 163.75,82.16 163.25,81.65 161.46,81.65 160.57,80.76 158.85,80.76 158.56,81.06 156.85,81.06 156.23,81.68 154.7,81.68 153.58,82.8 150.47,82.8 148.94,84.32 140.68,84.32 139.85,83.48 138.15,83.48 137.49,82.82 134.92,82.82 133.83,83.91 130.78,83.91 130.02,83.15 119.38,83.15 117.73,81.5 115.24,81.5 112.7,78.96 109.61,78.96 109.16,78.51 109.16,77.94 110.21,76.89 110.21,74.91 v2(110.03,74.73)
  BOTTOM w0.076: UC1.F1 109.89,67.29 109.89,68.28 108.58,69.6 108.58,69.82 108.56,69.83 108.56,69.84
  BOTTOM w0.102: 108.56,69.84 108.56,70.24 108.43,70.38 RP8.6 108.43,71.04 108.62,71.24 109.19,71.24 110.21,72.26 v3(110.21,73.89) 110.21,74.55 v2(110.03,74.73) 110.03,74.72 110.26,74.95 110.26,75.05 RC176.2
I2C1_SCL_VMM: length 30.3
  TOP w0.102: U6.A2 116.95,100.64 116.75,100.64 116.37,100.26 116.37,100.07 114.62,98.31 114.62,92.48 114.71,92.39 114.71,92.03 v2(114.53,91.85)
  BOTTOM w0.102: RC176.1 110.11,76.8 110.11,77.74 110.39,78.02 110.39,82.74 109.54,83.59 109.54,86.92 109.19,87.26 109.19,88.63 111.15,90.58 113.87,90.58 114.64,91.35 114.64,91.74 v2(114.53,91.85)
I2C1_SDA_TCH_PAD: length 108.4
  TOP w0.102: v2(180.86,102.06) 180.94,101.97 R450.1
  IN3 w0.102: v2(110.61,74.73) 110.44,74.9 110.44,76.98 109.38,78.04 109.38,78.41 109.7,78.73 112.79,78.73 115.33,81.27 117.83,81.27 119.48,82.92 130.12,82.92 130.88,83.68 133.74,83.68 134.83,82.59 137.58,82.59 138.24,83.25 139.94,83.25 140.78,84.09 148.85,84.09 150.37,82.57 153.49,82.57 154.6,81.45 156.13,81.45 156.76,80.83 158.46,80.83 158.76,80.53 160.67,80.53 161.56,81.42 163.34,81.42 163.85,81.93 165.55,81.93 165.66,82.05 166.27,82.05 170.43,86.21 170.43,88.24 172.03,89.84 174.08,89.84 175.64,91.4 176.6,91.4 177.24,92.04 178.92,92.04 179.84,92.96 179.84,97.26 179.73,97.37 179.73,100.96 180.08,101.31 180.35,101.31 180.68,101.64 180.68,101.88 v2(180.86,102.06)
  BOTTOM w0.076: 108.79,69.84 108.79,69.83 108.78,69.82 108.78,69.68 110.1,68.37 110.1,67.61 110.3,67.4 110.3,67.04 110.45,66.89 110.45,66.38 110.33,66.26 110.33,65.65 UC1.G4
  BOTTOM w0.102: RC174.2 110.55,75.38 110.55,74.79 v2(110.61,74.73) 110.44,74.55 110.44,72.16 109.28,71.01 108.97,71.01 108.93,70.97 RP8.5 108.93,70.38 108.79,70.24 108.79,69.84
I2C1_SDA_VMM: length 30
  TOP w0.102: v2(115.11,91.85) 114.93,92.03 114.93,92.49 114.85,92.57 114.85,98.22 116.6,99.97 116.6,100.17 116.85,100.42 116.95,100.42 U6.A1
  BOTTOM w0.102: RC174.1 110.33,76.84 110.33,77.65 110.61,77.93 v3(110.61,81.4) 110.61,82.84 109.77,83.68 109.77,87.01 109.42,87.36 109.42,88.53 111.24,90.35 113.96,90.35 114.87,91.26 114.87,91.61 v2(115.11,91.85)
I2CC_SCL: length 10.5
  BOTTOM w0.102: v1(59.61,101.51) RV45.2 60.62,101.02 60.81,100.83 62.27,100.83 62.97,100.13 62.97,98.54 66.09,95.42 UV1.A9
I2CC_SDA: length 9.8
  BOTTOM w0.102: RV46.2 62.28,101.51 v1(62.8,100.99) 63.83,99.97 63.83,98.63 66.46,95.99 66.46,94.89 66.09,94.51 UV1.B9
I2CS_SCL: length 16.1
  IN2 w0.102: v4(66.51,92.35) 68.87,94.71 68.87,98.63 71.4,101.16 v2(71.4,101.42)
  BOTTOM w0.1: v4(66.51,92.35) 66.11,92.75 UV1.D9
  BOTTOM w0.102: v2(71.4,101.42) 70.86,101.42 v1(69.77,102.51) 69.77,103.03 69.6,103.2 QC9.1 70.77,103.6 RV49.2
I2CS_SDA: length 18.6
  IN2 w0.102: v4(66.51,93.15) 68.49,95.13 68.49,101.6 69.34,102.45 69.34,105.44 v2(68.62,106.16)
  BOTTOM w0.1: v4(66.51,93.15) 66.91,92.75 UV1.D8
  BOTTOM w0.102: RV50.2 70.43,106.84 v1(69.44,106.84) 69.07,106.84 68.62,106.38 v2(68.62,106.16) 68.3,105.84 QC9.4
I2S_BCLK: length 65.8
  IN3 w0.102: v2(260.2,153.96) 259.03,155.12 253.04,155.12 250.25,157.92 243.26,157.92 241.1,155.76 227.88,155.76 v2(226.86,156.77)
  BOTTOM w0.102: v2(226.86,156.77) 226.41,156.33 225.97,156.33 222.42,159.87 221.54,159.87 v1(218.83,162.58) 217.97,163.44 R139.2 ; U17.16 v2(260.2,153.96)
I2S_DI#: length 70.5
  IN3 w0.102: v2(260.45,150.04) 260.64,150.23 260.64,154.74 259.18,156.2 252.97,156.2 250.46,158.7 243.05,158.7 241.56,157.22 226.22,157.22 v2(226.06,157.38)
  BOTTOM w0.102: R144.2 218.67,164.65 v1(220.83,162.49) 225.93,157.38 v2(226.06,157.38)
  BOTTOM w0.254: v2(260.45,150.04) 260.37,149.96 U17.24
I2S_DO: length 69.9
  IN3 w0.102: v2(226.58,157.65) 230.18,157.65 230.99,158.46 239.51,158.46 239.96,158.9 242.74,158.9 242.96,159.12 250.55,159.12 252.96,156.71 259.18,156.71 261.07,154.82 v2(261.07,153.92)
  BOTTOM w0.102: v2(261.07,153.92) 260.62,153.46 U17.17 ; R141.2 218.54,165.28 224.88,158.94 v1(225.05,158.94) 225.29,158.94 v2(226.58,157.65)
I2S_LRCLK: length 67.8
  IN3 w0.102: v2(260.14,152.96) 260.14,153.28 258.67,154.74 252.92,154.74 250.25,157.41 243.26,157.41 241.23,155.38 227.62,155.38 v2(226.22,156.77)
  BOTTOM w0.102: R143.2 200.93,163.99 217.99,163.99 v1(221.46,160.52) 221.65,160.33 222.48,160.33 226.03,156.77 v2(226.22,156.77) ; U17.18 v2(260.14,152.96)
I2S_MCLK: length 66.1
  IN3 w0.102: v2(260.2,154.55) 259.12,155.63 253.03,155.63 250.37,158.3 243.14,158.3 241.62,156.77 v2(227.49,156.77)
  BOTTOM w0.102: R137.2 218.41,165.92 224.64,159.69 225.13,159.69 227.57,157.25 227.57,156.85 v2(227.49,156.77) ; v2(260.2,154.55) 260.1,154.46 U17.15
IMON: length 5.1
  BOTTOM w0.102: v1(49.5,11.71) PC300.1
  BOTTOM w0.203: 50.14,14.6 50.64,15.09 PU300.13
  BOTTOM w0.254: PC300.1 49.5,13.53 PR301.1 50.06,14.52 50.14,14.6
IMVP_PWRGD: length 222.2
  TOP w0.102: U37.A62 v2(173.66,100.34) ; v2(171.73,110.54) 173.37,110.54 v1(174,111.18)
  IN1 w0.097: v2(171.73,110.54) 172.44,109.83 172.44,107.85 172.95,107.34 172.95,102.41 173.66,101.7 v2(173.66,100.34)
  IN2 w0.102: v2(171.73,110.54) 171.11,109.92 170.48,109.92 166.17,105.61 157.6,105.61 156.76,104.77 156.76,103.31 155.49,102.04 155.1,102.04 154.55,101.48 154.55,101.27 153.33,100.06 153.33,99.75 152.47,98.89 150.95,98.89 148.6,96.54 147.4,96.54 146.64,95.77 146.09,95.77 145.11,94.8 142.53,94.8 141.64,95.69 137.2,95.69 135.67,94.16 132.31,94.16 130.03,96.45 125.06,96.45 123.27,94.66 116.92,94.66 116.24,93.97 115.29,93.97 113.76,92.44 111.72,92.44 111.16,91.88 94.14,91.88 92.49,90.22 90.08,90.22 85.83,85.97 85.83,78.16 86.17,77.81 86.17,76.03 85.55,75.4 84.71,75.4 84.33,75.02 84.33,65.8 83.98,65.46 83.98,64.25 86.27,61.97 86.27,55.36 87.73,53.9 87.73,32.58 87.27,32.12 81.89,32.12 81.38,31.61 81.38,26.34 81.95,25.77 81.95,24.05 83.86,22.14 83.86,17.08 82.58,15.8 72.34,15.8 71,17.14 57.06,17.14 56.49,17.71 v2(56.49,17.71)
  BOTTOM w0.254: v2(56.49,17.71) PR318.2
IMVP_VR_ON: length 236.5
  TOP w0.102: v2(180.48,117.33) 180.25,117.1 180.25,111.94 178.72,110.41 178.72,105.95 v1(178.45,105.69) R294.2
  IN2 w0.102: v2(180.48,117.33) 176.81,113.66 174.88,113.66 173.84,112.62 173.84,111.37 172.16,109.69 170.64,109.69 166.33,105.38 159.36,105.38 158.76,104.79 157.54,104.79 157.07,104.32 157.07,103.18 156.69,102.8 156.69,101.72 155.23,100.26 154.41,100.26 152.48,98.33 150.71,98.33 147.92,95.54 146.31,95.54 145.3,94.54 142.4,94.54 141.52,95.43 137.32,95.43 135.8,93.91 132.24,93.91 129.93,96.22 125.15,96.22 123.36,94.43 117.02,94.43 116.31,93.72 115.42,93.72 113.91,92.21 111.88,92.21 111.29,91.62 94.27,91.62 92.62,89.97 90.21,89.97 86.08,85.84 86.08,78.29 86.4,77.97 86.4,75.81 85.76,75.18 84.81,75.18 84.56,74.92 84.56,65.65 84.24,65.33 84.24,64.38 86.59,62.03 86.59,55.49 87.98,54.09 87.98,32.5 87.35,31.87 82.02,31.87 81.63,31.49 81.63,26.47 82.21,25.9 82.21,24.12 84.09,22.24 84.09,16.99 82.64,15.55 72.21,15.55 70.88,16.88 58.71,16.88 v2(57.5,15.68)
  BOTTOM w0.102: v2(57.5,15.68) 57.25,15.93 PR313.2
INT_SPK_L+: length 59.8
  IN3 w0.635: 248.45,151.44 245.15,151.44 241.4,147.69 233.5,147.69 230.16,144.35 230.16,140.65 225.18,135.67 222.58,135.67 221.08,134.17 221.08,132.26 218.79,129.98 215.05,129.98 210.28,125.21 208.95,125.21 206.03,122.29
  BOTTOM w0.254: U17.40 v1(250.67,151.46) 249.87,151.46 v2(249.85,151.44)
  vias: v2(204.44,122.24) v2(205.05,122.24) v2(249.21,151.44)
INT_SPK_L-: length 60.1
  IN3 w0.635: 205.81,123.15 208.63,125.98 209.97,125.98 214.73,130.74 218.48,130.74 220.32,132.58 220.32,134.48 222.26,136.43 224.87,136.43 229.4,140.96 229.4,144.67 233.19,148.45 241.08,148.45 244.83,152.2 248.45,152.2
  BOTTOM w0.254: U17.41 250.53,151.96 250.29,152.2 v2(249.85,152.2)
  vias: v1(248.7,152.07) v2(204.44,123.13) v2(205.05,123.13) v2(249.21,152.2)
INT_SPK_R+: length 59.9
  IN3 w0.635: 205.84,126.1 206.22,126.1 206.86,126.74 209.65,126.74 214.54,131.63 218.16,131.63 219.49,132.96 219.49,134.87 222.16,137.53 224.7,137.53 228.51,141.34 228.51,145.05 232.68,149.22 240.57,149.22 244.38,153.03 248.79,153.03
  BOTTOM w0.254: U17.44 251.5,153.46 251.38,153.34 250.04,153.34 v2(249.59,153.79)
  vias: v1(249.27,153.36) v2(204.52,126.05) v2(205.13,126.05) v2(248.96,153.79)
INT_SPK_R-: length 59.4
  IN3 w0.635: 205.84,126.99 205.97,126.99 206.48,127.5 209.34,127.5 214.23,132.39 217.84,132.39 218.73,133.28 218.73,135.18 221.84,138.29 224.38,138.29 227.75,141.66 227.75,145.37 232.36,149.98 240.26,149.98 244.07,153.79 246.84,153.79
  BOTTOM w0.254: v2(248.2,153.79) 249.03,152.96 U17.43
  vias: v1(247.94,153.22) v2(204.52,126.98) v2(205.13,126.98) v2(247.56,153.79)
INT_SPKR_L+: length 10.7
  TOP w0.635: R2688.2 201.28,121.59 197.55,121.59 DE2.3
  BOTTOM w0.635: 197.14,122.48 197.84,123.18 202.41,123.18 202.66,122.93 JSPK1.1
  vias: v1(196.82,121.91) v2(195.87,122.36) v2(196.48,122.36)
INT_SPKR_L-: length 10.5
  TOP w0.635: R2702.2 201.47,123.82 197.61,123.82 DE2.2
  BOTTOM w0.635: JSPK1.2 202.54,124.18 202.3,123.94 197.52,123.94 197.14,123.56
  vias: v1(196.63,123.63) v2(195.87,123.12) v2(196.48,123.12)
INT_SPKR_R+: length 11.1
  TOP w0.635: R2703.2 201.4,125.47 197.67,125.47 DE1.3
  BOTTOM w0.635: 196.95,125.78 197.52,125.21 199.62,125.21 200.13,125.72 202.13,125.72 202.41,125.43 JSPK1.3
  vias: v1(196.43,125.58) v2(195.87,126.36) v2(196.48,126.36)
INT_SPKR_R-: length 10.7
  TOP w0.635: DE1.2 197.67,127.88 201.15,127.88 R2704.2
  BOTTOM w0.635: 197.4,126.42 197.84,125.98 199.3,125.98 199.81,126.48 202.16,126.48 202.36,126.68 JSPK1.4
  vias: v1(196.94,127.54) v2(195.87,127.12) v2(196.48,127.12)
INTRUDER#: length 8.1
  TOP w0.076: v2(130.91,65.31) 130.75,65.31 130.53,65.52 130.53,66.09 130.72,66.29 131.36,66.29 v1(131.53,66.46) 132.51,67.44 RC7.2
  BOTTOM w0.076: UC1.AU6 127.51,64.17 127.98,64.17 128.02,64.13 129.37,64.13 129.65,64.41 130.02,64.41 130.91,65.3 v2(130.91,65.31)
IO_LDOSEL: length 3.3
  BOTTOM w0.102: R212.2 R214.1 7.3,28.45 v1(7.95,28.45) 8.55,28.45 8.68,28.31 U27.18
IOR_DB_DET#: length 193.1
  TOP w0.102: v2(170.6,98.23) 171.39,98.23 171.75,98.59 U37.B62 ; v1(187.36,92.23) 188.09,92.96 v2(188.25,92.96)
  IN2 w0.102: v2(188.25,92.96) 188.76,93.46 188.76,101.72 195.11,108.07 195.11,119.82 196.4,121.11 206.02,121.11 209.61,124.71 215.43,124.71 235.3,144.58 235.3,146.81 239.36,150.87 242.29,150.87 244.03,152.61 250.51,152.61 253.15,155.25 261.85,155.25 262.8,154.3 269.66,154.3 270.04,154.68 274.67,154.68 275.56,153.79 283.69,153.79 285.09,152.39 296.2,152.39 297.72,153.91 299.09,153.91 302.33,157.15 304.01,157.15 304.71,157.85 308.58,157.85 309.35,157.09 v2(309.35,156.26)
  BOTTOM w0.102: v2(170.6,98.23) 170.76,98.06 171.77,98.06 172.71,97.12 175.85,97.12 176.82,96.15 176.82,96.13 178.09,94.86 182.31,94.86 182.74,94.43 182.74,94.43 183.4,93.77 185.91,93.77 186.73,92.96 v2(188.25,92.96) ; v2(309.35,156.26) 309.35,154.8 309.75,154.4 JIO1.54 311.65,154.4 311.82,154.23 312.98,154.23 R476.1
IRQ_SERIRQ: length 121.9
  TOP w0.102: U38.A28 150.95,105.56 151.17,105.78 151.52,105.78 151.55,105.82 151.56,105.82 v2(151.64,105.9) ; U25.27 164.33,109.33 v2(164.82,108.84) 164.82,108.79 v1(164.32,108.3) ; v2(163.54,100) 163.45,100.09 U37.B21 ; RP3.8 113.52,85.26 113.32,85.46 v2(113.32,85.91)
  IN2 w0.076: v2(115.62,65.59) 115.67,65.59 116.05,65.96 116.05,66.43 115.7,66.78 115.37,66.78 114.39,67.76 114.39,69.42 113.96,69.84
  IN2 w0.102: v2(154.47,93.37) 154.44,93.37 152.86,91.79 150.92,91.79 147.83,88.7 141.46,88.7 141.2,88.43 135.17,88.43 134.56,87.82 130.94,87.82 130.2,88.56 125.27,88.56 124.36,87.65 121.39,87.65 120.67,88.36 118.88,88.36 118.27,87.75 118.27,87.41 118.08,87.21 117.48,87.21 117.43,87.27 116.74,87.27 116.02,86.54 113.75,86.54 113.32,86.11 v2(113.32,85.91) 113.32,85.37 110.89,82.95 110.89,77.98 110.74,77.83 110.74,76.4 112.5,74.65 112.5,72.25 113.31,71.43 113.31,70.49 113.96,69.84
  IN3 w0.102: v2(164.82,108.84) 164.74,108.77 164.74,107.51 163.98,106.75 163.98,106.32 163.1,105.44 163.1,102.52 163.99,101.63 163.99,100.45 v2(163.54,100) ; v2(154.47,93.37) 154.47,95.12 153.95,95.64 153.95,106.52 152.78,107.69 151.42,107.69 151.1,107.37 151.1,106.43 v2(151.64,105.9)
  BOTTOM w0.076: v2(115.62,65.59) 115.54,65.59 UC1.T4
  BOTTOM w0.102: v2(151.64,105.9) 151.62,105.9 150.85,106.67 150.85,107 151.42,107.57 152.75,107.57 153.66,106.67 161.36,106.67 162.53,107.84 162.53,108.98 162.85,109.3 164.36,109.3 v2(164.82,108.84)
JTAG_CLK: length 45.5
  TOP w0.102: U38.B56 140.88,105.81 140.94,105.75 141.53,105.75 v2(141.91,105.38) ; RP2.3 137.03,120.26 139.22,122.44 143.79,122.44 144.11,122.13 146.8,122.13 v1(147.29,121.63) 147.64,121.29 148.94,121.29 149.64,121.99 v2(149.64,122.86) 150.08,122.86 150.48,123.26 JDEG1.4
  IN3 w0.102: v2(149.64,122.86) 149.64,122.67 146.38,119.41 145.71,119.41 143.35,117.05 143.35,111.9 144.01,111.25 145.09,111.25 145.77,110.57 145.77,109.15 146.91,108 146.91,106.73 146.21,106.04 142.57,106.04 v2(141.91,105.38)
JTAG_RST#: length 8.5
  TOP w0.102: U38.A57 138.87,103.56 138.82,103.61 137.86,103.61 C362.1 R384.1 135.13,104.4 JTAG1.1 135.01,104.42 134.4,103.81 R380.2 134.04,103.79 132.64,102.39 132.46,102.39 v1(132.45,102.4)
JTAG_TDI: length 31.9
  TOP w0.102: RP2.1 137.44,119.26 v2(137.64,119.05) 137.83,118.86 v1(138.33,118.86) 138.87,118.86 139.57,119.56 139.57,120.41 141.11,121.95 143.64,121.95 143.92,121.67 146.36,121.67 147.2,120.83 149.13,120.83 150.55,122.26 JDEG1.2 ; U38.A51 138.83,106.56 138.31,107.08 138.31,107.73 v2(138.73,108.14)
  IN3 w0.102: v2(137.64,119.05) 137.32,118.74 137.32,116.51 138.02,115.82 138.02,110.42 138.39,110.05 138.39,108.49 v2(138.73,108.14)
JTAG_TDO: length 45.3
  TOP w0.102: RP2.4 137.1,120.76 139.25,122.91 v1(141.31,122.91) 141.64,122.91 141.88,122.67 143.89,122.67 144.21,122.36 147.12,122.36 147.95,121.52 148.67,121.52 148.89,121.74 148.89,122.74 v2(149.06,122.91) 149.42,123.27 149.92,123.27 150.41,123.76 JDEG1.5 ; U38.B55 140.73,106.31 140.89,106.15 v2(141.21,106.15)
  IN3 w0.102: v2(141.21,106.15) 141.21,106.23 141.64,106.67 142.53,106.67 142.79,106.42 145.71,106.42 146.06,106.77 146.06,108.1 145.39,108.77 145.39,110.62 144.99,111.02 143.91,111.02 143.12,111.81 143.12,118.29 143.94,119.11 143.94,120.19 146.17,122.42 147.75,122.42 148.24,122.91 v2(149.06,122.91)
JTAG_TMS: length 34.3
  TOP w0.102: v2(138.33,106.1) 138.33,106.07 138.84,105.56 U38.A53 ; RP2.2 137.83,119.76 v2(138.09,119.5) 138.09,120.72 v1(139.31,121.94) 139.55,122.18 143.73,122.18 144.02,121.9 146.46,121.9 147.3,121.06 149.03,121.06 150.15,122.18 150.15,122.48 150.42,122.76 JDEG1.3
  IN3 w0.102: v2(138.33,106.1) 136.88,107.55 136.88,119.12 137.26,119.5 v2(138.09,119.5)
KB_DET#: length 115.3
  TOP w0.102: v2(182.37,112.27) 181.47,112.27 180.51,111.31 JKB1.10
  IN3 w0.102: v2(182.37,112.27) 184.12,110.52 184.12,94.81 182.36,93.05 181.58,93.05 179.43,90.89 177.73,90.89 177.04,90.21 176.13,90.21 174.58,88.66 172.48,88.66 171.59,87.76 171.59,85.66 170.2,84.28 170.2,82.92 168.48,81.19 165.65,81.19 165.25,80.8 164.86,80.8 v2(164.45,81.21)
  BOTTOM w0.076: 126.54,69.84 126.54,69.13 126.66,69.02 126.66,68 126.2,67.55 126.2,67.08 126.4,66.88 126.59,66.88 126.79,66.69 126.79,66.17 UC1.AT3
  BOTTOM w0.102: 126.54,69.84 126.54,70.59 126.36,70.77 126.36,71.8 127.02,72.46 127.25,72.46 128.04,72.99 129.45,74.4 129.45,78.67 129.95,79.16 RP14.5 129.95,79.54 130.3,79.9 130.3,80.53 131.16,81.4 v1(131.16,81.65) 131.16,87.54 130.5,88.21 130.5,89.5 131.26,90.26 134.42,90.26 137.31,87.37 140.5,87.37 141.19,86.68 142.92,86.68 143.68,87.44 146.9,87.44 150.65,83.7 153.61,83.7 153.98,83.33 156.13,83.33 156.74,83.94 161.96,83.94 164.45,81.45 v2(164.45,81.21)
LAN_ACTLED_YEL#: length 128.8
  TOP w0.102: v2(190.98,157.47) 191.32,157.81 v1(191.64,157.81) 192.05,157.81 192.84,157.02 Q32.1
  IN3 w0.102: v2(190.98,157.47) 190.47,157.98 190.47,160.54 194.22,164.29 214.03,164.29 216.93,167.19 223.26,167.19 225.36,169.28 227.68,169.28 229.21,170.81 244,170.81 244.45,171.25 267.88,171.25 268.2,170.93 288.41,170.93 293.62,165.73 304.27,165.73 304.44,165.9 v2(305.17,165.9)
  BOTTOM w0.102: JIO1.7 v2(305.17,165.9)
LAN_ACTLED_YEL#_Q: length 7.2
  TOP w0.102: v1(194.03,154.81) Q32.6 192.84,154.16 192.54,153.86 191.67,153.86 189.9,155.63 188.84,155.63 188.77,155.7 U23.17
LAN_DISABLE#_R: length 48.8
  TOP w0.102: U37.B47 169.48,93.34 169.53,93.38 169.53,93.98 v2(169.96,94.42) ; v2(172.82,131.82) 174.9,131.82 v1(175.52,132.43) R180.2 176.51,133.43 176.51,134.43 177.3,135.22 U21.3
  IN3 w0.102: v2(169.96,94.42) 169.72,94.66 169.72,99.66 169.16,100.22 169.16,103.37 169.48,103.69 169.48,105.19 169.77,105.48 169.77,109.3 168.82,110.25 168.82,111.8 169.32,112.29 169.32,116.44 171.68,118.8 171.68,127.94 171.36,128.26 171.36,129.53 172.82,130.99 v2(172.82,131.82)
LAN_RST#: length 166.7
  TOP w0.102: U20.1 174.04,146.5 174.22,146.68 174.74,146.68 R331.1 177,148.07 v1(178.76,148.07) v2(180,148.07)
  IN2 w0.076: v2(117.15,67.98) 116.76,68.37 116.76,69.36 116.28,69.84
  IN2 w0.102: 116.28,69.84 115.32,70.8 115.32,71.57 114.13,72.76 114.13,74.32 112.52,75.93 112.52,78.13 111.66,78.99 111.66,81.99 114.77,85.11 115.89,85.11 116.72,85.93 117.26,85.93 117.79,86.47 119.34,86.47 119.99,87.11 120.63,87.11 121.18,86.57 121.18,86.37 121.66,85.88 123.56,85.88 124.52,86.84 125.55,87.88 129.89,87.88 130.66,87.11 134.61,87.11 135.19,87.7 140.92,87.7 141.76,86.86 143.23,86.86 144.93,85.16 146.91,85.16 147.27,85.51 147.27,86.24 151.9,90.87 154,90.87 154.55,91.41 156.44,91.41 157.13,90.72 160.23,90.72 160.82,91.3 162.56,91.3 163.28,92.02 167.99,92.02 168.91,91.1 168.91,90.28 169.16,90.03 173.14,90.03 174.8,91.7 174.8,96.75 176.2,98.15 180.45,98.15 181.52,99.22 181.52,103.12 182.03,103.62 182.03,106.99 v2(183.36,108.32)
  IN3 w0.102: v2(180,148.07) 180.12,147.95 180.12,145.85 177.01,142.74 177.01,135.94 176.69,135.63 176.69,132.98 174.76,131.05 174.76,127.13 178.38,123.51 178.38,118.73 179.4,117.72 179.4,114.08 180.22,113.26 180.22,111.46 v2(183.36,108.32)
  BOTTOM w0.076: v2(117.15,67.98) 117.5,67.62 UC1.Y1
LAN_SMBCLK: length 156.2
  TOP w0.102: v2(179.61,146.61) v1(180.01,146.22) 180.12,146.1 180.12,144.2 179.9,143.98 179.9,142.42 179.7,142.22 U21.28 ; v2(112.71,91.8) 112.53,91.63 112.53,90.57 114.55,88.55 116.27,88.55 117.6,87.21 117.98,87.21 118.99,86.21 118.99,85.77 119.09,85.67 RC186.1 118.99,85.11 118.99,83.8 118.75,83.57 118.75,81.74 119.04,81.46 119.04,79.12 120.37,77.78 120.37,75.96 119.48,75.07 119.48,74.79 120.74,73.53 120.74,72.2 121.5,71.43 121.5,70.79 121.87,70.43 121.87,68.97 122.14,68.7 123.54,68.7 124.18,69.33 124.81,69.33 125.45,68.7 v2(125.51,68.7)
  IN3 w0.102: v2(112.71,91.8) 112.53,91.98 112.53,92.48 113.51,93.46 113.51,94.8 111.04,97.27 111.04,100.64 112.62,102.23 112.62,113.71 118.85,119.94 118.85,126.61 122.15,129.91 122.15,132.07 121.11,133.11 121.11,133.74 120.54,134.31 v2(120.54,134.62)
  BOTTOM w0.076: v2(125.51,68.7) 125.18,68.37 125.18,67.57 125,67.38 UC1.AN1
  BOTTOM w0.102: v2(179.61,146.61) 179.41,146.82 179.41,147.14 179.11,147.44 177.2,147.44 171.86,142.1 161.77,142.1 157.83,138.17 148.14,138.17 146.36,136.39 141.26,136.39 140.15,135.28 137.3,135.28 136.05,134.04 120.87,134.04 120.54,134.37 v2(120.54,134.62)
LAN_SMBDATA: length 151.9
  TOP w0.102: v2(112.13,91.8) 112.31,91.62 112.31,90.47 114.46,88.32 116.17,88.32 117.51,86.99 117.89,86.99 118.76,86.11 118.76,85.77 118.66,85.67 RC192.1 118.76,85.11 118.76,83.9 118.53,83.66 118.53,81.65 118.81,81.37 118.81,79.02 120.14,77.69 120.14,76.05 119.25,75.16 119.25,74.7 120.51,73.44 120.51,72.1 121.27,71.34 121.27,70.7 121.64,70.33 121.64,68.88 v2(122.8,67.72) ; U21.31 178.5,144.16 178.47,144.19 178.47,146.1 v2(178.98,146.61)
  IN3 w0.102: v2(112.13,91.8) 112.3,91.98 112.3,92.58 113.28,93.56 113.28,94.7 110.81,97.18 110.81,100.73 112.39,102.32 112.39,113.81 118.62,120.03 118.62,126.7 121.92,130.01 121.92,131.98 120.88,133.01 120.88,133.65 120.33,134.21 v2(120.13,134.21)
  BOTTOM w0.076: UC1.AK1 122.8,67.27 v2(122.8,67.72)
  BOTTOM w0.102: v2(178.98,146.61) 179.18,146.82 179.18,147.04 179.01,147.21 177.29,147.21 171.96,141.88 161.87,141.88 157.93,137.94 148.23,137.94 146.46,136.16 141.35,136.16 140.25,135.06 137.39,135.06 136.15,133.81 120.77,133.81 120.38,134.21 v2(120.13,134.21)
LAN_TEST_EN: length 2.8
  TOP w0.102: U21.30 v1(178.9,143.03) 178.9,143.73 R184.1
LAN_TX0+: length 21.4
  TOP w0.089: v2(183.12,136.15) 183.02,136.25 182.24,136.25 182.05,136.44 181.68,136.44 U21.13 ; v2(179.76,150.9) 179.85,151 179.85,151.52 L27.1
  IN1 w0.089: v2(183.12,136.15) 182.99,136.28 181.86,136.28 177.82,140.32 177.82,148.25 179.89,150.31 179.89,150.77 v2(179.76,150.9)
LAN_TX0+R: length 3.9
  TOP w0.089: U23.2 181.27,155.36 181.32,155.31 181.32,155.16 180.83,154.68 v1(180.57,154.68) 180.25,154.68 179.87,154.3 179.87,153.78 179.49,153.4 L27.2
LAN_TX0-: length 21.2
  TOP w0.089: v2(180.34,150.9) 180.25,151 180.25,151.76 180.5,152.01 L28.1 ; v2(183.12,136.74) 183.02,136.64 182.41,136.64 182.21,136.84 U21.14
  IN1 w0.089: v2(183.12,136.74) 182.99,136.61 182,136.61 178.15,140.45 178.15,148.11 180.22,150.18 180.22,150.77 v2(180.34,150.9)
LAN_TX0-R: length 4
  TOP w0.089: L28.2 180.78,153.4 180.26,153.92 180.26,154.13 180.41,154.28 181,154.28 181.72,155 181.72,155.31 181.77,155.36 U23.3
LAN_TX1+: length 18.8
  TOP w0.089: v2(182.83,151.05) 182.83,151.6 L29.1 ; U21.17 183.02,138.04 v2(183.12,137.94)
  IN1 w0.089: v2(182.83,151.05) 182.83,150.39 181.08,148.64 181.08,145.37 180.11,144.4 180.11,139.87 180.93,139.05 180.93,138.81 181.81,137.94 v2(183.12,137.94)
LAN_TX1+R: length 3.1
  TOP w0.089: U23.6 183.27,155.5 183.32,155.45 183.32,155.25 182.97,154.89 182.97,153.83 182.54,153.4 L29.2
LAN_TX1-: length 18.8
  TOP w0.089: L30.1 183.75,152.01 183.22,151.47 183.22,151.24 v2(183.41,151.05) ; U21.18 181.68,138.43 183.02,138.43 v2(183.12,138.53)
  IN1 w0.089: v2(183.41,151.05) 183.16,150.79 183.16,150.26 181.41,148.51 181.41,145.23 180.44,144.26 180.44,140.01 181.26,139.19 181.26,138.95 181.94,138.27 182.86,138.27 v2(183.12,138.53)
LAN_TX1-R: length 3.1
  TOP w0.089: L30.2 183.83,153.4 183.36,153.87 v1(183.36,154.51) 183.36,154.73 183.72,155.08 183.72,155.48 183.77,155.53 U23.7
LAN_TX2+: length 17.5
  TOP w0.089: v2(185.94,151.11) 185.95,151.12 185.95,151.52 L31.1 ; U21.20 182.34,139.24 182.44,139.33 v2(183.07,139.33)
  IN1 w0.089: v2(183.07,139.33) 182.49,139.33 181.49,140.33 181.49,144.17 182.84,145.52 182.84,148.21 185.05,150.42 185.65,150.42 185.94,150.71 v2(185.94,151.11)
LAN_TX2+R: length 3.4
  TOP w0.089: U23.9 184.77,155.5 184.82,155.45 184.82,154.84 185.27,154.39 185.36,154.3 185.87,153.79 185.87,153.69 185.76,153.58
  TOP w0.102: L31.2 185.58,153.4 185.76,153.58
LAN_TX2-: length 17.4
  TOP w0.089: L32.1 186.35,151.36 186.35,151.28 v2(186.52,151.11) ; U21.21 181.68,139.63 182.18,139.63 182.27,139.72 182.88,139.72 v2(183.07,139.91)
  IN1 w0.089: v2(186.52,151.11) 186.49,151.11 186.27,150.88 186.27,150.58 185.78,150.09 185.19,150.09 183.17,148.07 183.17,145.38 181.83,144.04 181.83,140.46 182.63,139.66 182.84,139.66 183.07,139.89 v2(183.07,139.91)
LAN_TX2-R: length 3.6
  TOP w0.089: 186.59,153.53 186.27,153.85 186.27,153.95 v1(185.64,154.58) 185.22,155.01 185.22,155.5 185.27,155.56 U23.10
  TOP w0.102: L32.2 186.72,153.4 186.59,153.53
LAN_TX3+: length 17.2
  TOP w0.089: v2(183.37,140.92) 182.98,140.92 182.51,140.44 181.68,140.44 U21.23 ; L33.1 189.08,151.44 189.08,151.27 v2(188.99,151.17)
  IN1 w0.089: v2(183.37,140.92) 183.24,141.04 182.96,141.04 182.63,141.38 182.63,142.7 184,144.08 184,147.13 187.62,150.74 188.93,150.74 189.08,150.89 189.08,151.08 v2(188.99,151.17)
LAN_TX3+R: length 5.6
  TOP w0.089: U23.11 185.77,155.57 185.84,155.5 185.84,155.13 187.05,153.92 189,153.92 189.06,153.85 189.06,153.62 188.84,153.4 L33.2
LAN_TX3-: length 16.8
  TOP w0.089: L34.1 189.47,151.44 189.47,151.27 v2(189.57,151.17) ; v2(183.37,141.5) 183.18,141.31 182.82,141.31 182.35,140.84 U21.24
  IN1 w0.089: v2(189.57,151.17) 189.41,151.01 189.41,150.75 189.06,150.41 187.75,150.41 184.33,146.99 184.33,143.94 182.96,142.56 182.96,141.51 183.1,141.37 183.24,141.37 v2(183.37,141.5)
LAN_TX3-R: length 5.6
  TOP w0.089: L34.2 189.69,153.4 189.46,153.64 189.46,154.02 189.17,154.31 187.21,154.31 186.23,155.29 186.23,155.46 186.27,155.5 U23.12
LAN_WAKE#: length 113.8
  TOP w0.102: v1(157.77,86.96) 157.77,87.31 v2(157.45,87.63) ; v2(149.05,104.54) 149.27,104.31 U38.B27 ; v2(172.82,133.15) 172.94,133.26 R179.1 ; v2(137.13,75.2) 136.66,74.73 RC211.1
  IN2 w0.102: v2(172.82,133.15) 171.87,133.15 167.65,128.93 165.74,128.93 165.13,128.32 163.41,128.32 162.79,127.7 162.79,126.55 163.8,125.53 163.8,121.78 163.36,121.34 162.04,121.34 159.78,119.08 158.54,119.08 157.58,118.12 157.58,117.66 154.85,114.93 152.88,114.93 152.37,114.42 152.37,113.21 153.9,111.69 153.9,108.64 152.88,107.62 151.17,107.62 150.28,106.73 150.28,105.08 149.74,104.54 v2(149.05,104.54) ; v2(137.13,75.2) 137.26,75.2 138.4,74.06 141.07,74.06 141.71,74.69 153.31,74.69 155.52,76.9 155.52,80.28 155.45,80.36 155.45,80.76 153.26,82.95 153.26,85.03 153.67,85.44 153.67,86.36 154.41,87.1 156.93,87.1 v2(157.45,87.63)
  IN3 w0.102: v2(157.45,87.63) 157.45,88.52 154.82,91.15 154.81,91.15 153.77,92.19 153.77,95.01 152.82,95.97 152.82,97.72 153.49,98.39 153.49,106.33 153,106.82 152.66,106.82 152.31,106.48 152.31,105.68 152.06,105.42 152.06,104.39 151.91,104.24 151.83,104.16 151.75,104.08 150.38,104.08 149.93,104.54 v2(149.05,104.54)
LAN_WAKE#_R: length 4.1
  TOP w0.102: U21.2 176.9,135.2 176.08,134.38 v1(175.6,134.38) 174.74,134.38 R176.1 R179.2
LANCLK_REQ#: length 162.6
  TOP w0.102: v2(191.24,125.53) 188.19,125.53 185.6,128.12 177.34,128.12 176.69,128.77 176.69,130.8 176.25,131.25 v1(173.33,131.25) 172.69,131.25 172.38,131.56 172.38,135.07 R169.1 ; v2(113.11,82.49) 113.11,82.83 113.32,83.05 113.32,83.56 113.52,83.76 RP3.5
  IN2 w0.102: v2(191.24,125.53) 190.85,125.53 185.65,120.33 185.65,113.72 184.12,112.2 184.12,108.33 182.28,106.49 182.28,103.43 181.77,102.92 181.77,99.15 180.54,97.92 176.3,97.92 175.03,96.65 175.03,91.61 173.23,89.81 169.06,89.81 168.68,90.19 168.68,91 167.89,91.79 163.4,91.79 162.69,91.08 160.91,91.08 160.33,90.49 157.04,90.49 156.34,91.19 154.64,91.19 154.07,90.61 151.96,90.61 147.5,86.15 147.5,85.41 147.01,84.93 144.83,84.93 143.13,86.63 141.63,86.63 140.82,87.44 135.26,87.44 134.7,86.88 130.53,86.88 129.77,87.65 125.65,87.65 123.66,85.65 121.57,85.65 120.95,86.27 120.95,86.47 120.54,86.88 120.08,86.88 119.33,86.14 118.61,86.14 117.74,85.27 117.24,85.27 116.57,84.6 114.91,84.6 113.11,82.79 v2(113.11,82.49) 113.36,82.24 113.36,79.21 113.23,79.09 113.23,76.71 114.14,75.81 114.14,75 115.32,73.82 115.32,73.03 116.45,71.9 116.55,71.9 v2(118.43,70.02)
  BOTTOM w0.076: UC1.AD1 119.33,67.64 119.33,68.34 118.43,69.24 118.43,69.84
  BOTTOM w0.102: 118.43,69.84 v2(118.43,70.02)
