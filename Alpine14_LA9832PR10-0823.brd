# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_SMBCLK: length 3.8
  BOTTOM w0.102: JMINI2.30 220.66,143.9 220.95,144.19 221.46,144.19 R218.1 R216.2
WWAN_SMBDAT: length 3.6
  BOTTOM w0.102: R217.2 R219.1 222.05,144.41 220.95,144.41 220.66,144.7 JMINI2.32
XDP_DBRESET#: length 141.6
  TOP w0.102: v2(101.56,81.11) 101.65,81.19 RC116.2 ; v2(106.72,18.47) 106.72,18.41 108.11,17.01 110.78,17.01 113.35,14.44 114.57,14.44 114.82,14.69 v1(116.89,14.69) 127.39,14.69 131.9,10.18 131.9,9.36 132.76,8.49 133.86,8.49 133.95,8.59 136.29,8.59 137.15,7.72 JXDP1.48 137.15,5.28 136.33,4.46 CC68.1
  IN2 w0.102: v2(106.72,18.47) 105.98,19.21 104.65,19.21 101.07,22.79 98.4,22.79 97.56,23.63 95.28,23.63 94.97,23.94 94.97,26.66 93.26,28.38 93.26,42.54 92.68,43.11 92.68,52.18 90.02,54.84 90.02,63.43 86.21,67.24 86.21,69.02 85.7,69.52 85.7,70.1 86.91,71.31 86.91,79.75 v2(87.03,79.87)
  IN3 w0.102: v2(101.56,81.11) 101.16,81.51 99.63,81.51 98.29,80.17 92.65,80.17 91.95,79.47 89.76,79.47 89.2,80.03 87.18,80.03 v2(87.03,79.87)
  BOTTOM w0.102: v2(101.56,81.11) 101.56,79.21 101.93,78.84 103.44,78.84 103.74,79.15 103.74,79.63 104,79.88 UC2.1 105.33,79.88 105.57,80.13 105.57,81.46 105.89,81.78 107.67,81.78 107.91,81.54 RC72.1
XDP_OBS0_R: length 42.3
  TOP w0.102: v2(110.46,18.41) v1(111.23,18.41) 111.67,17.96 111.67,16.89 113.29,15.27 127.5,15.27 133.1,9.67 143.11,9.67 143.65,10.21 JXDP1.21
  BOTTOM w0.102: RC194.2 111.54,19.98 111.54,19.31 RC121.1 110.92,18.86 v2(110.46,18.41)
XDP_OBS1_R: length 37.6
  TOP w0.102: JXDP1.23 143.15,10.39 142.91,10.15 133.3,10.15 127.68,15.77 v1(123.1,15.77) 113.5,15.77 112.24,17.03 v2(112.24,17.2)
  BOTTOM w0.102: v2(112.24,17.2) 111.99,17.46 RC204.2 RC121.2
XDP_RST#_R: length 2.4
  TOP w0.102: JXDP1.46 137.65,5.27 137.22,4.84 RC109.2
XTAL24_IN: length 8.5
  BOTTOM w0.076: UC1.A25 106.41,52.63 105.86,52.63 105.12,53.37 103.64,53.37 102.97,52.7 102.97,52.43 v1(102.62,52.07) 101.26,50.71 100.94,50.71
  BOTTOM w0.102: RC40.1 RC44.2 100.94,50.71
XTAL24_IN_R: length 5.3
  BOTTOM w0.102: RC40.2 99.67,49.83 CC7.2 99.3,50.22 97.19,50.22 YC2.3
XTAL24_OUT: length 11.3
  BOTTOM w0.076: UC1.B25 106.95,52.5 106.66,52.79 105.94,52.79 105.19,53.53 103.28,53.53 v1(103.15,53.41) 102.63,52.89 102.63,52.61 101.65,51.63 100.94,51.63
  BOTTOM w0.102: 100.94,51.63 RC44.1 99.67,50.74 CC6.2 98.64,50.71 YC2.1
XTAL24M_IN: length 5.9
  TOP w0.254: U90.33 172.82,115.89 RC297.2 173.84,114.88 CC85.1 172.97,114.62 Y6.3
XTAL24M_OUT: length 7.5
  TOP w0.254: U90.32 172.32,117.67 172.39,117.6 v1(172.39,116.48) 172.39,115.59 RC297.1 CC86.1 171.37,115.44 171.37,113.52 Y6.1
XTAL_OUT: length 11.5
  TOP w0.102: v1(65.52,94.26) 65.21,94.26 64.91,93.96 v2(64.9,93.96)
  IN3 w0.102: v2(67.54,96.3) 67.25,96.3 v2(64.9,93.96)
  BOTTOM w0.1: v2(64.9,93.96) 65.29,94.35 UV1.B10
  BOTTOM w0.102: YV2401.3 66.27,100.52 66.27,98.91 CV105.1 66.01,98.43 66.01,97.83 v2(67.54,96.3)
XTALI: length 5.2
  TOP w0.102: Y3.1 181.89,131.84 C190.2 181.2,133.35 R206.2 180.19,134.37 ; U21.10 180.1,134.45 180.19,134.37 ; 180.19,134.37 v1(180.19,134.37)
XTALIN: length 10.5
  TOP w0.102: v2(64.86,93.14) 65.38,92.62 v1(65.38,92.59)
  IN3 w0.102: v2(64.86,93.14) 65.63,93.91 65.63,94.17 66.5,95.04 66.97,95.04 67.98,96.05 67.98,96.53 v2(67.56,96.95)
  BOTTOM w0.1: v2(64.86,93.14) 64.45,93.55 UV1.C11
  BOTTOM w0.102: YV2401.1 66.83,99.37 CV104.1 66.65,98.37 66.65,97.87 v2(67.56,96.95)
XTALO: length 3.4
  TOP w0.102: R183.2 180.25,133.39 R206.1 179.93,133.71 179.93,134.13 179.7,134.36 U21.9
XTALO_R: length 5.6
  TOP w0.102: Y3.3 183.27,130.67 181.95,130.67 181.66,130.38 v1(181.27,130.38) 180.62,130.38 C189.2 R183.1
Z4012: length 3
  BOTTOM w0.102: RTCR1.2 42.07,61.87 v1(42.13,61.92)
  BOTTOM w0.508: RTCD1.2 40.01,62.74 40.88,61.87 RTCR1.2
Z4304: length 10.8
  TOP w0.254: PR3.1 99.46,168.14 ; 99.46,168.14 98.62,168.99 PD2.2 ; 99.46,168.14 97.19,168.14 v2(96.94,168.39)
  IN1 w0.254: v2(96.94,168.39) 96.94,169.48 PBATT2.7
  BOTTOM w0.102: v1(97.65,168.1) 97.36,168.39 v2(96.94,168.39)
Z4305: length 4.1
  TOP w0.254: PR5.1 98.6,170.04 PD2.3 98.46,170.06 98.46,171.39 ; 98.46,171.39 v1(98.46,171.48) ; 98.46,171.39 PBATT2.6
Z4306: length 5
  TOP w0.254: PBATT2.5 v1(96.46,171.49) 96.46,171.25 95.19,169.97 PD1.2 93.87,169.97 PR4.1
N07538: length 2
  TOP w0.254: PR534.1 118.34,141.09 118.75,140.67 PU701.28
N07670: length 4.6
  TOP w0.102: PR507.1 124.18,149.47 v1(125.12,148.53)
  TOP w0.254: PQ501.4 125.69,149.09 PR502.2 PR507.1
N07710:
  vias: v1(120.9,147.86)
N07778: length 4.6
  TOP w0.254: PQ502.5 141.18,135.03 141.18,135.87 141.07,135.98 v1(140.87,135.98) 140.66,135.98 140.55,135.86 PQ502.6 140.55,134.28 140.42,134.15 PR504.2
N07808: length 1.1
  TOP w0.102: PR513.1 v1(145.86,161.48)
N07946:
  vias: v1(132.22,166.93)
N07954: length 68.6
  TOP w0.102: v1(130.45,134.22) 130.91,134.67 130.91,135.92 131.08,136.1 v2(131.08,136.52)
  TOP w0.254: v2(131.08,136.52) 131.36,136.52 PD507.1 PD510.1 ; PD513.1 144.65,134.27 144.23,134.69 v2(144,134.69) ; PR520.1 128.93,167.63 PR517.2 PC509.2 128.93,166.03 128.65,165.75 PQ511.4 128.65,163.69 v2(128.88,163.47) 132.84,163.47 133.22,163.85 133.22,164.56 133.61,164.94 PQ524.4
  IN2 w0.254: v2(131.08,136.52) 131.22,136.66 142.34,136.66 144,134.99 v2(144,134.69)
  BOTTOM w0.254: v2(131.08,136.52) 131.08,136.91 130.02,137.98 125.58,137.98 122.47,141.09 122.47,148.58 128.43,154.55 128.43,163.02 v2(128.88,163.47)
N07974: length 8.5
  TOP w0.254: PQ525.1 134.64,172.7 134.43,172.91 v1(133.16,172.91) 132.64,172.91 130.42,170.69 PR520.2
N07998: length 8
  TOP w0.254: PU503.2 145.52,148.42 145.52,147.93 v1(145.15,147.57) PR518.1 142.85,145.27 142.85,144.58 143.17,144.26 PQ512.1
N08002: length 1.7
  TOP w0.254: PU503.4 146.16,151.68 145.5,152.34 PU504.1
N08014: length 27.3
  TOP w0.254: PQ525.2 133.91,169.86 135.85,171.81 136.42,171.81 136.96,171.27 PD512.1 137.79,171.61 v1(137.79,172.73) 137.79,172.97 137.59,173.18 v2(137.07,173.18) ; v2(144.37,159.89) PD508.1 PD506.1
  IN3 w0.254: v2(144.37,159.89) 144.37,160.14 136.27,168.24 136.27,170.85 137.07,171.65 v2(137.07,173.18)
N08016: length 4.1
  TOP w0.102: v1(147.59,157.57) 146.41,156.4 PD506.2
  TOP w0.254: PD506.2 146.15,156.09 146.8,155.44 PU504.4
N08030: length 7.4
  TOP w0.102: v1(139.5,127.31) 139.81,126.99 PU502.2
  TOP w0.254: PR514.2 PR506.2 141.63,124.32 PQ508.1 141.52,125.03 141.52,126.67 141.2,126.99 PU502.2
N08062: length 8.2
  TOP w0.102: v1(132.64,146.9) 133.14,146.4 PD501.1
  TOP w0.254: PD501.1 133.14,144.57 133.49,144.22 PQ500.3 133.49,142.45 133.01,141.97 133.01,139.87 PR503.1
N08064: length 5.6
  TOP w0.254: PR503.2 134.37,139.45 PR501.1 135.45,139.45 136.09,140.09 v1(136.09,140.5) 136.09,141.9 135.42,142.57 PQ500.2
N08074: length 2
  TOP w0.102: PR501.2 v1(134.39,138.54)
  TOP w0.254: PR501.2 135.36,137.98 135.47,137.87 PQ503.6
N08082: length 3.4
  TOP w0.102: PU500.4 138.62,130.15 138.49,130.03 v1(138.49,129.02)
  TOP w0.381: PU500.4 139.4,130.15 140.05,130.8 PQ507.5
N08084: length 14.9
  TOP w0.254: PQ502.2 141.2,132.01 141.75,131.45 PQ507.3 143.67,131.45 PR500.1 143.74,132.02 v2(143.74,132.39) PD504.1
  TOP w0.381: PQ507.6 140.29,129.9 v1(140.29,129.01) 140.31,129.01 140.55,128.77 v2(140.88,128.77)
  IN3 w0.254: v2(143.74,132.39) 143.1,133.02 141.83,133.02 140.88,132.07 v2(140.88,128.77)
N08086: length 7.4
  TOP w0.254: PU502.4 143.91,126.34 144.44,126.86 v1(144.44,127.31) 144.44,129.33 142.97,130.8 PQ507.2
N08128: length 3.4
  TOP w0.102: PR519.1 147.8,154.46 v1(147.92,154.58)
  TOP w0.254: PR519.1 146.48,153.61 146.15,153.28 PU504.2
N08144: length 4.3
  TOP w0.102: PD508.2 143.88,156.4 143.22,157.06 v1(142.71,157.06)
  TOP w0.254: PU505.4 143.24,154.88 144.37,156.01 PD508.2
N08150: length 3.1
  TOP w0.254: PU701.19 125.03,142.16 125.27,142.39 125.76,142.39 125.89,142.52 v1(125.89,142.93) PR551.1
N08170: length 5.1
  TOP w0.102: PR505.2 v1(139.15,136.57)
  TOP w0.254: PQ503.2 136.12,135.03 136.26,134.89 136.6,134.89 136.77,135.06 PQ503.3 136.77,136.21 137.01,136.45 138.03,136.45 PR505.2
N08182: length 14.2
  TOP w0.254: PR522.2 142.2,146.89 PQ514.2 141.33,147.44 140.92,147.03 v1(140.92,145.86) 140.92,144.94 140.73,144.75 138.95,144.75 138.4,144.2 138.4,143.44 138.88,142.97 PQ516.3 139.78,142.21 ; PR562.1 139.5,141.93 139.78,142.21 ; 139.78,142.21 140.08,141.91 140.69,141.91 141.08,141.52 PQ516.6
N08184: length 5.3
  TOP w0.102: v1(140.3,147.83) 140.91,147.83 142.41,149.34 PQ514.1
  TOP w0.254: PR523.2 PR521.2 PQ514.1
N08204: length 1.5
  TOP w0.254: PU505.2 142.59,152.15 PR523.1
N08214: length 4.2
  TOP w0.102: v1(131.07,121.73) 131.07,121.91 131.81,122.64 PR526.1
  TOP w0.254: PQ515.3 132.2,123.31 PR526.1 131.81,123.44 131.55,123.7 PQ515.2
N08226: length 4.5
  TOP w0.102: v1(127.77,130.39) PQ517.2
  TOP w0.254: PR528.1 PR524.2 129.59,129.21 129.31,129.49 PQ517.2
N08230: length 3.9
  TOP w0.254: PD507.2 132.05,133.51 v1(131.98,133.44) 130.5,133.44 130.28,133.21 PQ517.1
N08260: length 5.7
  TOP w0.102: v1(136.73,128.21) 136.22,127.7 135.17,127.7 134.77,128.1 PR544.1
  TOP w0.254: PR544.1 PR535.2 133.78,129.01 133.33,129.47 PQ520.2
N08264: length 4.3
  TOP w0.102: PD510.2 134.46,134.81 v1(135.15,134.11)
  TOP w0.254: PQ520.1 134.29,133.45 133.83,133.91 PD510.2
N08280: length 8.1
  TOP w0.254: PR551.2 125.89,145.89 v1(125.99,145.99) PQ522.3 127.62,146.58 128.19,147.14 130.26,147.14 131.54,145.86 PR554.1
N08282: length 6.3
  TOP w0.102: v1(131.33,146.9) 132.13,146.1 132.13,145.04 131.91,144.82 PR554.2
  TOP w0.254: PQ522.2 130.39,145.99 131.54,144.83 PR554.2 PR555.1
N08290: length 2.5
  TOP w0.254: PQ523.6 130.58,141.94 130.44,142.08 v1(130.44,142.67) 130.68,142.92 PR555.2
N08296: length 3.5
  TOP w0.254: 131.23,138.69 130.96,138.69 130.4,138.13 PR557.2 ; 131.23,138.69 PQ523.2 ; 131.23,138.69 131.36,138.56 v1(131.63,138.56) 131.74,138.56 131.88,138.7 PQ523.3
N16932721: length 0.8
  TOP w0.102: 131.1,82.3 131.1,82.02 v1(130.71,81.62)
N16958676: length 2.9
  TOP w0.102: U43.5 88.98,72.11 88.81,71.94 88.21,71.94 88.11,72.04 R418.2 87.63,72.04 87.63,72.93 R417.2
N16958821: length 2.8
  TOP w0.102: v1(93.55,70.88) 93.55,70.97 93.41,71.11 93.41,71.52 C391.1 92.8,72.06 92.04,72.06 91.99,72.11 U43.10
N17049026: length 5.3
  TOP w0.102: v1(178.05,104.23) 178.6,103.68 L45.2 178.71,102.94 R449.2 R444.2 178.71,100.13 R405.2 178.71,99.24 C378.1
N17049030: length 4.9
  TOP w0.102: v1(182.42,98.13) C377.1 182.42,99.24 R404.2 182.42,100.13 R441.2 R450.2 182.42,103 L44.2
N17119989: length 8.9
  TOP w0.102: v2(170.66,94.42) 170.38,94.14 170.38,93.43 170.48,93.32 U37.B49 ; v1(174.46,89.97) 174.38,90.05 R316.2 v2(173.07,90.8)
  BOTTOM w0.102: v2(170.66,94.42) 170.38,94.14 170.38,93.04 172.63,90.8 v2(173.07,90.8)
N17156946: length 60.6
  TOP w0.102: v1(124.14,128.73) 124.09,128.73 123.62,129.2 PR20.1
  TOP w0.254: v2(89.32,154.33) 89.65,154.66 PR21.1 89.97,155.76 90.78,155.76 91.03,155.5 PQ4.4 ; v2(120.83,129.98) PR14.2 120.94,130.67 121.42,130.19 PC5.2 122.96,129.28 PR20.1 123.03,127.76 123.26,127.53 PQ5.4
  IN3 w0.254: v2(120.83,129.98) 120.25,130.55 117.13,130.55 116.5,129.91 108.27,129.91 102.53,135.66 102.53,140.29 101.35,141.47 94.08,141.47 89.32,146.23 v2(89.32,154.33)
N17156948: length 2.1
  TOP w0.254: PQ5.2 120.97,126.53 120.62,126.19 120.62,125.82 120.92,125.53 PQ5.1
N17205976: length 2.6
  TOP w0.254: JDEG1.1 150.73,121.76 v1(150.02,121.05) 149.18,120.21 R388.2
N17328413: length 4.2
  TOP w0.254: PU401.6 113.64,130.98 113.51,130.85 113.51,130.29 113.63,130.18 v1(113.63,129.89) 113.63,129.04 113.42,128.83 PR404.1 PR402.2
N17352357: length 2.1
  TOP w0.102: v1(158.29,26.27) RC83.1
  TOP w0.508: RC83.1 CC67.2
N17353670: length 2.2
  TOP w0.102: v1(153.92,11.46) 154.1,11.28 RC128.1
  TOP w0.508: RC128.1 CC69.2
N17353833: length 2.1
  TOP w0.102: v1(161.07,11.28) CC70.2
  TOP w0.508: CC70.2 RC195.1
N17404646: length 2
  TOP w0.102: v1(156.98,95.74) 157.15,95.57 C339.1 R324.2
N18063845: length 2.5
  TOP w0.102: U42.4 141.69,119.2 141.46,119.42 141.46,119.64 141.35,119.75 v1(141.35,120.03) 141.35,120.13 141.53,120.31 R413.1
N18070155: length 10.2
  TOP w0.102: v2(170.76,99.91) 170.76,99.91 171.2,100.35 171.62,100.35 171.86,100.59 U37.B66 ; v2(174.27,103.06) 174.64,103.43 R294.1 175.28,102.85 175.51,102.62 v1(177.24,102.62)
  IN3 w0.102: v2(170.76,99.91) 171.23,100.38 171.6,100.38 174.27,103.06 v2(174.27,103.06)
N18435663: length 4.8
  TOP w0.102: v1(139.51,66.07) 139.51,66.97 139.12,67.36 RC263.1 139.29,67.92 139.29,69.64 139.09,69.84 UC4.2
N18502042: length 5.1
  TOP w0.102: v1(177.75,2.42) 177.32,2.85 D24.2 175.96,2.85 175.9,2.9 R428.2 174.27,2.9 D23.2 173.61,2.85 173.56,2.9 Q24.1
N18502098: length 11.5
  TOP w0.102: Q26.2 181.18,3.06 180.16,2.05 v1(179.49,2.05) 172.64,2.05 171.79,2.9 Q24.6
N18502175: length 2.1
  TOP w0.102: v1(178.89,5.24) 179.33,4.8 Q26.1 179.31,4.26 R438.1
N18599297: length 1
  BOTTOM w0.102: R57.1 C76.2
N18599324: length 0.9
  BOTTOM w0.102: R45.1 C85.2
N18632981: length 61.8
  TOP w0.102: v2(110.46,95.63) 110.59,95.76 R2602.1 R2601.1 ; v5(97.33,144.89) 97.42,144.97 Q126.2 102.01,144.97 102.55,144.43 102.55,140.73 102.11,140.29 101.1,140.29 v2(100.94,140.45)
  IN3 w0.102: v2(100.94,140.45) 100.56,140.07 100.56,118.99 107.01,112.54 107.01,108.58 107.99,107.6 107.99,98.1 110.45,95.63 v2(110.46,95.63)
N18633605: length 2.8
  BOTTOM w0.102: R2578.2 v1(89.64,161.31)
  BOTTOM w0.254: Q125.3 88.55,160.44 89.16,160.44 R2578.2
N18640439: length 2.3
  TOP w0.102: R556.2 159.97,148.66 v1(159.97,149.5) U39.8
N18782591: length 3.4
  TOP w0.102: U52.12 105.36,109.36 105.55,109.17 106.12,109.17 106.36,108.94 106.36,108.85 v1(106.59,108.61) 106.78,108.42 106.95,108.42 107.3,108.07 R2583.2
N19641658: length 3.7
  TOP w0.102: v1(112.29,133.21) 112.64,132.87 PR411.1
  TOP w0.254: PU401.4 112.65,132.28 PR411.1 112.64,132.24 111.72,131.33 PR408.2
N19821558: length 1.6
  BOTTOM w0.102: v1(40.36,27.06) 39.6,27.82 PC704.1
N19821564: length 7.5
  TOP w0.254: v2(38.59,31.54) v1(38.59,33.59) v2(38.59,35.4)
  BOTTOM w0.254: PC706.1 PR711.1 PR710.1 v2(38.59,35.4) ; v2(38.59,31.54) PU700.7
N19821679: length 1.7
  BOTTOM w0.102: PR706.1 v1(49.15,34.92)
N19844496: length 10.7
  IN2 w0.254: v2(54.19,19.12) 56.54,21.47 57.8,21.47 v2(57.87,21.4)
  BOTTOM w0.203: PR317.1 v1(54,18.6) 53.65,18.94 PU300.3
  BOTTOM w0.254: PR318.1 PR317.1 PR319.1 54.56,19.49 v2(54.19,19.12) ; PD300.1 v2(57.87,21.4)
N19844507: length 6.6
  BOTTOM w0.203: PU300.26 49.84,20.87 49.44,21.26 48.17,21.26
  BOTTOM w0.254: 48.17,21.26 v1(47.78,21.26) 46.97,21.26 PC305.2 PR323.2 PC308.2 45.11,21.45 PR322.1
N19844524: length 3.8
  BOTTOM w0.203: PU300.28 50.64,21.17 v1(50.33,21.48) 49.87,21.94
  BOTTOM w0.254: PR327.2 PC310.1 49.63,22.18 49.87,21.94
N19844548: length 3.1
  BOTTOM w0.102: v1(68.81,33.56) 68.93,33.68 70.4,33.68 70.66,33.42 PH301.2
  BOTTOM w0.254: PH301.2 70.65,33.19 PR329.1
N19844564: length 2
  BOTTOM w0.102: PR324.1 v1(74.42,19.61)
N19844606: length 38.9
  IN2 w0.254: v2(68.43,28.82) 67.6,27.99 65.12,27.99 61.44,24.31 54.77,24.31 54.33,23.87 49.38,23.87 48.3,22.79 48.3,21.45 47.22,20.37 47.22,16.79 48.58,15.42 v2(50.14,15.42)
  BOTTOM w0.102: v1(67.98,29.23) 68.39,28.82 v2(68.43,28.82)
  BOTTOM w0.203: PU300.14 50.24,15.52 v2(50.14,15.42) 49.44,14.72 48.66,14.72 PC301.1
  BOTTOM w0.254: PH300.2 v2(68.43,28.82) ; PC301.1 PR305.1
N19844618: length 5.3
  BOTTOM w0.203: PU300.25 49.44,20.76 49.29,20.9 48.79,20.9 v2(48.4,20.52) 48.09,20.21 47.11,20.21 PC305.1
  BOTTOM w0.254: PR325.1 45.9,20.44 PR323.1 PC305.1
N19844649: length 4.9
  BOTTOM w0.203: PR311.2 45.88,13.79 v1(46.84,14.75) 47.64,15.55 49.06,15.55 49.44,15.92 PU300.16
N19844680: length 5.5
  BOTTOM w0.102: v1(55.75,23.02) 55.09,22.35 PC306.1
  BOTTOM w0.203: 53.79,19.39 53.69,19.3 53.36,19.3 53.31,19.34 PU300.2
  BOTTOM w0.254: 53.79,19.39 54.96,20.56 PR320.1 PC306.1
N19844689: length 3.5
  BOTTOM w0.203: PR313.1 54.06,15.93 v1(54.01,15.98) 53.78,16.22 53.78,16.48 53.32,16.94 PU300.8
  BOTTOM w0.254: PR313.1 PR312.1
N19844763: length 1.9
  BOTTOM w0.102: PR325.2 v1(44.04,19.55)
  BOTTOM w0.254: PC308.1 45.06,19.63 PR325.2
N19847729: length 5.4
  TOP w0.102: PR53.2 186.65,142.14 185.23,142.14 v1(185.15,142.07)
  TOP w0.203: PR51.2 187.36,141.66 188.36,142.66 PU51.4
  TOP w0.254: PR51.2 PR53.2
N19847766: length 2.7
  TOP w0.203: PR55.1 187.16,143.46 PU51.2
  TOP w0.254: PR55.1 PR52.1
N19847771: length 4.7
  TOP w0.102: PR56.2 187.07,140.71 186.61,140.25 186.18,140.25 v1(185.67,139.74)
  TOP w0.203: PU51.5 188.53,142.26 188.31,142.04 188.31,141.34 187.68,140.71 PR56.2
N19847781: length 1.5
  TOP w0.102: PR61.2 191.61,149.07 v1(192.07,149.53)
N19847797: length 3.9
  TOP w0.102: v1(188.06,145.72) 187.56,145.72 PR57.2
  TOP w0.203: PR57.2 187.74,144.66 187.74,144.01 187.89,143.86 PU51.1
N19847834: length 1.4
  TOP w0.102: PC61.2 190.15,137.27 v1(190.77,136.66)
N19847903: length 1.9
  TOP w0.102: PR64.1 v1(197.24,150.42)
N19847904: length 1.7
  TOP w0.102: v1(197.36,134.81) 197.62,134.55 PR63.1
N19848836: length 1.7
  TOP w0.102: PC104.1 179.79,77.97 v1(180.71,77.05)
N19848854: length 4
  TOP w0.203: PU100.7 172.93,82.38 172.59,82.72 172.59,83.46 v1(172.49,83.56) 172.3,83.75 PR110.2
  TOP w0.254: PR111.2 PR110.2
N19848898: length 3.1
  TOP w0.203: PU100.9 173.13,81.58 172.66,81.11 172.66,80.43 v1(172.53,80.31) 172.44,80.22 171.59,80.22 PR106.2
N19849916: length 1.5
  TOP w0.102: PC165.2 151.93,80.64 v1(152.17,80.88)
N19850629: length 26.2
  TOP w0.102: v2(101.26,150.36) 101.26,150.44 v1(102.04,151.22)
  TOP w0.254: PQ402.2 v2(111.55,137.6) 111.66,137.7 PR403.2 ; PC400.2 v2(101.26,150.36) ; v2(107.49,137.66) PQ401.2
  IN1 w0.254: v2(111.55,137.6) 111.22,137.26 107.89,137.26 v2(107.49,137.66) 106.4,137.66 105.87,138.19 105.87,139.58 104.56,140.89 104.56,142.49 101.27,145.77 101.27,150.35 v2(101.26,150.36)
N19850656: length 5.2
  TOP w0.254: PR421.2 PC413.2 ; PC413.2 v1(113.68,142.74) 113.39,142.74 113.23,142.9 113.23,144.1 112.92,144.41 PU402.6 ; PC413.2 PR424.2
N19850732: length 30.5
  TOP w0.102: PQ401.1 107.3,134.01 v1(108.29,133.02)
  TOP w0.305: PR400.3 98.59,156.16 98.97,155.78 v2(98.97,155.69)
  TOP w0.508: v2(105.51,134.01) PQ401.1
  IN1 w0.508: v2(105.51,134.01) 104.52,134.01 102.72,135.82 102.72,142.17 98.97,145.91 98.97,148.71 97.95,149.72 97.95,152.71 98.97,153.72 v2(98.97,155.69)
N19850733: length 36.5
  TOP w0.305: v2(98.34,155.69) 98.34,155.5 98.59,155.25 PR400.2
  TOP w0.508: v2(111.73,134.61) 111.19,134.61 PQ402.1
  IN1 w0.508: v2(98.34,155.69) 98.34,154.04 97.32,153.03 97.32,149.41 98.34,148.39 98.34,145.6 102.08,141.85 102.08,135.5 104.24,133.34 105.83,133.34 107.1,134.61 v2(111.73,134.61)
N19850750: length 11.2
  IN3 w1.016: 106.21,147.38 106.21,158.04 106.59,158.42
  vias: v1(109.89,162.79) v2(106.02,145.66) v2(106.02,145.03) v2(107.29,160.33) v2(107.29,159.69) v2(107.29,159.06) v2(107.99,160.33) v2(107.99,159.69) v2(107.99,159.06) v2(108.62,164.58) v2(108.62,163.95) v2(108.62,163.31) v2(108.62,162.68) v2(108.69,160.33) v2(108.69,159.69) v2(108.69,159.06) v2(109.26,164.58) v2(109.26,163.95) v2(109.26,163.31) v2(109.26,162.68)
N19850800: length 3.9
  TOP w0.102: PQ411.1 123.67,118.92 v1(123.29,119.31)
  TOP w0.254: PQ411.1 123.09,118.16 122.76,118.49 PR449.2 122.12,118.15 PU405.1
N19850808: length 3.9
  TOP w0.102: v1(118.73,116.75) 118.73,118.22 118.21,118.74
  TOP w0.254: PU405.4 119.11,119.45 118.4,118.74 PQ409.5
N19850812: length 5
  TOP w0.102: v1(115.11,116.65) 115.43,116.97 PR442.1
  TOP w0.254: PR442.1 116.12,117.42 116.21,117.51 PQ409.3 116.54,118.09 116.94,118.48 116.94,118.86 117.46,119.39 PQ409.6
N19850816: length 4.2
  TOP w0.102: v1(110.64,119.54) 111.2,119.54 111.85,118.89 112.58,118.89 112.94,118.53 PR443.2
  TOP w0.254: PR443.2 PQ410.1
N19850828: length 6.1
  TOP w0.102: 106.18,120.15 107.16,119.17 v1(107.26,119.17)
  TOP w0.254: PR453.1 105.75,120.15 105.51,120.39 PR450.1 PR448.2 PR447.2 105.66,122.16 106.23,122.74 PU404.7
N19850831: length 4.2
  TOP w0.254: PU404.3 PC432.1 114.01,124.02 PR437.1 PR441.2
N19850842: length 16.8
  TOP w0.102: PU404.5 107.87,125.28 v1(109.13,126.53)
  TOP w0.254: v2(103.67,122.16) PR447.1 ; PU404.5 105.98,125.28 105.54,125.72 PC434.1 PR445.2 PR451.1 v2(106.32,127.27)
  IN3 w0.254: v2(103.67,122.16) 103.1,122.74 103.1,127.19 103.72,127.82 105.78,127.82 v2(106.32,127.27)
N19850846: length 8.8
  TOP w0.102: v1(110.53,126.66) 107.87,124.01 PU404.6
  TOP w0.254: PU404.6 106.11,124.01 105.96,123.85 105.96,123.31 105.7,123.05 PC435.1 105.33,123.06 PR452.1 105.33,123.94 PR446.2
N19850858: length 9.4
  TOP w0.254: PR443.1 112.69,119.45 v1(112,120.13) 110.78,121.35 110.78,122.36 111.16,122.74 PU404.2 113.19,122.74 113.32,122.61 114,122.61 PC431.1 PR444.1 PR440.2
N19850883: length 12.5
  TOP w0.254: PU404.1 112.9,121.47 113.15,121.21 v2(113.15,120.2) 113.4,120.2 PR435.2 114.2,119.45 114.99,118.66 PC439.1 115.53,118.66 115.61,118.74 PQ409.2 ; v2(115.54,125.09) 115.23,125.4 PR437.2
  IN3 w0.254: v2(113.15,120.2) 113.15,122.7 v2(115.54,125.09)
N19850895: length 2.1
  TOP w0.254: PU402.17 108.57,145.91 107.8,146.68 PR423.1
N19850900: length 3.6
  TOP w0.254: PU402.11 111.84,147.93 112.11,148.2 v1(113.68,148.2) PR432.1
N19850905:
  vias: v1(104.08,145.56)
N19850931: length 4.4
  TOP w0.254: PU402.3 110.84,142.82 111.37,142.29 113.32,142.29 113.64,141.98 PR422.2
N19905073: length 2.7
  BOTTOM w0.102: v1(61.45,41.14) PR601.2
  BOTTOM w0.508: PR601.2 PC612.1
N20025090: length 4.5
  BOTTOM w0.254: PC614.1 61.11,36.06 PR634.2 ; PR603.2 61.11,34.28 PR634.2 ; PR634.2 59.85,35.17 59.73,35.05 PU600.4
N20054548: length 4.3
  BOTTOM w0.102: R39.1 261.77,149.14 v1(261.9,149.01)
  BOTTOM w0.254: U17.22 260.31,150.96 261.16,150.11 R39.1
N20054658: length 5.1
  BOTTOM w0.102: C134.1 248.37,147.88 v1(248.13,148.12)
  BOTTOM w0.254: C134.1 249.91,148.64 250.86,148.64 251.24,149.03 251.24,149.66 251.54,149.96 U17.37
N20054660: length 3.5
  BOTTOM w0.254: C134.2 250.61,147.82 v1(251.68,147.82) 252.26,147.82 253.18,148.74 U17.35
N20089981: length 5.1
  BOTTOM w0.102: v1(253.83,144.96) 253.44,145.36 C385.1
  BOTTOM w0.254: C385.1 253.46,146.36 255.18,148.08 U17.31
N20133265: length 4.1
  BOTTOM w0.102: PR621.1 49.67,29.9 v1(49.05,29.28)
  BOTTOM w0.254: PR620.2 PR618.2 50.26,29 PR619.1 PR621.1
N20137396: length 2.2
  BOTTOM w0.102: PC620.1 52.04,27.91 v1(52.21,27.74)
  BOTTOM w0.254: PC620.1 51.18,29 PR619.2
N20143338: length 2
  BOTTOM w0.102: v1(49.25,30.72) 49.82,30.72 49.94,30.84 PR622.2
  BOTTOM w0.254: PR622.2 PC622.1
N20194225: length 2.7
  BOTTOM w0.254: PR608.1 57.37,29.54 PC617.1 ; PR607.2 PC617.1 ; PC617.1 57.35,29.51 PR604.2
N20340292: length 2
  BOTTOM w0.102: v1(55.37,25.71) PR610.2
  BOTTOM w0.254: PR610.2 PR611.1
N20539095: length 20.3
  BOTTOM w0.102: Q123.2 247.74,147.95 248.2,147.49 248.2,146.49 C412.1 246.94,145.23 242.49,145.23 241.59,146.13 v1(241.59,148.64) 241.59,153.34 242.47,154.22 R142.2 R153.2
N20539102: length 5.1
  BOTTOM w0.102: Q123.5 245.66,147.95 245.85,148.14 245.85,148.44 245.69,148.6 Q123.6 245.34,148.66 R208.2 244.83,150.22 244.83,151.31 v1(245.24,151.72)
N21005554: length 3.1
  TOP w0.102: v1(214.58,139.55) 214.58,139.36 214.15,138.93 C409.1 212.83,138.48 212.78,138.44 U51.12
N21082240: length 2.4
  TOP w0.102: U52.2 101.36,109.25 101.24,109.13 101.24,108.75 100.68,108.2 RC32.1
N21162283: length 0.9
  TOP w0.102: R290.2 CC84.1
N21214262: length 3.5
  TOP w0.102: R2701.1 169.71,117.97 169.92,117.76 170.22,117.76 170.32,117.87 U90.28
N21386608: length 9.7
  TOP w0.102: v1(91.96,92.49) 91.96,92.6 91.59,92.97 91.59,93.88 91.96,94.25 94.6,94.25 D76.2 95.86,95.51 R110.2 97.97,95.51 98.41,95.95 U86.4
N21466889: length 2.9
  TOP w0.102: v1(214.26,136.63) 214.15,136.74 C427.1 212.74,137.6 212.7,137.64 U51.10
N21609269: length 5.1
  TOP w0.102: v1(35.56,85.65) RV2909.2 34.01,86.05 34.01,88.7 33.66,89.05 UV5.L8
N21618610: length 4
  BOTTOM w0.254: UV4.L8 33.26,94.51 33.26,95.08 32.8,95.53 32.8,97.7 RV2906.2
N21623176: length 4.5
  TOP w0.102: RV2907.2 35.34,69.98 35.34,71.17 34.01,72.51 34.01,73.08 33.67,73.42 UV7.L8
N21628194: length 14.2
  BOTTOM w0.102: RV2908.2 25.37,85.45 v1(25.37,84.73) 25.37,83.11 27.15,81.33 31.6,81.33 32.98,79.95 32.99,79.95 33.31,79.63 33.31,78.86 33.67,78.5 UV6.L8
N21706833: length 2.7
  BOTTOM w0.102: PR321.1 v1(66.59,30.43)
  BOTTOM w0.254: PR321.1 66.59,28.57 66.34,28.32 PC304.2
N21706836: length 2.9
  BOTTOM w0.203: PU301.7 64.95,26.08 64.58,26.45
  BOTTOM w0.381: 64.58,26.45 64.58,27.26 65.19,27.87 PC304.1
N21711362: length 8.6
  BOTTOM w0.102: PR328.1 70.19,30.06 68.95,30.06 v1(68.65,30.35)
  BOTTOM w0.254: PL300.2 75.03,29.61 74.42,30.22 71.54,30.22 71.22,30.53 PR328.1
N21720435: length 3.4
  TOP w0.508: PC164.1 146.63,79.02 v1(146.63,77.69) 147.05,77.27 PR155.2
N21722925: length 2.9
  TOP w0.102: v2(155.1,77.91) v1(155.1,78.54)
  TOP w0.254: v2(155.1,77.91) 154.72,77.91 154.28,77.46 PC150.2
  BOTTOM w0.203: PU150.21 154.7,78.12 154.91,77.91 v2(155.1,77.91)
N21726938: length 5.7
  TOP w0.102: PR157.1 v1(148.01,74.93)
  TOP w0.254: PR157.1 148.94,75.19 148.94,77.52 149.26,77.84 v2(149.45,77.84)
  BOTTOM w0.203: v2(149.45,77.84) 149.57,77.72 PU150.2
N21828358: length 4.2
  TOP w0.102: LE2.2 99.32,132.9 v1(98.14,134.08) 97.8,134.42 JLVDS1.13
N22048929: length 15.7
  BOTTOM w0.102: JMINI1.24 286.66,149.8 282.8,153.66 282.8,157.93 281.85,158.88 R233.1 R228.1 283.26,159.88 283.26,161.47 v1(283.2,161.54)
N22150023: length 3.4
  TOP w0.102: R406.1 149.82,127.55 v1(150.19,127.17) 150.28,127.09 150.28,125.91 150.43,125.76 JDEG1.9
N22201445: length 6.4
  BOTTOM w0.102: v1(64.95,30.45) 65.19,30.2 PR321.2
  BOTTOM w0.203: PU301.6 64.66,25.68
  BOTTOM w0.381: 64.66,25.68 64.49,25.68 64.06,26.11 64.06,27.67 64.68,28.3 64.68,28.63 PR321.2
N22285464: length 3.6
  TOP w0.102: U83.24 297.43,168.53 297.27,168.37 297.27,167.99 v1(296.59,167.31) 296.21,166.93 R2627.2
N22421033: length 3.2
  TOP w0.102: R2699.1 166.44,119.9 U90.26
N22423064: length 4.8
  TOP w0.102: R2700.1 165.63,119.12 166.88,119.12 167.06,118.94 v1(167.25,118.94) 167.45,118.94 167.59,119.08 167.59,119.41 167.8,119.63 168.38,119.63 168.6,119.4 U90.27
N22905003: length 3.1
  TOP w0.102: RV2720.1 56.09,94.76 56.16,94.82 v1(56.16,94.85)
  TOP w0.254: RV2720.1 56.09,93.77 55.49,93.16 v4(54.94,93.16)
  BOTTOM w0.254: v4(54.94,93.16) 55.35,92.75 UV1.D22
N22905006: length 2.2
  TOP w0.102: RV2721.1 53.28,93.97 v4(53.27,93.96) 52.89,93.96 52.69,93.77 v1(52.69,93.56)
  BOTTOM w0.134: v4(53.27,93.96) 53.67,93.56 UV1.C24
N22905009: length 2.1
  TOP w0.102: RV2722.1 52.58,94.86 v4(52.47,94.75)
  BOTTOM w0.1: v4(52.47,94.75) UV1.B25
N22916336:
  vias: v1(65.24,90.28) v4(64.81,89.91) v4(65.7,89.91) v4(66.52,89.91)
N23032286: length 2.2
  TOP w0.102: v1(70.69,86.67) 70.4,86.38 CV3062.1
  BOTTOM w0.254: v2(68.24,85.72) 68.61,86.09 UV1.M6
N23032504: length 6.9
  BOTTOM w0.102: RV2442.1 62.39,98.48 v1(63.63,97.25) 64.05,96.83 64.24,96.83 65.7,95.36 65.7,93.96 UV1.C10
N23032510: length 5.4
  BOTTOM w0.102: UV1.A10 65.29,95.33 64.17,96.45 63.84,96.45 v1(62.41,97.88) RV2441.2
N23034682: length 3.4
  TOP w0.102: RV2444.2 63.85,93.32 v4(64.03,93.15) 64.03,92.97 64.22,92.78 64.22,91.91 64.52,91.62 v1(64.52,91.46)
  BOTTOM w0.1: UV1.D11 64.43,92.75 v4(64.03,93.15)
N23437023: length 3.9
  BOTTOM w0.102: Q20.1 261.09,157.8 R152.2 262.79,156.9 v1(263.03,157.14)
N23621189: length 2.5
  BOTTOM w0.102: v1(51.92,41.27) PR631.2
  BOTTOM w0.508: PR631.2 PC627.1
N23656617: length 4
  TOP w0.254: PR524.1 128.67,128.09 129.3,127.46 v1(129.96,127.46) 130.3,127.46 130.9,126.86 PQ515.6
N23693397: length 4.1
  TOP w0.102: v1(178.26,70.54) v2(177.58,70.54) RD5.2
  BOTTOM w0.102: v2(177.58,70.54) 177.58,70.33 176.81,69.55 JDIMM1.197
N23693399: length 5.9
  TOP w0.102: v2(173.56,71.54) 173.56,70.67 RD6.2 173.7,69.99 173.36,69.66 173.36,69.11 v1(173.95,68.52)
  BOTTOM w0.102: v2(173.56,71.54) 174.35,70.75 JDIMM1.201
N23699971: length 3.8
  TOP w0.102: v2(164.1,70.22) 163.85,70.22 v1(163.47,70.6) 163.31,70.6 163.18,70.73 RD10.1
  BOTTOM w0.102: v2(164.1,70.22) 163.57,70.75 JDIMM2.201
N23699973: length 4.9
  TOP w0.102: RD11.1 159.36,70.49 v1(159.36,70.48) 159.36,70.2 v2(159.73,69.84)
  BOTTOM w0.102: v2(159.73,69.84) 160.01,69.55 JDIMM2.197
N23709542: length 1.3
  BOTTOM w0.102: PC615.1 81.03,43.62 v1(81.27,43.37)
N23724597: length 1.5
  BOTTOM w0.102: C163.1 76.35,85.75 U19.10
N23724615: length 3.4
  BOTTOM w0.102: U19.3 81.69,86.55 R155.2 v1(82,88.05)
N23724651: length 3.1
  BOTTOM w0.102: U19.12 77.5,86.55 77.32,86.73 C152.1 76.3,86.73 v1(75.25,87.79)
N23729658: length 2.8
  TOP w0.102: RZ10.2 27.71,99.55 v1(28.17,99.09)
  TOP w0.254: RZ10.2 27.22,100.69 QZ5.6
N23729757: length 2.3
  TOP w0.102: RZ11.2 30.25,102.96 30.48,103.19 30.48,103.55 v1(30.31,103.71)
  TOP w0.254: QZ5.3 29.13,102.73 RZ11.2
N23729780: length 2.5
  TOP w0.102: QZ21.3 60.14,70.59 RZ40.2 59.93,71.38 59.78,71.53 v1(59.78,72.15)
N23729789: length 2.8
  TOP w0.102: v1(63.83,70.36) 64.23,70.76 RZ41.2 63.55,71.35 63.01,71.89 QZ21.6
N23819369: length 10.9
  TOP w0.102: PR510.1 138.89,147.76 139.76,146.88 v1(139.76,146.54)
  TOP w0.254: PQ505.4 137.96,152.9 137.39,152.33 137.39,148.77 137.07,148.45 PC506.1 PR510.1
N24106181: length 3.7
  TOP w0.254: PQ519.5 134.4,126.6 PR561.1 135.86,127.05 v1(136,126.91) 136.3,126.62 PR560.1
N24276807: length 4.2
  BOTTOM w0.102: RV75.1 RV76.2 80.07,90.93 80.21,90.8 QC6.2 81.38,90.8 v1(81.74,91.15)
N24520734: length 0.6
  TOP w0.102: 124.39,151.68 124.48,151.76 v5(124.93,151.76)
N24520740: length 3.1
  TOP w0.254: PD503.1 121.85,151.88 122.08,151.65 122.08,150.54 122.37,150.25 PQ506.6
N24520821: length 8
  TOP w0.102: PR564.1 136.3,124.64 136.97,123.97 v1(137.25,123.97)
  TOP w0.254: PR563.1 131.55,127.04 PQ515.5 131.55,125.66 131.86,125.34 135.58,125.34 136.03,124.9 PR564.1
N24568926: length 4.4
  TOP w0.102: v1(116.53,144.59) 116.13,145 115.05,145 PR429.2 113.26,145.47 113.19,145.41 PU402.8
N24568942: length 3
  TOP w0.102: PU402.9 v2(113.54,145.91) 114.13,145.91 PR430.2
  BOTTOM w0.102: v2(113.54,145.91) 113.38,145.75 v1(113.38,145.2)
N24568999: length 5.4
  TOP w0.102: PR59.1 189.71,146.86 189.71,149.15 v1(189.89,149.33)
  TOP w0.203: 189.52,145.6 190.07,145.05 PU51.19
  TOP w0.254: PR59.1 189.2,145.91 189.52,145.6
N24602247: length 14.7
  TOP w0.102: PQ528.1 v1(133.03,119.23)
  TOP w0.254: PQ528.1 130.48,119.23 v2(130.19,118.94) ; PR535.1 132.86,128.21 133.27,127.8 v2(133.27,126.52) PQ519.6
  IN2 w0.102: v2(133.27,126.52) 133.27,125.24 131.21,123.18 131.21,119.96 v2(130.19,118.94)
N24714082: length 2.3
  BOTTOM w0.102: R165.2 81.65,85.75 v1(81.06,85.75) U19.5
N24749465: length 2.9
  BOTTOM w0.102: PR150.2 v1(155.74,77.14)
  BOTTOM w0.203: PU150.20 155.41,78.52 155.72,78.21 PR150.2
N24839824: length 6.2
  TOP w0.102: v1(117.69,128.52) 118.1,128.52 119,127.62 PQ2.3
  TOP w0.254: PR9.1 120.12,125.26 120.12,125.82 PQ2.3
N24839835: length 6.5
  TOP w0.254: PL3.2 v1(115.89,128.06) 115.89,127.68 116.91,126.65 PQ2.1 116.91,123.42 PR10.1
N24840014: length 6.7
  TOP w0.254: PR13.1 120.1,121.54 118.59,123.05 PQ3.1 118.46,124.48 PQ2.2 120.24,123.77 PR11.2
N24856259:
  vias: v1(147.8,132.96)
N24856273:
  vias: v1(154.4,131.27)
N24856289: length 1.4
  TOP w0.254: PQ527.1 151.65,130.46 PR540.2
N24856313: length 3.4
  TOP w0.102: PQ527.2 148.59,131.64 v1(149.2,132.25)
  TOP w0.254: PU506.4 147.06,131.19 147.2,131.33 147.89,131.33 148.12,131.11 PQ527.2
N24865866: length 3.8
  TOP w0.102: v1(134.47,121.96) 134.73,122.23 PR539.1
  TOP w0.254: PQ519.3 135.05,123.25 PR539.1 134.4,123.26 PQ519.2
N24866547: length 2.6
  TOP w0.102: v1(129.39,116.97) PR566.2
  TOP w0.254: PQ528.2 129.81,118.1 PR566.2
N24957625: length 7.6
  TOP w0.254: PBATT2.3 92.04,172.57 92.04,168.98 92.87,168.14 v1(93.48,168.14) 93.95,168.14 PD1.3
N24972678: length 21.1
  TOP w0.254: v2(118.77,143.14) 118.28,143.14 v1(118.15,143.02) 118.12,142.99 118.12,142.14 PR527.2 ; PQ518.2 v2(117.93,151.84) ; PQ529.1 v2(112.24,154.92)
  IN1 w0.254: v2(117.93,151.84) 119.46,150.32 119.46,149.19 118.12,147.86 118.12,143.8 118.77,143.16 v2(118.77,143.14)
  IN3 w0.254: v2(117.93,151.84) 117.48,151.84 114.41,154.92 v2(112.24,154.92)
N24972684: length 13.9
  TOP w0.102: v2(116.76,141.98) 116.76,142.95 v1(116.85,143.04)
  TOP w0.254: PR527.1 v2(116.76,141.98) ; v2(117.9,149.91) PQ518.3 116.71,149.21 117.02,148.91 PR568.1 117.02,147.5 PR567.1
  IN1 w0.254: v2(117.9,149.91) 117.36,149.37 117.36,142.57 v2(116.76,141.98)
N24972963: length 1.1
  TOP w0.102: v1(109.26,152.88) 109.37,153 PR525.2
N25025874: length 9.8
  TOP w0.102: PD509.2 117.36,145.51 v1(118.27,144.6)
  TOP w0.254: PQ518.1 v2(120.05,150.88)
  TOP w0.508: PD509.2 118.36,146.1 v2(118.6,146.34)
  IN2 w0.254: v2(118.6,146.34) 118.41,146.54 118.41,148.12 120.05,149.76 v2(120.05,150.88)
N25025878: length 0.8
  TOP w0.102: v1(124.95,127.36) 125.03,127.28 125.77,127.28
N25442948: length 3.4
  TOP w0.102: U87.4 102.16,96.88 101.89,97.15 101.13,97.15 100.86,97.42 D80.2 99.95,97.87 v1(99.82,97.74)
N25461188: length 13.6
  BOTTOM w0.102: JMINI1.16 280.26,154.86 280.77,155.38 280.77,159.62 v1(279.81,160.58) 279.7,160.58 R234.1
N25461247: length 13.3
  BOTTOM w0.102: R236.1 278.35,159.25 v1(280.12,159.25) 280.52,158.86 280.52,155.5 279.46,154.45 JMINI1.14
N25461262: length 14.1
  BOTTOM w0.102: v1(271.75,159.68) R238.1 272.83,155.38 273.4,154.8 274.29,154.8 275.12,153.98 275.12,152.34 277.06,150.4 JMINI1.8
N25461295: length 17
  BOTTOM w0.102: JMINI1.12 278.66,149.93 278.23,150.36 277.75,150.36 275.63,152.48 275.63,154.23 274.55,155.31 273.66,155.31 273.29,155.68 273.29,158.69 273.79,159.19 274.24,159.19 R240.1 275.21,160.15 275.21,161.6 v1(274.98,161.83)
N25461301: length 15.6
  BOTTOM w0.102: JMINI1.10 277.86,149.92 275.37,152.41 275.37,154.11 274.42,155.06 273.53,155.06 273.06,155.53 273.06,158.96 R239.1 273.3,160.16 v1(273.3,161.6)
N25462362: length 3.5
  BOTTOM w0.102: v1(285.81,159.64) 285.22,159.64 285,159.43 R244.2 284.66,159.38 JMINI1.19
N25462371: length 5.3
  BOTTOM w0.102: v1(285.15,161.61) 284.71,161.61 284.21,161.11 284.21,159.88 R241.2 283.76,159.01 283.86,158.91 JMINI1.17
N26045473: length 0.9
  TOP w0.102: C319.1 178.68,164.77 R273.2
N26045635: length 2.2
  TOP w0.102: RE4.2 CE8.1 169.35,165.54 v1(169.25,165.64)
N26045731: length 2.1
  TOP w0.102: v1(167.04,162.53) 167.04,162.98 167.42,163.36 RE5.2 CE9.1
N26176018: length 3.2
  TOP w0.102: v1(25.25,90.85) 25.12,90.97 R460.2 24.98,92 23.8,92 23.47,91.67 QZ22.5
N26268990: length 8.8
  TOP w0.102: R422.2 83.27,25.26 84.06,25.26 R421.2 84.97,25.21 v2(84.97,25.01)
  BOTTOM w0.102: v2(84.97,25.01) v1(85.4,24.58) 85.57,24.41 85.57,21.99 86.86,20.7 U45.5
N26269092: length 8.8
  TOP w0.102: v2(84.37,25) 84.76,24.6 85.14,24.6 85.38,24.84 R423.2 R424.2
  BOTTOM w0.102: U45.3 86.06,20.59 84.71,21.94 v1(84.71,22.97) 84.71,24.66 v2(84.37,25)
N27140797: length 6.3
  BOTTOM w0.102: UV1.F3 71.47,90.65 71.47,90.06 71.71,89.82 73.8,89.82 74.6,90.62 v1(74.99,90.62) 75.85,90.62 RV2436.1
N27141414: length 4.2
  TOP w0.102: RV2704.1 52.75,91.88 54.57,91.88 v4(54.95,91.49) 55.12,91.49 v1(55.65,90.96)
  BOTTOM w0.1: UV1.F22 55.37,91.08 v4(54.95,91.49)
N27141416: length 2.1
  TOP w0.102: v1(55.24,89.27) 55.54,88.98 v4(55.72,88.98) 55.74,89.01 RV2705.1
  BOTTOM w0.1: v4(55.72,88.98) UV1.J22
N27747674: length 5
  BOTTOM w0.102: v1(81.39,126.4) 82.14,125.66 R52.2 83.79,124.41 83.79,124.11 84.07,123.84 JSATA1.10
N28295639: length 2.4
  TOP w0.102: v1(174.14,5.25) 174.22,5.17 D23.1 174.17,4.2 Q24.3
N28889829: length 2
  TOP w0.102: RV73.1 RV74.1 74.52,94.73 74.44,94.81 QC8.6
N28926298: length 4.3
  TOP w0.102: R77.2 156.92,123.84 156.92,125.73 157.23,126.04 U15.11
N29179028: length 5.3
  TOP w0.102: R319.2 159.74,104.19 160.06,103.88 v1(160.39,103.88) 160.5,103.88 160.69,104.07 161.07,104.07 161.33,103.81 161.33,102.8 162.54,101.59 U37.B18
N31479955: length 7.8
  TOP w0.102: 159.69,103.24 v1(160.57,102.37) ; 159.69,103.24 160.48,103.24 v2(160.9,103.66) ; 159.69,103.24 R321.1 ; v2(163.54,101.4) 163.23,101.09 U37.B19
  IN1 w0.097: v2(163.54,101.4) 162.23,101.4 160.9,102.73 v2(160.9,103.66)
N35502990: length 3.6
  TOP w0.102: v1(83.26,107.85) 83.35,107.94 R126.2 84.35,108.44 84.38,108.46 Q19.6 84.38,109.34 84.25,109.47 83.86,109.47 83.73,109.34 Q19.5
N48705663: length 3.1
  TOP w0.102: v1(115.82,122.64) 116.12,122.34 PR10.2
  TOP w0.254: PR10.2 PR12.1 117.55,121.42 PQ3.2
N53734664: length 12.2
  TOP w0.102: v2(141.21,103.31) 141.2,103.31 U38.B61 ; R381.1 131.6,104.07 v1(131.6,103.88) 131.6,103.64 v2(131.86,103.37)
  BOTTOM w0.102: v2(131.86,103.37) 131.93,103.43 141.08,103.43 v2(141.21,103.31)
N53866851: length 0.9
  TOP w0.102: C363.1 R382.2
N61090377: length 6.1
  TOP w0.102: v1(189.72,47.37) 189.98,47.12 R33.1
  TOP w0.254: QD1.3 189.63,42.32 189.98,42.66 R29.1 R30.1 R31.1 189.98,46.09 R33.1
N61399843: length 2.3
  TOP w0.102: R318.2 164.83,104.91 v1(164.83,104.16) 164.83,103.59 164.73,103.5 U37.A14
N61858263: length 2.4
  BOTTOM w0.102: U27.26 10.36,32.07 10.27,32.16 10.27,32.49 v1(10.03,32.74) 9.81,32.95 R211.1
N62014302: length 2.6
  TOP w0.102: v1(219.23,151.98) 218.91,151.67 C401.1 217.89,151.06 217.84,151.01 U46.12
N62015979: length 2.6
  TOP w0.102: v1(219.16,149.2) 218.91,149.46 C402.1 217.82,150.17 217.78,150.21 U46.10
N62018216: length 7.1
  TOP w0.102: U46.5 214.79,150.21 214.69,150.11 214.59,150.09 212.7,150.09 R425.2 R426.2 v1(213.52,150.68) 213.65,150.68 213.99,151.01 U46.3
N62020898: length 2.9
  BOTTOM w0.102: C398.1 86.54,15.4 v1(86.54,16.44) 86.54,17.11 86.86,17.43 U45.10
N62020976: length 3
  BOTTOM w0.102: C397.1 86.06,15.87 U45.12
N62022297: length 2.7
  TOP w0.102: U43.12 91.93,72.91 92.04,73.02 92.86,73.02 C390.1 92.99,74.17 v1(93.04,74.22)
N62022948: length 2.2
  TOP w0.102: U43.3 89.16,72.91 88.17,73.9 R416.2
N62071680: length 7.9
  TOP w0.102: v1(138.28,109.05) 138.28,108.98 137.98,108.69 v2(137.98,108.58) R349.1 ; v2(141.32,105.34) 140.82,105.34 140.79,105.31 U38.B57
  BOTTOM w0.102: v2(141.32,105.34) 140.15,106.51 140.15,107.81 139.39,108.58 v2(137.98,108.58)
N62078629: length 3.9
  TOP w0.102: U18.10 250.21,167.46 v2(250,167.25)
  BOTTOM w0.102: v2(250,167.25) 249.99,167.26 C148.1 249.34,168.34 v1(249.25,168.43)
N62078645: length 5
  TOP w0.102: U18.5 250.21,171.71 250.16,171.76 250.16,172.44 R154.2 ; U18.3 251.01,171.7 251.05,171.74 251.05,172.47 R154.2 ; v1(251.68,173.1) 251.47,172.9 R154.2
N62078782: length 3.9
  TOP w0.102: v2(251.22,167.25) 251.01,167.46 U18.12
  BOTTOM w0.102: v2(251.22,167.25) 251.23,167.26 C147.1 252.78,167.26 v1(253.06,166.98)
N62111964: length 4.3
  TOP w0.102: v1(149.54,113.85) 149.54,113.98 R403.2 150.81,114.74 150.91,114.85 Q12.2
N63746311: length 8.1
  TOP w0.102: v2(141.65,99.87) 141.64,99.86 U38.B2 ; R352.1 v2(141.32,93.79)
  BOTTOM w0.102: v2(141.32,93.79) 140.89,94.23 v1(140.89,94.89) 140.89,95.51 140.82,95.58 140.82,99.05 141.64,99.87 v2(141.65,99.87)
N63746359: length 15.3
  TOP w0.102: R338.1 142.98,90.12 143.09,90.24 v1(143.09,91.06) 143.09,92.71 v2(142.79,93.02) ; U38.B8 144.64,100.21 144.92,100.48 v2(145.16,100.48)
  IN1 w0.097: v2(142.79,93.02) 143.93,93.02 144.18,93.27 144.18,93.84 146.01,95.68 146.01,96.76 145.74,97.03 145.74,98.52 144.75,99.51 144.75,100.38 144.85,100.48 v2(145.16,100.48)
N64492809: length 2.1
  BOTTOM w0.102: Q21.3 266.66,158.67 R157.2 266.74,159.5 v1(266.9,159.67)
N64492816: length 2.2
  BOTTOM w0.102: v1(263.07,155.77) R156.2 264.31,155.88 Q21.6
N64569940: length 0.9
  BOTTOM w0.254: C136.1 R149.2
N64569944: length 2.1
  BOTTOM w0.102: v1(253.29,160.85) 253.95,160.19 C135.1
  BOTTOM w0.254: C135.1 R148.2
N70882705: length 4.6
  TOP w0.102: Q16.1 179.3,8.6 v1(179.74,8.16) 181.36,8.16 R435.1
N70882773: length 109.5
  TOP w0.102: Q28.3 v2(191.68,87.54) ; v2(177.52,3.42) 177.58,3.48 v1(177.58,5.36) 177.58,5.41 176.81,6.19 Q16.2
  IN2 w0.102: v2(191.68,87.54) 192.44,86.78 192.44,77.72 188.38,73.65 188.38,72.99 184.7,69.3 184.7,61.29 186.37,59.62 187.68,59.62 189.05,58.25 189.05,54.95 190.92,53.08 190.92,51.68 195.68,46.91 195.68,45.27 196.48,44.47 196.48,37.3 193.37,34.19 193.37,22.06 190.6,19.3 190.6,16.25 187.62,13.26 187.62,6.66 184.57,3.61 177.71,3.61 v2(177.52,3.42)
N74832224: length 8.8
  TOP w0.102: R367.1 R370.1 134.72,100.42 v2(135.01,100.42) 135.01,99.93 v1(135.36,99.58) ; U38.A59 138.64,102.56 v2(138.62,102.54)
  BOTTOM w0.102: v2(138.62,102.54) 138.62,101.68 137.36,100.42 v2(135.01,100.42)

## Copper pours and planes (outline as drawn)
1.5VRUN_LX on BOTTOM (solid shape): 273.53,170.81 273.53,169.79 273.15,169.41 272.07,169.41 271.56,168.9 268.77,168.9 268.45,168.58 268.45,167.66 268.4,167.61 267.74,167.61 267.69,167.66 267.69,168.58 267.63,168.65 267.62,168.65 267.62,170.68 267.82,170.87 273.47,170.87
1.5VRUN_VIN on BOTTOM (solid shape): 260.18,168.46 260.64,168.46 261.15,168.46 263.25,166.36 266.1,166.36 267.05,165.41 268.39,165.41 268.45,165.35 268.45,164.96 268.45,164.96 268.45,164.26 268.26,164.08 261.91,164.08 260.83,165.15 260.07,165.15 259.63,165.6 259.63,166.74 260.18,166.74 260.18,168.14 259.63,168.14 259.63,168.46
1.35V_B+ on TOP (solid shape): 190.98,80.16 190.98,76.13 190.41,75.56 185.96,75.56 185.56,75.96 185.56,80.26 185.74,80.44 190.7,80.44
1.35V_B+ on BOTTOM (solid shape): 194.6,80.76 194.6,80.13 194.47,80 193.96,80 193.71,79.75 193.71,76.44 193.51,76.25 191.86,76.25 191.51,75.9 191.51,74.93 191.41,74.83 190.62,74.83 189.77,75.68 189.77,80.51 190.16,80.89 194.47,80.89
+0.9V_LAN on TOP (solid shape): 176.25,137.34 176.25,136.77 176.18,136.71 174.53,136.71 174.03,136.2 172.69,136.2 172.69,137.09 174.09,137.09 174.22,137.21 175.04,137.21 175.23,137.4 176.18,137.4
+0.9V_LAN on TOP (solid shape): 179.55,130.29 179.49,130.23 177.27,130.23 177.2,130.29 177.2,131.25 177.33,131.37 178.03,131.37 178.15,131.5 178.15,132.2 179.55,132.2
+0.9V_LAN on BOTTOM (solid shape): outline of 221 points within 173.58,133.72 184.19,142.93
+0.675V_DDR_VTT on TOP (solid shape): 181.33,87.42 181.33,86.41 181.27,86.35 179.74,86.35 179.62,86.48 179.62,87.91 179.81,88.1 180.64,88.1
+0.675V_DDR_VTT on TOP (solid shape): outline of 259 points within 161.9,71.07 186.05,75.3
+0.675V_DDR_VTT on IN2 (solid shape): outline of 136 points within 176.63,73.33 181.96,88.26
+0.675V_P on TOP (solid shape): 180.38,86.1 180.38,85.59 180.89,85.59 180.89,86.16 181.14,86.16 181.14,84.76 180.89,84.51 177.99,84.51 177.62,84.14 177.62,83.1 177.21,82.69 176.21,82.69 176.16,82.74 176.16,82.83 176.24,82.91 176.57,82.91 176.76,83.1 176.76,84.09 176.61,84.24 175.92,84.24 175.67,83.99 175.67,83.02 175.61,82.97 175.51,82.97 175.46,83.02 175.46,84.65 175.99,85.18 175.99,85.77 176.07,85.84 179.55,85.84 179.87,86.16 180.31,86.16
+1.2V_LDO on BOTTOM (solid shape): 17.12,29.52 16.8,29.52 16.48,29.2 15.98,29.2 15.79,29.01 14.83,29.01 14.77,29.07 14.77,29.14 14.83,29.2 15.59,29.2 16.04,29.65 16.48,29.65 16.86,30.03 17.12,30.03
+1.2V_LDO on IN2 (solid shape): outline of 293 points within 9.24,23.36 20.42,30.28
+1.5V_GPU on TOP (solid shape): 30.52,70.86 30.52,68.63 30.45,68.57 29.05,68.57 28.99,68.63 28.99,70.79 29.12,70.92 30.45,70.92
+1.05V_GPU on TOP (solid shape): 76.68,85.91 76.68,83.68 75.92,82.92 73.25,82.92 73.06,83.11 73.06,84.38 74.21,84.38 74.52,84.7 74.52,86.22 76.36,86.22
+1.5V_GPU on TOP (solid shape): 41.95,101.66 41.95,97.46 41.69,97.21 40.1,97.21 39.85,97.46 39.85,99.88 39.66,100.07 33.18,100.07 33.15,100.04 33.03,100.16 32.64,100.16 32.21,100.16 32.29,99.73 32.34,99.66 32.31,99.57 32.1,99.37 32.1,97.53 31.98,97.4 30.71,97.4 30.52,97.59 30.52,98.92 30.38,99.06 30.38,99.08 30.36,99.08 30.07,99.37 30.07,101.65 30.58,102.16 41.44,102.16
+1.5V_GPU on TOP (solid shape): outline of 375 points within 34.84,52.19 47.66,71.05
+1.05V_GPU on TOP (solid shape): outline of 537 points within 50.9,70.35 64.62,80.18
+1.5V_GPU on TOP (solid shape): outline of 1544 points within 38.63,80.48 58.77,95.56
+1.5V_GPU on BOTTOM (solid shape): 31.4,99.56 31.4,97.59 31.21,97.4 29.88,97.4 29.69,97.59 29.69,98.99 29.88,99.18 29.88,99.5 30.07,99.69 31.28,99.69
+1.05V_GPU on BOTTOM (solid shape): 78.21,85.4 78.21,82.54 77.95,82.29 74.33,82.29 74.08,82.54 74.08,85.02 74.4,85.34 76.87,85.34 77,85.46 78.14,85.46
+1.5V_GPU on BOTTOM (solid shape): 41.29,56.32 41.3,56.27 41.84,54.63 43.03,53.38 43.03,51.49 42.84,51.3 42.39,51.3 42.39,51.87 40.99,51.87 40.99,51.3 38.58,51.3 38.58,51.87 37.18,51.87 37.18,51.3 36.7,51.3 36.51,51.49 36.51,55.97 36.85,56.32 37.95,56.32 38.45,56.82 40.78,56.82
+1.5V_GPU on BOTTOM (solid shape): outline of 180 points within 28.93,66.03 47.73,71.68
+1.5V_GPU on BOTTOM (solid shape): outline of 409 points within 55.12,80.05 63.19,91.36
+1.05V_GPU on BOTTOM (solid shape): outline of 887 points within 50.65,73.59 65.65,80.06
+1.5V_GPU on IN1 (solid shape): outline of 350 points within 29.06,52.51 47.92,71.37
+1.05V_GPU on IN1 (solid shape): outline of 4497 points within 48.11,71.72 75.71,88.95
+1.5V_GPU on IN2 (solid shape): outline of 13363 points within 25.39,68.57 64.74,98.92
+1.05V_GPU on IN3 (solid shape): outline of 253 points within 51.09,73.65 63.28,80.51
+1.5V_GPU on VCC: 33.1,51.81 32.36,52.55 32.36,66.77 30.69,68.44 22.71,68.44 22.71,69.95 21.31,71.34 21.31,105.22 28.86,105.22 29.08,105.17 29.25,105.02 32.3,103.47 35.35,105.02 35.52,105.17 35.74,105.22 50.28,105.22 56.49,105.83 62.46,107.63 62.46,98.18 63.98,96.66 63.98,89.53 57.65,89.53 56.99,88.87 56.99,74.01 55.75,72.76 49.02,72.76 47.85,71.6 47.85,54.71 44.95,51.81
+1.05V_M on TOP (solid shape): 134.15,91.11 134.15,90.54 134.69,90 134.69,89.35 134.49,89.15 130.91,89.15 130.91,92.01 133.26,92.01
+1.05V_M on TOP (solid shape): 89.83,71.75 89.83,70.92 90.12,70.63 90.12,69.46 90.12,68.36 89.89,68.13 87.79,68.13 87.6,68.32 87.6,71.29 88,71.68 88.81,71.68 88.94,71.81 89.76,71.81
+1.05V_M on TOP (solid shape): 97.79,67.28 97.79,66.29 97.7,66.2 97.7,64.95 97.89,64.76 99.16,64.76 99.16,64.13 98.4,64.13 97.89,63.62 96.87,63.62 96.87,67.24 97,67.36 97.7,67.36
+1.05V_M on TOP (solid shape): outline of 99 points within 131.29,76.45 138.4,81.84
+1.05V_M on TOP (solid shape): 97.79,79.62 97.79,77.14 98.46,76.47 98.46,74.52 98.22,74.29 94.59,74.29 94.45,74.15 93.59,74.15 93.49,74.25 93.49,74.9 93.5,74.91 93.5,75.96 93.49,75.97 93.49,76.8 93.51,76.82 93.53,76.89 93.59,76.92 93.68,76.84 93.78,76.78 93.84,76.73 93.85,76.65 94.15,76.17 94.53,76.59 94.53,76.61 95,77.08 95.03,77.07 95.1,77.04 95.18,77.03 95.64,77.03 95.97,77.25 95.89,77.64 95.89,77.64 95.86,77.71 95.89,77.78 95.89,77.79 95.97,78.18 95.64,78.39 93.93,78.39 93.81,78.27 93.51,78.27 93.51,79.53 93.83,79.85 97.55,79.85
+1.05V_M on BOTTOM (solid shape): 134.9,89.46 134.9,88.32 134.87,88.29 134.87,86.95 133.96,86.03 133.96,79.3 133.77,79.11 131.55,79.11 131.36,79.3 131.36,81.45 131.37,81.46 131.4,81.5 131.42,81.54 131.44,81.58 131.44,81.63 131.44,81.68 131.44,81.72 131.42,81.76 131.4,81.81 131.37,81.84 131.36,81.86 131.36,82.31 132.14,82.31 132.14,82.26 132.15,82.2 132.17,82.15 132.19,82.1 132.22,82.06 132.26,82.02 132.3,81.99 132.34,81.96 132.39,81.94 132.45,81.93 132.5,81.93 132.55,81.93 132.6,81.94 132.65,81.96 132.7,81.99 132.74,82.02 132.78,82.06 132.81,82.1 132.83,82.15 132.85,82.2 132.85,82.26 132.85,82.31 132.85,82.36 132.83,82.41 132.81,82.46 132.78,82.51 132.74,82.54 132.7,82.58 132.65,82.6 132.6,82.62 132.55,82.64 132.5,82.64 132.45,82.64 132.39,82.62 132.34,82.6 132.3,82.58 132.26,82.54 132.22,82.51 132.19,82.46 132.17,82.41 132.15,82.36 132.14,82.31 131.36,82.31 131.36,87.18 132.5,88.32 132.5,89.46 133.01,89.97 134.39,89.97
+1.05V_M on IN2 (solid shape): outline of 142 points within 119.3,56.57 122.76,59.1
+1.05V_M on VCC: 122.4,58.14 122,58.54 119.58,58.54 119.48,58.64 119.48,60.97 120.75,62.24 120.75,64.1 119.96,64.89 87.86,64.89 87.86,70.6 89.2,71.95 89.2,86.37 90.27,87.44 137.1,87.44 138.38,86.17 138.38,75.86 139.04,75.2 139.04,75.2 139.19,75.05 141.73,75.05 142.37,74.41 142.37,67.81 138.81,67.81 135.12,64.13 132.08,64.13 128.14,60.19 127.25,60.19 126.55,59.49 123.76,59.49 ; 1 cut-out
+1.05V_MODPHY on TOP (solid shape): outline of 138 points within 93.89,68.42 102.26,79.71
+1.05V_MODPHY on BOTTOM (solid shape): outline of 212 points within 90.4,62.16 94.4,70.98
+1.05V_MODPHY_PCH on TOP (solid shape): outline of 1150 points within 99.86,59.79 114.23,72.06
+1.05V_MP on TOP (solid shape): 141.9,80.26 141.9,80.06 141.77,79.94 141.77,75.05 139.22,75.05 138.34,75.92 138.34,80.19 138.66,80.51 141.64,80.51
+1.05V_MP on BOTTOM (solid shape): 82.78,80.95 82.78,80.13 81.7,79.05 78.84,79.05 78.59,79.3 78.59,81.02 78.71,81.14 82.59,81.14
+1.05V_MP on BOTTOM (solid shape): 143.11,80.56 143.49,80.56 143.64,80.42 143.64,75.73 143.33,75.43 139.42,75.43 139.1,75.75 139.1,79.49 139.42,79.81 139.42,80.13 139.86,80.57 143.1,80.57
+1.05V_MP on VCC: 138.88,76.07 138.88,86.38 137.31,87.95 90.06,87.95 88.69,86.58 88.69,79.75 79.2,79.75 78.59,80.36 78.59,91.05 81,93.46 86.59,93.46 87.6,94.48 139.8,94.48 145.77,88.51 145.77,74.79 145.13,74.16 142.85,74.16 142.85,74.67 141.96,75.56 139.4,75.56
+1.5V_RUN on TOP (solid shape): 98.59,25.39 98.59,23.23 98.48,23.13 96.56,23.13 96.42,23.26 96.42,25.38 96.31,25.49 96.31,26.01 96.35,26.04 97.94,26.04
+1.05V_RUN on TOP (solid shape): 109.77,99.11 109.51,98.86 109.51,97.59 109.96,97.15 109.96,95.37 110.27,95.06 110.27,92.27 110.13,92.14 110.13,89.1 108.84,87.81 106.08,87.81 105.45,87.18 104.62,87.18 104.37,86.92 103.67,86.92 103.35,87.24 103.35,88.89 104.56,90.1 105.57,90.1 106.04,90.56 106.04,92.46 106.72,93.14 106.72,93.65 106.15,94.23 106.15,98.7 107,98.7 107,98.64 107,98.59 107.02,98.54 107.04,98.49 107.07,98.45 107.11,98.41 107.15,98.38 107.2,98.35 107.25,98.33 107.3,98.32 107.35,98.31 107.41,98.32 107.46,98.33 107.51,98.35 107.55,98.38 107.59,98.41 107.63,98.45 107.66,98.49 107.68,98.54 107.7,98.59 107.71,98.64 107.71,98.7 107.7,98.75 107.68,98.8 107.66,98.85 107.63,98.89 107.59,98.93 107.55,98.96 107.51,98.99 107.46,99.01 107.41,99.02 107.35,99.03 107.3,99.02 107.25,99.01 107.2,98.99 107.15,98.96 107.11,98.93 107.07,98.89 107.04,98.85 107.02,98.8 107,98.75 107,98.7 106.15,98.7 106.15,99.5 106.46,99.81 109.77,99.81
