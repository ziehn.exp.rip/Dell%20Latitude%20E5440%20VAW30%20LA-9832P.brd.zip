# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_XDP_TCLK: length 58.4
  TOP w0.102: JXDP1.57 134.65,13.34 134.33,13.67 131.39,13.67 130.93,14.13 130,14.13 127.88,16.25 115.34,16.25 v2(114.39,17.2)
  IN1 w0.097: v2(108.76,30.2) 108.76,29 112.43,25.33 112.43,20.69 111.67,19.93 111.67,18.72 112.31,18.09 113.5,18.09 v2(114.39,17.2)
  IN3 w0.102: v2(114.39,17.2) 114.39,17.59 113.75,18.23 111.54,18.23 110.79,17.48 110.22,17.48 107.53,14.79 103.35,14.79 102.72,15.42 v2(101.12,15.42)
  BOTTOM w0.076: UC1.E60 109.1,30.54 v2(108.76,30.2)
  BOTTOM w0.102: RC127.2 RC124.1 101.76,15.41 RC97.1 v2(101.12,15.42)
CPU_XDP_TDI: length 9.9
  BOTTOM w0.102: UC6.6 106.21,16.94 105.44,17.71 105.44,18.32 104.41,19.35 104.32,19.35 104.22,19.45 103.77,19.45 103.29,19.93 103.15,19.93 RC209.2 RC119.2 v1(100.3,20.76)
CPU_XDP_TDI_R: length 14.5
  BOTTOM w0.076: 102.75,25.9 103.83,26.98 104.34,26.98 104.63,27.27 107.72,27.27 109.04,25.95 v5(109.69,25.95) 109.97,26.23 UC1.F63
  BOTTOM w0.102: RC209.1 101.74,23.22 101.74,24.15 102.41,25.55 102.75,25.9
CPU_XDP_TDO: length 12.1
  IN1 w0.097: v2(109.38,20.76) 109.89,20.25 109.89,18.15 109.38,17.64 108.3,17.64 106.65,15.98 v2(105.67,15.98)
  BOTTOM w0.102: v1(108.93,20.22) 109.38,20.68 v2(109.38,20.76) 109.4,20.77 RC122.2 110.08,21.45 109.96,21.58 RC208.2 ; UC6.3 106.21,15.44 v2(105.67,15.98)
CPU_XDP_TDO_R: length 6.5
  BOTTOM w0.076: UC1.F62 109.97,29 110.26,28.71 110.26,27.37 110.36,27.27 110.36,25.9
  BOTTOM w0.102: RC208.1 110.05,23.15 v5(110.05,24.21) 110.05,25.49 110.36,25.79 110.36,25.9
CPU_XDP_TMS: length 26.4
  TOP w0.102: v2(107.99,18.47) v5(107.99,17.75)
  IN1 w0.076: v2(103.32,27.07) 102.31,26.06 102.31,25.9
  IN1 w0.097: v2(107.99,18.47) 106.91,19.55 104.96,19.55 102.31,22.2 102.31,25.9
  BOTTOM w0.076: UC1.E61 108.91,29.61 108.91,28.79 108.83,28.71 108.83,28.12 108.34,27.63 107.35,27.63 107.16,27.44 104.56,27.44 104.27,27.14 103.39,27.14 v2(103.32,27.07) 102.42,26.18 102.42,25.9
  BOTTOM w0.102: 102.42,25.9 102.13,25.6 RC118.2 ; UC6.8 108.21,18.24 v2(107.99,18.47)
CPU_XDP_TRST#: length 21.6
  TOP w0.102: v5(111.06,16.15) 110.66,16.55 v2(110.65,16.55)
  IN1 w0.097: v2(110.65,16.55) 110.65,17.52 111.1,17.96 111.1,20.38 112.11,21.39 112.11,25.2 108.35,28.96 108.35,30.42 v2(108.77,30.84)
  BOTTOM w0.076: v2(108.77,30.84) 109.12,31.19 UC1.E59
  BOTTOM w0.102: UC6.11 109.52,15.94 109.7,16.12 110.22,16.12 v2(110.65,16.55) 110.83,16.37 110.83,16.14 111.28,15.7 RC135.1 RC131.2
CRT_SWITCH: length 83.6
  TOP w0.102: U39.30 v2(155.23,152.26) ; U37.B52 172.31,93.59 173.05,92.85 v2(173.61,92.85) 174.28,92.85 v1(174.76,92.37)
  IN3 w0.102: v2(173.46,147.76) 173.46,135.25 174.28,134.42 174.28,119.08 175.18,118.18 175.18,113.29 176.21,112.26 176.21,110.32 175.49,109.59 175.49,99.82 175.23,99.55 175.23,94.28 173.8,92.85 v2(173.61,92.85)
  BOTTOM w0.102: v2(155.23,152.26) 155.61,152.26 156.18,151.69 156.18,147.88 156.31,147.76 v2(173.46,147.76)
CS_1.35V: length 6.9
  TOP w0.203: PU100.13 175.17,79.53 v2(175.1,79.47)
  TOP w0.508: PR101.2 v2(175.12,75.82)
  IN2 w0.508: v2(175.1,79.47) 174.77,79.14 174.77,76.17 v2(175.12,75.82)
  BOTTOM w0.102: v2(175.1,79.47) 175.6,79.96 v1(175.6,80.15)
CSN1: length 52
  IN2 w0.254: v2(69.05,31.41) 68.97,31.49 66.27,31.49 60.08,25.29 48.23,25.29 45.95,23.01 45.95,14.85 45.5,14.41 45.06,14.41 v2(44.93,14.28)
  BOTTOM w0.203: PU300.18 48.19,17.34 47.61,16.77 PC318.2
  BOTTOM w0.254: v2(44.93,14.28) 44.87,14.28 44.36,14.79 v1(44.36,15.64) 44.36,15.9 45.22,16.77 PC320.2 PC318.2 ; v2(69.05,31.41) PR333.2 PR329.2 70.98,31.41 71.73,30.66 74.52,30.66 75.03,31.17 PL300.3
CSP1: length 45.6
  IN2 w0.254: v2(69.06,32.06) 68.93,31.93 66.08,31.93 59.82,25.67 48.07,25.67 45.57,23.16 45.57,15.01 45.35,14.79 45.06,14.79 v2(44.93,14.91)
  BOTTOM w0.203: PU300.17 48.29,16.94 v1(47.7,16.35) 47.2,15.85 PC318.1
  BOTTOM w0.254: PH301.1 69.75,32.34 PR333.1 69.33,32.33 v2(69.06,32.06) 68.81,32.06 68.55,31.8 68.55,31.11 69.13,30.53 PR328.2 ; PC318.1 PC320.1 45.3,15.85 44.93,15.49 v2(44.93,14.91)
CSS_GC: length 18.2
  TOP w0.254: PU701.10 126.37,136.67 126.59,136.45 126.59,135.34 v2(126.81,135.12) ; PR403.1 112.57,137.6 v2(112.57,137.6)
  BOTTOM w0.254: v2(126.81,135.12) 122.08,135.12 121.51,135.69 v1(119.65,135.69) 115.29,135.69 113.38,137.6 v2(112.57,137.6)
CSSN_1: length 29.4
  TOP w0.254: 109.7,142.55 109.84,142.69 PU402.1 ; 114.59,134.99 114.59,131.82 114.4,131.63 PU401.5 113.58,131.63 113.26,131.31 PR408.1 ; 114.59,134.99 PQ403.2 ; 114.59,134.99 114.59,136.58 115.24,137.23 PR418.1 v2(115.86,137.79)
  TOP w0.508: PC408.2 109.7,141.69 109.7,142.55 ; PC408.2 109.61,139.17 PR410.2 109.44,138.34 v2(109.37,138.28) v1(106.68,138.28) 106.21,138.28 105.56,137.63 PQ401.3 ; PC408.2 108.7,141.6 PC409.1
  IN2 w0.508: v2(109.37,138.28) 109.37,138.25 110.02,137.6 110.65,137.6 111.29,138.23 115.16,138.23 115.61,137.79 v2(115.86,137.79)
CSSP_1: length 27.6
  TOP w0.254: PQ403.5 115.16,134.99 114.97,135.18 114.97,136.42 115.45,136.9 115.67,136.9 116.37,137.6 116.37,138.12 116.05,138.43 v2(115.86,138.43) 115.54,138.43 115.3,138.67 PR417.1 ; 110.4,142.55 110.34,142.61 PU402.2
  TOP w0.508: PC438.2 112.48,141.61 PC407.2 110.54,141.61 PC408.1 ; PC408.1 110.4,141.72 110.4,142.55 ; PC408.1 110.53,141.01 110.35,140.83 v1(110.35,140.21) PR410.1 110.35,138.31 v2(110.28,138.24) 110.28,137.86 109.62,137.2 PQ402.3 109.51,135.98 109.51,133.34 110.08,132.77 111.21,132.77 PR411.2
  IN2 w0.508: v2(110.28,138.24) 110.91,138.87 115.43,138.87 v2(115.86,138.43)
D_CLKRUN#: length 93.2
  TOP w0.102: U37.A19 160.9,100.34 v2(159.93,99.37) 159.48,99.37 159.42,99.43 RP5.3
  IN3 w0.102: v2(177.46,166.62) 177.03,166.18 169.22,166.18 166.02,162.98 165.28,162.98 165.04,162.74 165.04,159.14 163.99,158.09 163.99,157.37 165.14,156.23 165.14,145.15 161.37,141.38 159.75,141.38 157.96,139.59 157.96,138.77 155.55,136.35 155.55,130.93 155.04,130.42 155.04,122.48 156.12,121.4 156.12,120.64 154.41,118.93 154.41,115.37 155.53,114.24 155.53,112.85 155.66,112.73 155.66,109.32 156.12,108.87 156.12,108.55 158.57,106.1 158.57,102.76 159,102.33 159,100.65 159.93,99.72 v2(159.93,99.37)
  BOTTOM w0.102: v2(177.46,166.62) 176.95,166.11 JDOCK1.111
D_DLDRQ1#: length 92.4
  TOP w0.102: RP5.1 159.41,98.43 159.99,97.85 v2(159.99,97.84) ; U37.B24 163.79,98.59 v2(164.31,99.11)
  IN3 w0.102: v2(177.46,165.98) 177.9,165.54 177.9,165.09 177.65,164.84 175.85,164.84 175.47,165.22 169.55,165.22 166.3,161.96 166.3,146.82 167.8,145.31 167.8,131.54 165.76,129.5 165.76,126.52 165.15,125.91 165.15,117.05 166.94,115.26 166.94,107.97 166.6,107.63 166.6,106.55 166.07,106.02 165.35,106.02 164.27,104.95 164.27,102.28 164.65,101.9 164.65,100.48 164.86,100.27 164.86,99.3 164.68,99.11 v2(164.31,99.11)
  BOTTOM w0.102: JDOCK1.117 178.45,164.99 v2(177.46,165.98) ; v2(159.99,97.84) 160.4,97.43 162,97.43 163.17,98.61 163.8,98.61 v2(164.31,99.11)
D_LAD0: length 80.1
  TOP w0.102: U37.B29 163.56,96.09 v2(163.6,96.13)
  IN3 w0.102: v2(163.6,96.13) 163.24,96.48 163.24,97.19 163.5,97.44 164.82,97.44 165.17,97.79 165.17,99.75 165.67,100.26 165.67,101.56 164.58,102.66 164.58,104.82 165.48,105.72 166.2,105.72 166.93,106.44 166.93,107.53 167.25,107.85 167.25,115.28 165.38,117.14 165.38,120.51 165.52,120.64 165.52,125.88 165.99,126.35 165.99,129.41 168.03,131.45 168.03,145.41 166.53,146.91 166.53,158.86 168.06,160.39 171.93,160.39 173.33,161.79 v2(173.33,162.23)
  BOTTOM w0.102: v2(173.33,162.23) 173.45,162.35 JDOCK1.97
D_LAD1: length 80.1
  TOP w0.102: U37.B28 163.97,96.59 v2(164.37,97)
  IN3 w0.102: v2(173.96,162.23) 173.96,161.98 172.06,160.07 168.19,160.07 166.75,158.64 166.75,147.18 168.26,145.67 168.26,131.35 166.22,129.31 166.22,126.26 165.74,125.78 165.74,120.55 165.61,120.42 165.61,117.35 167.55,115.41 167.55,107.72 167.23,107.4 167.23,106.29 166.22,105.27 165.47,105.27 164.88,104.69 164.88,102.78 165.98,101.69 165.98,100.28 166.19,100.07 166.19,97.37 165.81,97 v2(164.37,97)
  BOTTOM w0.102: v2(173.96,162.23) 173.95,162.25 JDOCK1.99
D_LAD2: length 92
  TOP w0.102: v2(160.63,97.84) 161.13,97.34 U37.A25
  IN3 w0.102: v2(160.63,97.84) 160.16,98.31 159.89,98.31 159.19,99.01 159.19,99.6 158.39,100.4 158.39,101.9 157.4,102.89 157.4,106.41 155.51,108.3 155.51,108.61 155.05,109.07 155.05,112.18 154.22,113.02 154.22,114.55 153.95,114.81 153.95,124.15 154.53,124.74 154.53,130.74 155.04,131.25 155.04,136.6 157.33,138.89 157.33,139.82 163.42,145.92 163.42,153.47 164.31,154.36 164.31,156.14 163.36,157.09 163.36,158.38 164.41,159.43 164.41,162.76 166.63,164.98 166.63,165.42 168.01,166.79 174.65,166.79 v2(175.55,167.69)
  BOTTOM w0.102: v2(175.55,167.69) 174.95,167.09 JDOCK1.103
D_LAD3: length 91
  TOP w0.102: v2(161.26,97.84) U37.A24
  IN3 w0.102: v2(161.26,97.84) 160.46,98.64 159.99,98.64 159.5,99.14 159.5,99.72 158.7,100.53 158.7,102.2 158.24,102.66 158.24,106 155.82,108.43 155.82,108.74 155.36,109.2 155.36,112.31 154.53,113.14 154.53,114.74 154.18,115.09 154.18,119.05 154.98,119.85 154.98,122.17 154.79,122.36 154.79,130.61 155.29,131.12 155.29,136.42 157.64,138.77 157.64,139.71 159.62,141.68 161.24,141.68 164.82,145.26 164.82,156.07 163.68,157.22 163.68,158.25 164.73,159.3 164.73,162.75 165.19,163.21 165.82,163.21 169.1,166.49 174.98,166.49 v2(175.55,167.06)
  BOTTOM w0.102: JDOCK1.105 175.45,166.96 v2(175.55,167.06)
D_LFRAME#: length 86.1
  TOP w0.102: v2(163.66,99.12) 163.63,99.09 U37.B23
  IN3 w0.102: v2(176.06,165.35) 175.87,165.54 169.44,165.54 165.77,161.87 165.77,144.92 161.62,140.77 160.21,140.77 159.1,139.66 159.1,132.2 162.41,128.9 162.41,126.36 162.34,126.29 162.34,121.22 162.74,120.82 162.74,116.12 163.55,115.31 165.01,115.31 165.61,114.71 165.61,107.71 165.45,107.56 165.2,107.31 165.04,107.31 164.34,106.61 164.34,106.17 163.46,105.29 163.46,102.67 164.35,101.77 164.35,100.35 164.56,100.14 164.56,99.75 164.36,99.56 164.13,99.56 163.69,99.12 v2(163.66,99.12)
  BOTTOM w0.102: JDOCK1.109 176.45,164.95 v2(176.06,165.35)
D_SERIRQ: length 91.3
  TOP w0.102: RP5.2 160.19,98.93 160.55,99.29 v2(160.55,99.32) 161.07,99.84 U37.A20
  IN3 w0.102: v2(177.46,165.35) 176.92,165.88 169.35,165.88 165.54,162.07 165.54,159.21 164.31,157.97 164.31,157.48 165.45,156.34 165.45,145.03 161.49,141.07 159.88,141.07 158.28,139.48 158.28,138.65 155.8,136.18 155.8,130.8 155.29,130.29 155.29,122.61 156.37,121.53 156.37,120.51 154.67,118.81 154.67,115.57 155.76,114.48 155.76,112.95 155.97,112.74 155.97,109.45 156.43,108.99 156.43,108.68 158.88,106.23 158.88,102.89 159.31,102.46 159.31,100.78 160.55,99.53 v2(160.55,99.32)
  BOTTOM w0.102: v2(177.46,165.35) 177.95,164.85 JDOCK1.115
DAI_12MHZ#: length 35.3
  TOP w0.102: v2(170.41,162.61) 170.41,162.82 170.3,162.93 RE4.1
  BOTTOM w0.102: R137.1 v1(197.71,165.92) 193.31,165.92 189.71,162.32 187.3,162.32 186.38,161.41 171.36,161.41 170.41,162.36 v2(170.41,162.61) 170.45,162.66 JDOCK1.89
DAI_BCLK#: length 41.9
  TOP w0.102: v2(167.69,165.67) 167.69,164.8 RE5.1
  BOTTOM w0.102: R139.1 192.85,163.44 188.27,158.87 v1(173.14,158.87) 169.99,158.87 167.45,161.41 JDOCK1.77 167.45,164.89 167.69,165.14 v2(167.69,165.67)
DAI_DI: length 37.1
  BOTTOM w0.102: R144.1 193.05,164.65 188.01,159.61 v1(178.73,159.61) 171.13,159.61 168.95,161.79 JDOCK1.83
DAI_DO#: length 34.8
  BOTTOM w0.102: JDOCK1.85 169.45,163.12 169.33,163 169.33,162.04 171.41,159.97 185.98,159.97 187.93,161.92 189.81,161.92 193.18,165.28 v1(195.74,165.28) R141.1
DAI_LRCK#: length 36.4
  BOTTOM w0.102: R143.1 192.92,164.01 188.16,159.26 v1(176.06,159.26) 170.36,159.26 167.95,161.66 JDOCK1.79
DAT_DDC2_CRT: length 165
  TOP w0.102: v2(163.87,151.46) v1(163.31,151.46) U39.12
  IN3 w0.102: v2(313.28,159.19) 312.65,158.55 311.5,158.55 310.55,159.5 306.42,159.5 306.11,159.19 303.31,159.19 302.17,160.33 292.07,160.33 291.18,161.22 287,161.22 285.34,162.87 279.64,162.87 278.62,163.88 274.36,163.88 274.04,164.2 268.2,164.2 267.18,165.22 238.03,165.22 237.16,164.35 229.45,164.35 227.62,162.53 222.45,162.53 219.96,160.04 200.72,160.04 199.74,159.06 193.78,159.06 v2(193.08,158.36)
  BOTTOM w0.102: v2(163.87,151.46) 164.15,151.18 178.22,151.18 178.92,151.88 189.46,151.88 192.51,154.93 192.51,157.03 193.01,157.53 193.01,158.3 v2(193.08,158.36) ; JIO1.30 311.43,160.4 311.7,160.14 312.52,160.14 313.28,159.38 v2(313.28,159.19)
DAT_DDC2_DOCK: length 29.5
  TOP w0.102: v2(157.9,167.89) 157.99,167.97 157.99,168.36 157.93,168.42 157.55,168.42 157.4,168.27 157.4,163.94 158.15,163.19 158.15,159.82 158.53,159.44 162.98,159.44 163.74,158.68 163.74,157.28 164.38,156.65 164.38,152.2 164.12,151.95 163.31,151.95 163.23,151.86 U39.13
  BOTTOM w0.102: v2(157.9,167.89) 157.9,169.38 158.58,170.06 158.58,171.04 158.45,171.17 JDOCK1.46
DAT_KBD: length 78.9
  TOP w0.102: RP4.8 146.58,112.02 146.6,112.01 v2(146.6,111.95) ; U38.B41 146.14,108.04 v2(146.46,107.72)
  IN1 w0.097: v2(146.6,111.95) 146.13,111.95 145.87,111.69 145.87,109.23 146.46,108.64 v2(146.46,107.72)
  IN3 w0.102: v2(167.45,169.98) 167.04,169.98 166.22,169.16 166.22,168.44 164.33,166.55 163.61,166.55 162.94,165.88 162.94,164.05 160.64,161.75 159.5,161.75 158,160.26 158,157.89 156.69,156.58 156.69,155.19 156.37,154.87 156.37,150.18 155.87,149.68 155.87,141.22 153.21,138.56 153.21,132.07 152.7,131.56 152.7,130.36 151,128.66 151,122.34 146.77,118.11 145.78,118.11 144.73,117.06 144.73,114.71 144.82,114.62 144.82,113.78 146.6,112.01 v2(146.6,111.95)
  BOTTOM w0.102: v2(167.45,169.98) 167.89,170.41 167.89,170.98 167.95,171.05 JDOCK1.80
DAT_MSE: length 77.1
  TOP w0.102: RP4.5 v2(145.08,111.8) ; U38.B42 145.64,107.76 v2(145.65,107.75)
  IN1 w0.097: v2(145.65,107.75) 145.39,108.01 145.39,111.37 145.08,111.68 v2(145.08,111.8)
  IN3 w0.102: v2(162.23,165.98) 161.71,165.45 161.71,163.5 160.44,162.23 159.3,162.23 154.28,157.22 154.28,149.98 154.94,149.32 154.94,142.64 154.28,141.98 154.28,141.2 152.5,139.43 152.5,132.36 149.33,129.19 149.33,124.96 149.58,124.71 150.09,124.71 150.34,124.45 150.34,122.69 146.41,118.75 145.74,118.75 144.25,117.26 144.25,114.51 144.33,114.42 144.33,112.55 v2(145.08,111.8)
  BOTTOM w0.102: JDOCK1.73 166.45,165.81 165.65,166.62 162.87,166.62 v2(162.23,165.98)
DAT_TP_SIO: length 46.1
  TOP w0.102: v2(180.86,100.84) 180.68,101.02 180.68,101.13 180.82,101.27 181.25,101.27 R441.1 ; U38.B40 146.64,108.22 146.93,107.93 146.93,107.92 146.93,107.59 146.95,107.57 146.95,107.52 146.92,107.49 146.92,107.34 v2(146.5,106.93)
  BOTTOM w0.102: v2(180.86,100.84) 180.63,100.61 180.63,100.39 180.44,100.19 179.71,100.19 177.48,102.43 176.6,102.43 175.04,103.99 172.62,103.99 171.48,102.85 162.01,102.85 158.34,99.18 154.6,99.18 154.02,99.75 154.02,100.51 152.5,102.04 151.29,102.04 149.48,103.85 147.96,103.85 147.39,104.42 147.39,105.81 146.5,106.7 v2(146.5,106.93)
DC_BLOCK_GC: length 48
  TOP w0.254: v2(95.67,151.5) 96.65,151.5 96.8,151.65 PQ400.4 ; PU701.7 124.03,135.07 124.59,134.52 124.59,134.4 125.34,133.66 v1(125.34,132.95) 125.34,131.57 v2(125.2,131.43)
  IN3 w0.254: v2(95.67,151.5) 95.67,149.91 97.51,148.07 101,148.07 101.45,147.63 101.45,144.39 104.18,141.66 113.89,141.66 115.99,139.56 117.22,139.56 118.53,138.25 118.53,138.23 120.95,135.81 122.24,135.81 123.11,134.94 123.11,134.28 125.32,132.07 125.32,131.56 v2(125.2,131.43)
DC_IN_SS: length 2.2
  TOP w0.254: PU701.34 119.08,137.67 118.34,138.42 PR529.2
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: UC1.A3 107.06,66.08 UC1.B3
DC_TEST_A4: length 4.3
  BOTTOM w0.102: RC139.2 104.19,67.67 UC1.A4
DC_TEST_A60: length 8.9
  TOP w0.102: v2(102.05,28.93) 101.67,28.93 v1(101.23,29.38) 100.83,29.77 100.05,29.77 99.73,29.46 99.73,28.96 RC143.2
  BOTTOM w0.109: v2(102.05,28.93) 102.38,29.26 105.25,29.26 105.39,29.4 105.39,29.55 106.32,30.49 UC1.A60
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.076: UC1.A61 107.13,29.83 UC1.B61
DC_TEST_A62: length 9.2
  TOP w0.102: RC143.1 99.35,28.96 99.35,29.58 99.8,30.03 101.05,30.03 101.68,29.39 102.34,29.39 102.91,28.82 v1(104.42,28.82) 104.82,28.82 v2(105.07,28.57)
  BOTTOM w0.102: UC1.A62 106.31,29.18 105.7,28.57 v2(105.07,28.57)
DC_TEST_AV1: length 5.2
  BOTTOM w0.076: 129.58,69.84 129.58,69.78 128.69,68.89 128.4,68.89 128.05,68.54 128.05,67.67 127.85,67.47 UC1.AV1
  BOTTOM w0.102: RC145.2 129.58,70.81 129.58,69.84
DC_TEST_AW1: length 3.8
  BOTTOM w0.076: UC1.AW1 129.18,67.82 129.18,69.04 129.98,69.84
  BOTTOM w0.102: RC145.1 130.09,69.94 129.98,69.84
DC_TEST_AW63: length 8
  BOTTOM w0.102: v1(131.68,23.06) 131.63,23.11 RC141.2 132.13,24.87 132.13,26.33 129.87,28.59 UC1.AW63
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.076: UC1.AW2 129.05,66.55 UC1.AY2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: UC1.AW3 128.56,65.95 UC1.AY3
DC_TEST_AY60: length 7.6
  BOTTOM w0.102: UC1.AY60 129.17,30.47 129.57,30.06 129.57,29.46 v1(132.71,26.32) 132.71,24.53 RC141.1
DC_TEST_AY61_AW61: length 0.7
  BOTTOM w0.076: UC1.AW61 128.59,29.81 UC1.AY61
DC_TEST_AY62_AW62: length 0.7
  BOTTOM w0.076: UC1.AW62 128.6,29.15 UC1.AY62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.254: UC1.B62 107.26,28.72 UC1.B63
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.076: UC1.C1 107.79,67.09 UC1.C2
DDI1_LANE_N0: length 101.8
  TOP w0.102: v2(120.5,93.16) 120.64,93.02 121.26,93.02 121.36,93.12 121.36,93.7 C156.1
  IN1 w0.097: v2(120.5,93.16) 120.31,92.98 120.08,92.98 119.93,93.13 119.93,94.29 116.98,97.23 109.12,97.23 104.72,92.83 103.59,92.83 102.59,91.83 99.05,91.83 93.29,86.07 93.29,76.31 93.59,76.01 93.59,64.51 95.01,63.09 95.01,59.72 95.9,58.83 95.9,54.94 95.2,54.24 95.2,48.3 95.39,48.1 96.47,48.1 105.57,39 105.57,34.71 104.05,33.18 104.05,32.84 v2(103.91,32.69)
  BOTTOM w0.076: v2(103.91,32.69) 104.05,32.84 104.05,33.1 104.24,33.29 105.98,33.29 106.16,33.48 106.21,33.53 106.62,33.53 106.71,33.56 106.76,33.58 106.76,33.59 106.95,33.59 107.1,33.53 107.1,33.53 107.23,33.53 107.34,33.56 107.54,33.77 107.54,33.94 107.72,34.11 UC1.C54
DDI1_LANE_N0_C: length 6.6
  TOP w0.102: C156.2 121.36,95.1 121.36,95.42 121.49,95.54 121.49,97.82 121.47,97.83 121.47,98.36 121.49,98.38 121.49,98.84 120.94,99.38 120.94,99.7 120.73,99.91 120.73,100.52 U6.G2
DDI1_LANE_N1: length 99.4
  TOP w0.102: v2(117.26,93.15) 117.45,92.96 117.7,92.96 118.21,92.45 119.19,92.45 119.51,92.76 119.51,93.06 120.17,93.73 120.17,95.18 120.47,95.48 120.47,96.14 120.38,96.23 120.23,96.23 C158.1
  IN1 w0.097: v2(117.26,93.15) 117.07,92.96 116.62,92.96 115.78,93.8 114.48,93.8 113.19,92.51 108.22,92.51 106.37,90.66 104.34,90.66 102.78,89.1 100.16,89.1 97.06,86 97.06,84.69 95.82,83.46 95.82,77.77 96.09,77.51 96.09,66.46 98.89,63.66 98.89,56.91 101.26,54.54 101.26,47.61 107.43,41.44 107.43,32.11 105.68,30.36 104.21,30.36 104.12,30.46 104.12,30.56 104.42,30.86 v2(104.56,30.86)
  BOTTOM w0.076: UC1.B58 107.51,31.73 107.4,31.61 107.24,31.61 107.13,31.73 107.13,31.87 107.06,31.93 106.07,31.93 105.44,31.3 104.41,31.3 104.28,31.17 104.28,30.89 104.35,30.82 104.51,30.82 v2(104.56,30.86)
DDI1_LANE_N1_C: length 4.3
  TOP w0.102: C158.2 120.24,97.16 120.24,99.63 120.08,99.79 120.08,100.52 U6.F2
DDI1_LANE_N2: length 100.8
  TOP w0.102: C160.1 118.91,93.74 118.91,93.56 118.66,93.3 118.66,93.18 v2(118.44,92.96)
  IN1 w0.097: v2(101.96,32.69) 102.08,32.57 102.08,32.25 102.4,31.93 105.32,31.93 106.4,33.01 106.4,39.45 100.05,45.8 100.05,52.19 97.7,54.54 97.7,62.09 95.54,64.25 95.54,64.93 94.88,65.59 94.88,77.05 94.23,77.69 94.23,83.52 95.08,84.36 95.08,85.67 100.33,90.92 102.95,90.92 103.91,91.88 105.86,91.88 108.83,94.85 113.69,94.85 114.65,95.81 117.07,95.81 118.66,94.22 118.66,93.18 v2(118.44,92.96)
  BOTTOM w0.076: UC1.B55 107.19,34.09 106.97,34.3 106.96,34.3 106.94,34.29 106.29,34.29 105.77,33.77 102.85,33.77 102.17,33.09 102.17,32.91 v2(101.96,32.69)
DDI1_LANE_N2_C: length 6.5
  TOP w0.102: U6.E2 119.45,100.54 119.45,99.85 119.53,99.77 119.53,98.72 119.51,98.7 119.51,97.99 118.95,97.43 118.95,95.1 C160.2
DDI1_LANE_N3: length 99.6
  TOP w0.102: v2(117.17,93.83) 117.41,94.07 117.41,94.44 117.9,94.92 117.9,96.09 117.81,96.18 117.64,96.18 C162.1
  IN1 w0.097: v2(102.61,30.89) 102.48,30.89 102.19,31.19 102.19,31.27 102.26,31.34 105.71,31.34 106.99,32.62 106.99,41.2 100.77,47.42 100.77,54.34 98.4,56.71 98.4,63.43 95.59,66.24 95.59,77.33 95.35,77.57 95.35,83.66 96.58,84.89 96.58,86.19 100.16,89.78 102.78,89.78 104.18,91.18 106.18,91.18 108.02,93.02 112.93,93.02 114.99,95.09 116.73,95.09 117.36,94.46 117.36,94.01 117.19,93.83 v2(117.17,93.83)
  BOTTOM w0.076: v2(102.61,30.89) 102.47,30.89 102.15,31.2 102.15,31.33 102.49,31.67 105.21,31.67 106.28,32.75 106.56,32.75 106.68,32.63 106.68,32.53 106.59,32.44 UC1.A57
DDI1_LANE_N3_C: length 4.7
  TOP w0.102: C162.2 117.69,97.14 117.69,97.62 118.78,98.71 118.78,100.52 U6.D2
DDI1_LANE_P0: length 101.8
  TOP w0.102: v2(120.5,92.57) 120.73,92.8 121.35,92.8 121.58,93.03 121.58,94.04 121.64,94.1 121.85,94.1 C155.1
  IN1 w0.097: v2(120.5,92.57) 120.31,92.76 119.99,92.76 119.71,93.04 119.71,94.2 116.9,97.02 109.21,97.02 104.81,92.62 103.67,92.62 102.68,91.62 99.14,91.62 93.5,85.98 93.5,76.4 93.8,76.09 93.8,64.6 95.22,63.17 95.22,59.81 96.11,58.92 96.11,54.86 95.41,54.15 95.41,48.38 95.48,48.31 96.56,48.31 105.78,39.09 105.78,34.62 104.26,33.1 104.26,32.86 104.43,32.69 v2(104.56,32.69)
  BOTTOM w0.076: UC1.C55 107.56,33.5 107.41,33.41 107.26,33.36 107.07,33.36 107.04,33.38 106.92,33.42 106.81,33.42 106.64,33.36 106.28,33.36 106.04,33.13 104.31,33.13 104.21,33.03 104.21,32.91 104.43,32.69 v2(104.56,32.69)
DDI1_LANE_P0_C: length 6.4
  TOP w0.102: C155.2 121.85,94.69 121.66,94.69 121.58,94.77 121.58,95.33 121.7,95.45 v3(121.7,98.1) 121.7,98.93 121.16,99.47 121.16,99.79 120.95,100 120.95,100.09 U6.G1
DDI1_LANE_P1: length 99.7
  TOP w0.102: C157.1 120.69,95.74 120.69,95.39 120.38,95.09 120.38,93.64 119.72,92.97 119.72,92.67 119.28,92.23 118.12,92.23 117.61,92.74 117.44,92.74 v2(117.26,92.56)
  IN1 w0.097: v2(103.91,30.86) 103.91,30.37 104.12,30.15 105.76,30.15 107.64,32.03 107.64,41.53 101.47,47.7 101.47,54.63 99.1,57 99.1,63.75 96.3,66.54 96.3,77.6 96.03,77.86 96.03,83.37 97.27,84.61 97.27,85.91 100.25,88.89 102.87,88.89 104.43,90.45 106.46,90.45 108.3,92.29 113.28,92.29 114.57,93.59 115.69,93.59 116.54,92.74 117.08,92.74 v2(117.26,92.56)
  BOTTOM w0.076: v2(103.91,30.86) 104.11,31.07 104.11,31.23 104.34,31.46 105.37,31.46 106.03,32.12 107.33,32.12 107.38,32.18 107.63,32.18 107.93,31.88 UC1.C58
DDI1_LANE_P1_C: length 4.2
  TOP w0.102: C157.2 120.72,96.69 120.55,96.69 120.46,96.78 120.46,99.72 120.3,99.88 120.3,100.09 U6.F1
DDI1_LANE_P2: length 100.8
  TOP w0.102: C159.1 118.87,93.21 118.87,93.12 v2(119.02,92.96)
  IN1 w0.097: v2(119.02,92.96) 118.87,93.12 118.87,94.31 117.16,96.02 114.57,96.02 113.61,95.06 108.75,95.06 105.77,92.09 103.82,92.09 102.87,91.13 100.25,91.13 94.87,85.75 94.87,84.45 94.02,83.61 94.02,77.6 94.67,76.96 94.67,65.5 95.33,64.84 95.33,64.17 97.49,62.01 97.49,54.45 99.84,52.1 99.84,45.71 106.19,39.37 106.19,33.1 105.23,32.14 102.48,32.14 102.29,32.33 102.29,32.46 102.53,32.69 v2(102.61,32.69)
  BOTTOM w0.076: v2(102.61,32.69) 102.46,32.69 102.33,32.82 102.33,33.02 102.92,33.61 105.84,33.61 106.36,34.13 106.82,34.13 106.95,34 106.77,33.82 UC1.A55
DDI1_LANE_P2_C: length 6.4
  TOP w0.102: U6.E1 119.88,100.09 119.88,99.96 119.75,99.83 v3(119.75,98.43) 119.75,97.92 119.17,97.34 119.17,94.74 119.26,94.65 119.39,94.65 C159.2
DDI1_LANE_P3: length 99.9
  TOP w0.102: v2(117.76,93.83) 117.63,93.95 117.63,94.36 118.11,94.83 118.11,95.69 C161.1
  IN1 w0.097: v2(117.76,93.83) 117.57,94.02 117.57,94.55 116.82,95.3 114.9,95.3 112.84,93.23 107.94,93.23 106.09,91.39 104.09,91.39 102.7,89.99 100.08,89.99 96.37,86.28 96.37,84.98 95.13,83.75 95.13,77.48 95.38,77.24 95.38,66.15 98.19,63.34 98.19,56.62 100.56,54.25 100.56,47.34 106.78,41.11 106.78,32.7 105.62,31.55 102.17,31.55 101.98,31.36 101.98,30.91 v2(101.96,30.89)
  BOTTOM w0.076: UC1.B57 107.14,32.44 106.64,32.94 106.21,32.94 105.13,31.86 102.41,31.86 101.96,31.41 v2(101.96,30.89)
DDI1_LANE_P3_C: length 4.5
  TOP w0.102: U6.D1 119,100.09 119,98.62 117.91,97.53 117.91,96.76 117.99,96.68 118.19,96.68 C161.2
DDR3_DRAMRST#: length 22.1
  TOP w0.102: CD34.1 172.83,17.6 v2(173.01,17.78) 173.79,17.78 175.05,19.04 183.42,19.04 v1(184.34,18.12) 185.04,17.42 CD3.1 RC279.1 186.74,17.92 186.57,18.09 v2(186.15,18.09)
  BOTTOM w0.102: v2(173.01,17.78) 172.28,17.05 JDIMM2.30 ; JDIMM1.30 185.12,17.05 v2(186.15,18.09)
DDR3_DRAMRST#_CPU: length 116.2
  TOP w0.102: RC279.2 RD3.2 v2(187.63,15.89)
  IN3 w0.102: v2(187.63,15.89) 186.63,16.9 186.63,31.26 183.17,34.71 183.17,51.49 182.14,52.52 177.44,52.52 174.85,55.11 174.85,69.59 174.22,70.22 166.01,70.22 165.59,70.64 159.45,70.64 158.71,69.89 155.68,69.89 154.13,68.34 145.29,68.34 v2(144.8,67.86)
  BOTTOM w0.076: UC1.AV15 128.12,58.3 128.63,58.3 128.71,58.38 128.97,58.38 129.04,58.3 129.29,58.3 129.47,58.49 132.05,58.49 132.16,58.6 134.33,58.6 137.03,61.3
  BOTTOM w0.102: 137.03,61.3 138.69,61.3 144.8,67.41 v2(144.8,67.86)
DDR_A_BS0: length 62.9
  IN1 w0.076: 136.75,44.21 136.33,44.21 134.93,45.6 133.18,45.6 132.38,46.4 v2(131.75,46.4)
  IN1 w0.14: 136.75,44.21 151.09,44.21 151.22,44.08 151.22,43.91 151.34,43.79 154.45,43.79 154.58,43.66 154.58,43.35 154.71,43.22 155.1,43.22 155.23,43.35 155.23,44.57 155.36,44.69 155.75,44.69 155.88,44.57 155.88,43.35 156,43.22 156.4,43.22 156.52,43.35 156.52,44.5 156.65,44.63 157.05,44.63 157.17,44.5 157.17,43.99 157.3,43.86 157.69,43.86 157.82,43.99 157.82,44.57 158.01,44.76 158.28,44.76 158.47,44.57 158.47,44.4 158.66,44.21 169.82,44.21 170.09,43.94 170.47,43.94 170.6,43.81 170.6,43.5 170.72,43.37 171.22,43.37 171.35,43.5 171.35,43.81 171.48,43.94 171.87,43.94 172,43.81 172,43.5 172.12,43.37 172.52,43.37 172.65,43.5 172.65,43.81 172.77,43.94 173.17,43.94 173.29,43.81 173.29,43.56 173.48,43.37 174.51,43.37 174.68,43.53 174.68,43.77 174.84,43.93 175.23,43.93 175.36,43.81 175.36,43.5 175.49,43.37 175.87,43.37 175.99,43.5 175.99,43.81 176.12,43.93 v2(177.19,43.93)
  BOTTOM w0.076: UC1.AU35 127.36,46.17 127.42,46.17 127.69,45.91 129.41,45.91 129.43,45.93 131.29,45.93 v2(131.75,46.4)
  BOTTOM w0.152: v2(177.19,43.93) 177.19,43.54 176.8,43.15 JDIMM1.109
DDR_A_BS1: length 64.3
  IN1 w0.076: v2(131.35,46.79) 131.36,46.79 131.44,46.88 132.27,46.88 133.04,46.1 134.66,46.1 136.21,44.56 136.75,44.56
  IN1 w0.14: 136.75,44.56 149.56,44.56 149.69,44.69 149.69,44.98 149.88,45.17 150.15,45.17 150.34,44.98 150.34,44.75 150.53,44.56 150.8,44.56 150.99,44.75 150.99,44.98 151.18,45.17 151.44,45.17 151.63,44.98 151.63,44.5 151.76,44.37 152.15,44.37 152.28,44.5 152.28,44.98 152.47,45.17 152.74,45.17 152.93,44.98 152.93,44.27 153.06,44.14 153.45,44.14 153.58,44.27 153.58,44.98 153.77,45.17 154.03,45.17 154.22,44.98 154.22,44.27 154.35,44.14 154.75,44.14 154.87,44.27 154.87,45.04 155,45.17 158.75,45.17 159.34,44.58 169.95,44.58 170.23,44.29 176.74,44.29 176.8,44.36 180.57,44.36 v2(181,43.93)
  BOTTOM w0.076: UC1.AV35 128.16,46.07 129.34,46.07 129.37,46.11 130.67,46.11 v2(131.35,46.79)
  BOTTOM w0.152: v2(181,43.93) 182.08,42.85 JDIMM1.108
DDR_A_BS2: length 61.9
  IN1 w0.076: v2(129.45,42.01) 130.43,41.03 132.71,41.03 133.14,40.6 133.14,37.33 135.54,34.94 136.75,34.94
  IN1 w0.14: v2(178.71,33.41) 178.71,33 178.49,32.77 177.06,32.77 176.9,32.94 176.9,33.42 176.73,33.58 176.5,33.58 176.34,33.42 176.34,32.94 176.17,32.77 175.94,32.77 175.78,32.94 175.78,33.42 175.62,33.58 175.38,33.58 175.22,33.42 175.22,32.94 175.06,32.77 163.56,32.77 162.35,33.98 143.74,33.98 142.78,34.94 136.75,34.94
  BOTTOM w0.076: UC1.AY41 129.16,42.3 v2(129.45,42.01)
  BOTTOM w0.152: v2(178.71,33.41) 177.97,34.15 JDIMM1.79
DDR_A_CAS#: length 62.9
  IN1 w0.076: 136.75,45.8 136.15,45.8 135.34,46.61 133.24,46.61 132.36,47.49 127.94,47.49 127.51,47.06 v2(127.51,46.79)
  IN1 w0.14: 136.75,45.8 145.73,45.8 145.89,45.96 145.89,46.9 146.02,47.03 146.49,47.03 146.62,46.9 146.62,46.67 146.81,46.48 147.08,46.48 147.27,46.67 147.27,47.45 147.39,47.58 147.79,47.58 147.91,47.45 147.91,46.67 148.1,46.48 148.37,46.48 148.56,46.67 148.56,47.45 148.69,47.58 149.08,47.58 149.21,47.45 149.21,46.67 149.4,46.48 149.67,46.48 149.86,46.67 149.86,47.45 149.98,47.58 150.38,47.58 150.51,47.45 150.51,46.67 150.7,46.48 150.96,46.48 151.15,46.67 151.15,47.45 151.28,47.58 151.67,47.58 151.8,47.45 151.8,46.67 151.99,46.48 160.13,46.48 160.8,47.16 161.62,47.16 162.3,46.48 169.56,46.48 169.77,46.27 174.93,46.27 175.13,46.07 176.6,46.07 v2(177.17,45.49)
  BOTTOM w0.076: UC1.AU34 127.51,46.94 v2(127.51,46.79)
  BOTTOM w0.152: v2(177.17,45.49) 177.17,45.18 176.94,44.95 JDIMM1.115
DDR_A_D0: length 74.5
  IN1 w0.097: v2(177.44,9.24) 177.28,9.41 164.65,9.41 164.53,9.53 164.53,9.95 164.4,10.08 164.15,10.08 164.02,9.95 164.02,9.36 163.9,9.23 163.65,9.23 163.52,9.36 163.52,9.75 163.4,9.87 163.15,9.87 163.02,9.75 163.02,9.03 162.9,8.91 162.65,8.91 162.52,9.03 162.52,10.4 162.39,10.53 162.14,10.53 162.02,10.4 162.02,8.96 161.89,8.84 161.59,8.84 161.47,8.96 161.47,9.65 161.34,9.77 160.83,9.77 160.71,9.9 160.71,10.44 160.58,10.56 159.44,10.56 155.22,14.79 132.73,14.79 128.22,19.29 126.91,19.29 123.34,22.87 v2(123.34,23.12)
  BOTTOM w0.076: 122.15,25.9 122.15,26.03 121.94,26.23 121.94,28.2 121.81,28.33 UC1.AH63
  BOTTOM w0.102: JDIMM1.5 177.14,9.55 v2(177.44,9.24) ; 122.15,25.9 122.15,25.33 v1(123.13,24.34) 123.34,24.13 v2(123.34,23.12)
DDR_A_D1: length 75.3
  IN1 w0.097: v2(122.5,24.04) 123.09,24.04 127.22,19.91 128.03,19.91 132.85,15.09 155.34,15.09 159.56,10.86 162.78,10.86 163.26,10.38 164.91,10.38 165.59,9.71 170.07,9.71 170.17,9.8 170.17,10.29 170.3,10.42 170.55,10.42 170.67,10.29 170.67,9.8 170.77,9.71 171.08,9.71 171.18,9.8 171.18,10.29 171.3,10.42 171.55,10.42 171.68,10.29 171.68,9.8 171.78,9.71 172.09,9.71 172.18,9.8 172.18,10.21 172.31,10.34 172.56,10.34 172.69,10.21 172.69,9.8 172.78,9.71 178.32,9.71 178.78,9.24 v2(178.97,9.24)
  BOTTOM w0.076: UC1.AH62 121.61,29.04 121.61,28.83 121.52,28.66 121.52,28.39 121.78,28.13 121.78,25.9
  BOTTOM w0.102: JDIMM1.7 178.06,10.15 178.96,9.24 v2(178.97,9.24) ; 121.78,25.9 121.78,25.26 122.5,24.54 v2(122.5,24.04)
DDR_A_D2: length 73.7
  IN1 w0.097: v2(126.49,24.21) 126.49,23.65 127.95,22.19 129.4,22.19 133.4,18.19 134.02,18.19 134.26,17.94 141.21,17.94 141.67,17.49 156.8,17.49 160.86,13.42 174.14,13.42 174.24,13.33 174.24,12.94 174.36,12.82 174.61,12.82 174.74,12.94 174.74,13.33 174.83,13.42 175.14,13.42 175.24,13.33 175.24,12.82 175.37,12.69 175.62,12.69 175.74,12.82 175.74,13.33 175.84,13.42 176.15,13.42 176.25,13.33 176.25,12.82 176.37,12.69 176.62,12.69 176.75,12.82 176.75,13.17 176.88,13.3 177.12,13.3 177.25,13.17 177.25,12.94 177.37,12.82 177.62,12.82 177.75,12.94 177.75,13.17 177.88,13.3 178.13,13.3 178.25,13.17 178.25,12.92 178.38,12.8 178.66,12.8 178.79,12.92 178.79,13.17 178.91,13.3 179.23,13.3 179.36,13.17 179.36,12.52 179.23,12.39 v2(179.22,12.39)
  BOTTOM w0.076: 123.61,25.9 123.61,26.72 123.54,26.79 123.54,27.95 123.29,28.19 123.29,28.46 UC1.AK63
  BOTTOM w0.102: 123.61,25.9 123.61,25.71 125.1,24.21 v2(126.49,24.21) ; v2(179.22,12.39) 178.69,11.87 177.45,11.87 176.77,12.55 JDIMM1.15
DDR_A_D3: length 74.4
  IN1 w0.097: v2(177.7,12.39) 174.27,12.39 174.09,12.57 173.59,12.57 173.46,12.7 173.46,13 173.34,13.12 173.06,13.12 172.96,13.03 172.96,12.7 172.83,12.57 172.59,12.57 172.46,12.7 172.46,13.03 172.36,13.12 172.05,13.12 171.96,13.03 171.96,12.44 171.83,12.31 171.58,12.31 171.45,12.44 171.45,13.03 171.36,13.12 171.05,13.12 170.95,13.03 170.95,12.39 170.82,12.26 170.57,12.26 170.45,12.39 170.45,13.03 170.35,13.12 170.04,13.12 169.94,13.03 169.94,12.39 169.82,12.26 169.57,12.26 169.44,12.39 169.44,13.03 169.34,13.12 169.03,13.12 168.94,13.03 168.94,12.84 168.81,12.71 168.56,12.71 168.43,12.84 168.43,13.03 168.34,13.12 168.03,13.12 167.93,13.03 167.93,12.84 167.8,12.71 167.56,12.71 167.43,12.84 167.43,13.03 167.33,13.12 167.02,13.12 166.93,13.03 166.93,12.81 166.83,12.71 166.52,12.71 166.42,12.81 166.42,13 166.3,13.12 166.05,13.12 165.92,13 165.92,12.84 165.79,12.71 165.54,12.71 165.42,12.84 165.42,13 165.29,13.12 165.04,13.12 164.91,13 164.91,12.84 164.79,12.71 164.54,12.71 164.41,12.84 164.41,13 164.28,13.12 160.73,13.12 158.02,15.83 158.02,15.84 156.68,17.19 141.54,17.19 141.08,17.64 134.14,17.64 133.89,17.89 133.27,17.89 129.27,21.89 127.83,21.89 125.57,24.14 125.57,24.37 v2(125.96,24.76)
  BOTTOM w0.076: UC1.AK62 123.17,29 123.46,28.71 123.46,28.26 123.7,28.01 123.7,26.86 123.97,26.58 123.97,25.9
  BOTTOM w0.102: 123.97,25.9 123.97,25.78 125,24.76 v2(125.96,24.76) ; JDIMM1.17 176.94,13.15 v2(177.7,12.39)
DDR_A_D4: length 76
  IN1 w0.097: v2(121.93,24.48) 121.93,23.82 126.76,19 128.1,19 133.19,13.9 155.68,13.9 161.04,8.54 168.96,8.54 169.26,8.84 170.03,8.84 170.12,8.74 170.12,8.44 170.25,8.31 170.5,8.31 170.63,8.44 170.63,8.74 170.72,8.84 181.61,8.84 v2(182.02,9.24)
  BOTTOM w0.076: UC1.AH61 121.43,29.5 121.43,28.84 121.36,28.7 121.36,28.32 121.6,28.07 121.6,27.13 121.45,26.98 121.45,25.9
  BOTTOM w0.102: v2(121.93,24.48) 121.92,24.48 121.45,24.96 v1(121.45,25.51) 121.45,25.9 ; v2(182.02,9.24) 182.01,9.25 JDIMM1.4
DDR_A_D5: length 76.7
  IN1 w0.076: v2(122.84,25.26) 122.84,24.77 123.06,24.56
  IN1 w0.097: 123.06,24.56 123.06,24.5 127.34,20.21 128.15,20.21 132.98,15.38 155.47,15.38 159.69,11.16 163.05,11.16 163.53,10.68 165.04,10.68 165.71,10.01 168.77,10.01 168.87,10.11 168.87,10.59 168.99,10.72 169.24,10.72 169.37,10.59 169.37,10.34 169.5,10.21 169.74,10.21 169.87,10.34 169.87,10.59 170,10.72 172.86,10.72 172.99,10.59 172.99,10.14 173.11,10.01 178.53,10.01 178.89,9.65 180.08,9.65 180.49,9.24 v2(180.49,9.24)
  BOTTOM w0.076: UC1.AH60 122.58,30.54 122.78,30.33 122.78,30.09 122.77,30.08 122.77,29.7 122.78,29.68 122.78,29.49 122.77,29.48 122.71,29.34 122.71,29.13 122.78,28.98 122.78,28.85 122.73,28.74 122.71,28.69 122.71,28.4 122.96,28.14 122.96,28.05 123.19,27.82 123.19,25.9
  BOTTOM w0.102: v2(180.49,9.24) 180.49,9.24 181.11,9.85 JDIMM1.6 ; 123.19,25.9 123.19,25.61 v2(122.84,25.26)
DDR_A_D6: length 75.6
  IN1 w0.097: v2(127.35,23.36) 128.23,22.49 129.52,22.49 133.52,18.49 134.14,18.49 134.39,18.24 141.33,18.24 141.79,17.79 156.93,17.79 160.99,13.72 161.92,13.72 162.04,13.85 162.04,14.39 162.16,14.51 162.42,14.51 162.55,14.38 162.55,13.85 162.67,13.72 162.92,13.72 163.05,13.85 163.05,14.39 163.17,14.51 163.42,14.51 163.55,14.38 163.55,13.85 163.68,13.72 169.11,13.72 169.2,13.82 169.2,14.05 169.33,14.17 169.58,14.17 169.7,14.05 169.7,13.82 169.8,13.72 170.11,13.72 170.21,13.82 170.21,14.05 170.33,14.17 170.58,14.17 170.71,14.05 170.71,13.82 170.81,13.72 171.12,13.72 171.21,13.82 171.21,14.05 171.34,14.17 171.59,14.17 171.72,14.05 171.72,13.82 171.81,13.72 177.06,13.72 177.18,13.6 181.5,13.6 182.27,12.83 v2(182.27,12.39)
  BOTTOM w0.076: 124.19,24.61 123.37,25.43 123.37,27.88 123.13,28.12 123.13,28.21 122.87,28.46 122.87,28.65 122.92,28.76 122.95,28.81 122.95,29.01 122.92,29.07 122.88,29.16 122.87,29.17 122.87,29.3 122.9,29.35 122.92,29.41 123.06,29.54 UC1.AK61
  BOTTOM w0.102: v2(127.35,23.36) 125.45,23.36 124.19,24.61 ; v2(182.27,12.39) 182.73,12.85 JDIMM1.16
DDR_A_D7: length 75.6
  IN1 w0.097: v2(180.75,12.39) 181,12.39 181.12,12.27 181.12,11.95 181,11.83 180.21,11.83 180.08,11.96 174.27,11.96 173.97,12.27 172.21,12.27 171.9,11.96 169.37,11.96 168.93,12.41 164.25,12.41 164.13,12.54 164.13,12.7 164,12.82 163.75,12.82 163.62,12.7 163.62,12.54 163.5,12.41 163.25,12.41 163.12,12.54 163.12,12.7 162.99,12.82 162.75,12.82 162.62,12.7 162.62,12.54 162.49,12.41 162.24,12.41 162.12,12.54 162.12,12.7 161.99,12.82 161.74,12.82 161.61,12.7 161.61,12.54 161.49,12.41 161.18,12.41 161.05,12.54 161.05,12.7 160.92,12.82 160.6,12.82 156.54,16.89 141.25,16.89 140.8,17.34 138.43,17.34 137.72,16.63 134.52,16.63 133.81,17.33 133.81,17.34 133.58,17.58 133.57,17.58 133.56,17.59 133.15,17.59 129.15,21.59 127.71,21.59 125,24.29 v2(125,25.77)
  BOTTOM w0.076: 124.3,25.9 124.16,26.05 124.16,26.7 123.87,26.99 123.87,28.08 123.62,28.33 123.62,28.78 123.46,28.94 123.46,29.36 123.33,29.48 123.33,29.75 123.35,29.77 123.35,30.01 123.06,30.3 UC1.AK60
  BOTTOM w0.102: v2(180.75,12.39) 181.8,13.45 JDIMM1.18 ; v2(125,25.77) 124.43,25.77 124.3,25.9
DDR_A_D8: length 70.9
  IN1 w0.097: v2(179.22,14.81) 178.82,14.4 177.53,14.4 176.96,14.98 164.09,14.98 163.76,15.31 163.12,15.31 163.03,15.41 163.03,15.7 162.93,15.8 162.62,15.8 162.52,15.7 162.52,15.41 162.43,15.31 161.53,15.31 161.39,15.17 160.79,15.17 157.37,18.59 143.38,18.59 142.82,19.14 136.23,19.14 135.93,19.44 135.93,20.34 135.8,20.47 135.55,20.47 135.42,20.34 135.42,19.44 135.33,19.35 135.02,19.35 134.92,19.44 134.92,20.34 134.79,20.47 134.55,20.47 134.42,20.34 134.42,19.55 134.29,19.42 134.04,19.42 133.92,19.55 133.92,20.34 133.79,20.47 132.68,20.47 129.85,23.29 128.61,23.29 126.83,25.06 v2(126.83,25.64)
  BOTTOM w0.076: 126.08,25.9 125.83,26.15 125.42,26.15 124.37,27.2 124.37,28.28 124.24,28.41 UC1.AM63
  BOTTOM w0.102: v2(179.22,14.81) 178.77,14.35 JDIMM1.21 ; v2(126.83,25.64) 126.34,25.64 126.08,25.9
DDR_A_D9: length 72.1
  IN1 w0.097: v2(177.7,14.81) 177.63,14.81 177.16,15.28 164.22,15.28 163.4,16.09 162.13,16.09 162.03,16 162.03,15.71 161.94,15.61 161.63,15.61 161.53,15.71 161.53,16 161.43,16.09 160.4,16.09 157.61,18.89 151.59,18.89 151.44,19.03 151.44,19.42 151.29,19.57 151.08,19.57 150.94,19.42 150.94,19.03 150.79,18.89 150.58,18.89 150.43,19.03 150.43,19.42 150.29,19.57 150.08,19.57 149.93,19.42 149.93,19.03 149.78,18.89 149.58,18.89 149.43,19.03 149.43,19.42 149.28,19.57 149.07,19.57 148.92,19.42 148.92,19.03 148.78,18.89 148.57,18.89 148.42,19.03 148.42,19.42 148.27,19.57 148.07,19.57 147.92,19.42 147.92,19.03 147.77,18.89 147.56,18.89 147.42,19.03 147.42,19.42 147.27,19.57 147.06,19.57 146.91,19.42 146.91,19.03 146.77,18.89 146.56,18.89 146.41,19.03 146.41,19.42 146.26,19.57 146.05,19.57 145.91,19.42 145.91,19.03 145.76,18.89 145.55,18.89 145.4,19.03 145.4,19.42 145.26,19.57 145.05,19.57 144.9,19.42 144.9,19.03 144.75,18.89 144.55,18.89 144.4,19.03 144.4,19.42 144.25,19.57 144.04,19.57 143.9,19.42 143.9,19.03 143.75,18.89 143.54,18.89 143.39,19.03 143.39,19.39 143.2,19.57 137.42,19.57 136.22,20.77 132.8,20.77 129.98,23.59 129.03,23.59 128.26,24.36 v2(128.23,24.36)
  BOTTOM w0.076: 125.65,25.9 125.44,25.9 124.21,27.13 124.21,28.21 123.95,28.46 123.95,28.71 124.24,29 UC1.AM62
  BOTTOM w0.102: v2(177.7,14.81) 177.55,14.95 JDIMM1.23 ; v2(128.23,24.36) 127.19,24.36 125.65,25.9
DDR_A_D10: length 70.1
  IN1 w0.097: v2(128.48,26.4) 129.76,26.4 133.54,22.63 137.09,22.63 138.28,21.43 144.97,21.43 145.1,21.56 145.1,21.96 145.23,22.09 145.48,22.09 145.6,21.96 145.6,21.56 145.73,21.43 145.98,21.43 146.11,21.56 146.11,22.5 146.23,22.63 146.48,22.63 146.61,22.5 146.61,21.56 146.74,21.43 146.99,21.43 147.11,21.56 147.11,22.5 147.24,22.63 147.49,22.63 147.62,22.5 147.62,21.56 147.74,21.43 147.99,21.43 148.12,21.56 148.12,22.5 148.25,22.63 148.49,22.63 148.62,22.5 148.62,21.56 148.75,21.43 149,21.43 149.12,21.56 149.12,22.5 149.25,22.63 149.5,22.63 149.63,22.5 149.63,21.56 149.75,21.43 150,21.43 150.13,21.56 150.13,22.5 150.26,22.63 152.99,22.63 153.24,22.37 153.24,21.57 153.39,21.43 157.91,21.43 160.88,18.46 162.3,18.46 162.31,18.47 171.21,18.47 171.49,18.19 177.54,18.19 v2(177.7,18.03)
  BOTTOM w0.076: UC1.AP63 125.6,28.19 127.39,26.4 v2(128.48,26.4)
  BOTTOM w0.102: JDIMM1.33 177.62,17.95 v2(177.7,18.03)
DDR_A_D11: length 71.4
  IN1 w0.097: v2(179.22,18.03) 178.76,18.49 171.84,18.49 171.56,18.77 161,18.77 158.03,21.73 153.68,21.73 153.54,21.87 153.54,22.5 153.12,22.92 145.93,22.92 145.81,22.8 145.81,22.52 145.68,22.39 145.43,22.39 145.3,22.52 145.3,22.8 145.18,22.92 144.93,22.92 144.8,22.8 144.8,21.86 144.67,21.73 144.43,21.73 144.3,21.86 144.3,22.8 144.17,22.92 143.92,22.92 143.8,22.8 143.8,21.86 143.67,21.73 143.42,21.73 143.29,21.86 143.29,22.8 143.17,22.92 142.92,22.92 142.79,22.8 142.79,21.86 142.66,21.73 142.41,21.73 142.29,21.86 142.29,22.8 142.16,22.92 141.91,22.92 141.78,22.8 141.78,21.86 141.66,21.73 138.41,21.73 137.21,22.92 133.66,22.92 129.8,26.79 v2(128.08,26.79)
  BOTTOM w0.076: UC1.AP62 125.6,29 125.89,28.71 125.89,28.13 127.23,26.79 v2(128.08,26.79)
  BOTTOM w0.102: JDIMM1.35 178.7,18.55 v2(179.22,18.03)
DDR_A_D12: length 72.2
  IN1 w0.076: 125.57,25.9 125.57,25.96 125.26,26.28 v2(124.56,26.28)
  IN1 w0.097: v2(180.75,14.81) 180.95,14.81 181.08,14.68 181.08,14.23 180.95,14.1 177.39,14.1 177.26,14.23 176.76,14.23 176.63,14.35 176.63,14.55 176.5,14.68 176.25,14.68 176.12,14.55 176.12,14.35 175.99,14.23 175.74,14.23 175.62,14.35 175.62,14.58 175.52,14.68 175.21,14.68 175.11,14.58 175.11,14.35 174.99,14.23 174.74,14.23 174.61,14.35 174.61,14.58 174.51,14.68 173.31,14.68 173.21,14.58 173.21,14.35 173.08,14.23 172.84,14.23 172.71,14.35 172.71,14.58 172.61,14.68 163.97,14.68 163.63,15.01 161.71,15.01 161.57,14.88 160.66,14.88 157.25,18.29 142,18.29 141.58,18.71 141.54,18.75 134.59,18.75 134.35,18.99 133.73,18.99 129.73,22.99 128.48,22.99 125.57,25.9
  BOTTOM w0.076: UC1.AM61 124.35,29.76 123.95,29.36 123.95,28.94 123.79,28.78 123.79,28.4 124.04,28.14 124.04,27.05 124.32,26.77 124.32,26.52 v2(124.56,26.28)
  BOTTOM w0.102: v2(180.75,14.81) 181.18,14.37 182.69,14.37 182.97,14.65 JDIMM1.22
DDR_A_D13: length 73.5
  IN1 w0.097: 164.34,15.58 177.3,15.58 177.67,15.21 181.87,15.21 v2(182.27,14.81) ; 163.52,16.4 160.53,16.4 157.7,19.22 157.22,19.22 157.08,19.37 157.08,19.77 156.93,19.92 156.72,19.92 156.57,19.77 156.57,19.37 156.43,19.22 156.22,19.22 156.07,19.37 156.07,19.77 155.92,19.92 155.72,19.92 155.57,19.77 155.57,19.37 155.42,19.22 155.21,19.22 155.07,19.37 155.07,19.77 154.92,19.92 154.71,19.92 154.56,19.77 154.56,19.37 154.42,19.22 154.21,19.22 154.06,19.37 154.06,19.77 153.91,19.92 153.7,19.92 153.56,19.77 153.56,19.37 153.41,19.22 153.2,19.22 153.05,19.37 153.05,19.77 152.91,19.92 152.7,19.92 152.55,19.77 152.55,19.37 152.4,19.22 152.2,19.22 152.05,19.37 152.05,19.62 151.79,19.88 137.53,19.88 136.35,21.07 132.92,21.07 130.1,23.89 129.35,23.89 127.97,25.26 v2(127.32,25.26)
  IN1 w0.102: 164.34,15.58 163.52,16.4
  BOTTOM w0.076: UC1.AM60 125.01,30.54 125.21,30.33 125.21,29.49 125.2,29.48 125.16,29.39 125.14,29.34 125.14,29.13 125.21,28.98 125.21,28.85 125.14,28.69 125.14,28.18 127.13,26.19 127.13,26.09 127.32,25.9
  BOTTOM w0.102: JDIMM1.24 182.71,15.25 v2(182.27,14.81) ; 127.32,25.9 v2(127.32,25.26)
DDR_A_D14: length 71.5
  IN1 w0.097: v2(182.27,18.03) 181.57,17.33 171.92,17.33 171.09,18.16 160.75,18.16 157.78,21.13 153.07,21.13 152.94,21.26 152.94,22.2 152.82,22.33 152.57,22.33 152.44,22.2 152.44,21.28 152.31,21.16 152.07,21.16 151.94,21.28 151.94,22.2 151.81,22.33 151.56,22.33 151.44,22.2 151.44,21.28 151.31,21.16 151.06,21.16 150.93,21.28 150.93,22.2 150.81,22.33 150.56,22.33 150.43,22.2 150.43,21.26 150.3,21.13 138.16,21.13 136.97,22.33 133.42,22.33 130.22,25.52 v2(129.38,25.52)
  BOTTOM w0.076: 128.18,25.9 127.92,26.15 127.4,26.15 125.3,28.25 125.3,28.65 125.35,28.76 125.38,28.81 125.38,29.01 125.35,29.07 125.35,29.07 125.31,29.16 125.3,29.17 125.3,29.3 125.35,29.41 125.6,29.65 UC1.AP61
  BOTTOM w0.102: JDIMM1.34 182.49,18.25 v2(182.27,18.03) ; v2(129.38,25.52) 128.55,25.52 128.18,25.9
DDR_A_D15: length 72.4
  IN1 w0.097: v2(180.75,18.03) 179.98,18.79 171.96,18.79 171.61,19.14 162.42,19.14 161.7,19.87 160.54,19.87 158.37,22.03 154.43,22.03 153.24,23.22 141.61,23.22 141.48,23.1 141.48,22.16 141.36,22.03 141.11,22.03 140.98,22.16 140.98,23.1 140.85,23.22 140.61,23.22 140.48,23.1 140.48,22.16 140.35,22.03 140.1,22.03 139.98,22.16 139.98,23.1 139.85,23.22 139.6,23.22 139.47,23.1 139.47,22.16 139.35,22.03 139.1,22.03 138.97,22.16 138.97,23.1 138.84,23.22 138.59,23.22 138.47,23.1 138.47,22.6 138.34,22.47 138.09,22.47 137.96,22.6 137.96,23.1 137.84,23.22 133.79,23.22 129.82,27.19 v2(127.69,27.19)
  BOTTOM w0.076: v2(127.69,27.19) 127.07,27.19 126.05,28.2 126.05,28.78 125.89,28.94 125.89,29.36 125.88,29.37 125.88,29.76 125.89,29.77 125.89,30.01 125.6,30.3 UC1.AP60
  BOTTOM w0.102: v2(180.75,18.03) 181.57,18.85 JDIMM1.36
DDR_A_D16: length 64.6
  IN1 w0.097: v2(130.96,28.88) 130.96,28.24 132.99,26.21 133.04,26.21 133.67,25.58 134.02,25.58 134.15,25.45 134.15,25.14 134.27,25.01 134.59,25.01 134.72,25.14 134.72,25.45 134.85,25.58 135.21,25.58 135.33,25.45 135.33,24.63 135.46,24.5 135.71,24.5 135.84,24.63 135.84,25.45 135.96,25.58 136.27,25.58 136.4,25.45 136.4,24.5 136.52,24.37 136.77,24.37 136.9,24.5 136.9,25.45 137.03,25.58 137.28,25.58 137.4,25.45 137.4,24.5 137.53,24.37 137.78,24.37 137.91,24.5 137.91,24.93 138.05,25.07 138.26,25.07 138.41,24.93 138.41,24.45 138.54,24.33 138.79,24.33 138.91,24.45 138.91,24.93 139.06,25.07 139.27,25.07 139.42,24.93 139.42,24.45 139.54,24.33 157.76,24.33 160.2,21.89 162.07,21.89 163.09,20.86 169.24,20.86 169.76,20.35 177.67,20.35 v2(177.7,20.31)
  BOTTOM w0.076: UC1.AY58 129.28,31.66 129.97,31.66 130.96,30.66 v2(130.96,28.88)
  BOTTOM w0.102: JDIMM1.39 177.14,19.75 v2(177.7,20.31)
DDR_A_D17: length 65.9
  IN1 w0.097: v2(130.6,29.31) 130.46,29.17 130.46,28.38 133.06,25.78 133.06,25.76 134.79,24.03 155.7,24.03 155.83,23.9 155.83,22.96 155.96,22.83 156.21,22.83 156.33,22.96 156.33,23.9 156.46,24.03 156.73,24.03 156.86,23.9 156.86,22.96 156.98,22.83 157.23,22.83 157.33,22.93 157.33,23.69 157.46,23.82 157.8,23.82 157.92,23.69 157.92,22.99 158.05,22.86 158.8,22.86 160.29,21.37 162.16,21.37 162.28,21.25 162.28,20.67 162.41,20.54 169.13,20.54 169.63,20.05 176.88,20.05 177.02,19.91 178.82,19.91 v2(179.22,20.31)
  BOTTOM w0.076: v2(130.6,29.31) 130.59,29.33 130.59,30.69 129.79,31.48 128.81,31.48 UC1.AW58
  BOTTOM w0.102: JDIMM1.41 176.66,20.35 177.14,20.83 178.7,20.83 v2(179.22,20.31)
DDR_A_D18: length 64.6
  IN1 w0.076: 136.75,27.33 134.39,27.33 131.73,29.99 131.73,30.72 131.03,31.43 v2(131.03,31.94)
  IN1 w0.097: 136.75,27.33 136.8,27.39 138.6,27.39 139.05,26.94 147.17,26.94 147.3,26.81 147.3,26.41 147.45,26.26 147.66,26.26 147.8,26.41 147.8,26.81 147.93,26.94 148.18,26.94 148.31,26.81 148.31,26.41 148.45,26.26 148.66,26.26 148.81,26.41 148.81,26.81 148.94,26.94 149.21,26.94 149.33,26.81 149.33,26.39 149.46,26.26 149.71,26.26 149.84,26.39 149.84,26.81 149.96,26.94 150.21,26.94 150.34,26.81 150.34,26.41 150.49,26.26 150.69,26.26 150.84,26.41 150.84,26.81 150.97,26.94 151.22,26.94 151.34,26.81 151.34,26.41 151.49,26.26 151.7,26.26 151.85,26.41 151.85,26.81 151.97,26.94 152.22,26.94 152.35,26.81 152.35,26.41 152.5,26.26 152.71,26.26 152.85,26.41 152.85,26.81 152.98,26.94 153.23,26.94 153.36,26.81 153.36,26.41 153.5,26.26 153.71,26.26 153.86,26.41 153.86,26.68 153.99,26.81 154.21,26.81 154.36,26.66 154.36,26.41 154.51,26.26 154.72,26.26 154.86,26.41 154.86,26.66 155.01,26.81 155.22,26.81 155.37,26.66 155.37,26.41 155.52,26.26 155.72,26.26 155.87,26.41 155.87,26.66 156.02,26.81 156.23,26.81 156.37,26.66 156.37,26.41 156.52,26.26 158.37,26.26 160.81,23.82 170.93,23.82 171.74,23.01 177.35,23.01 v2(177.7,23.36)
  BOTTOM w0.076: UC1.AY56 129.34,33.13 129.36,33.11 130.35,33.11 131.03,32.43 v2(131.03,31.94)
  BOTTOM w0.102: v2(177.7,23.36) 177.69,23.35 JDIMM1.51
DDR_A_D19: length 66.8
  IN1 w0.076: v2(131.9,31.07) 131.9,30.06 134.32,27.63 136.69,27.63 136.75,27.68
  IN1 w0.097: 136.75,27.68 138.73,27.68 139.17,27.24 154.25,27.24 154.38,27.37 154.38,27.65 154.51,27.78 154.76,27.78 154.88,27.65 154.88,27.37 155.01,27.24 155.3,27.24 155.42,27.36 155.42,27.65 155.55,27.78 155.8,27.78 155.92,27.65 155.92,27.23 156.05,27.11 156.3,27.11 156.43,27.23 156.43,27.65 156.55,27.78 156.8,27.78 156.93,27.65 156.93,26.73 157.08,26.59 157.28,26.59 157.43,26.73 157.43,27.44 157.56,27.57 157.81,27.57 157.93,27.44 157.93,26.73 158.08,26.59 158.79,26.59 160.43,24.95 161.45,24.95 161.58,24.82 161.58,24.25 161.71,24.12 171.06,24.12 171.88,23.31 174.58,23.31 174.72,23.46 174.72,23.69 174.85,23.82 175.1,23.82 175.23,23.69 175.23,23.46 175.37,23.31 175.58,23.31 175.73,23.46 175.73,23.69 175.86,23.82 176.11,23.82 176.23,23.69 176.23,23.46 176.38,23.31 176.76,23.31 176.88,23.44 176.88,23.69 177.01,23.82 178.77,23.82 v2(179.22,23.36)
  BOTTOM w0.076: v2(131.9,31.07) 131.9,31.8 130.42,33.27 129.43,33.27 129.29,33.42 128.81,33.42 UC1.AW56
  BOTTOM w0.102: JDIMM1.53 178.63,23.95 v2(179.22,23.36)
DDR_A_D20: length 66.6
  IN1 w0.097: v2(133.18,26.74) 133.25,26.74 134.11,25.88 137.84,25.88 138.33,25.39 139.74,25.39 139.86,25.26 139.86,24.75 139.99,24.63 140.29,24.63 140.42,24.75 140.42,25.26 140.55,25.39 140.8,25.39 141.01,25.18 141.01,24.88 141.16,24.73 157.78,24.73 160.32,22.19 162.2,22.19 163.22,21.16 169.36,21.16 169.81,20.72 180.15,20.72 180.56,20.31 v2(180.75,20.31)
  BOTTOM w0.076: UC1.AV58 127.7,31.78 127.21,32.26 127.21,32.54 127.42,32.74 127.66,32.74 127.67,32.73 128.05,32.73 128.07,32.74 128.26,32.74 128.27,32.74 128.36,32.69 128.41,32.67 128.62,32.67 128.77,32.74 128.9,32.74 129.01,32.7 129.01,32.69 129.06,32.67 129.35,32.67 129.46,32.78 129.98,32.78 130.17,32.58 130.17,32.19 133.18,29.18 v2(133.18,26.74)
  BOTTOM w0.102: JDIMM1.40 182.85,20.05 182.5,19.71 181.35,19.71 v2(180.75,20.31)
DDR_A_D21: length 67
  IN1 w0.097: v2(182.27,20.31) 182.27,19.42 182.14,19.29 181.58,19.29 181.43,19.44 181.43,19.66 181.28,19.8 181.08,19.8 180.93,19.66 180.93,19.44 180.78,19.29 180.57,19.29 180.42,19.44 180.42,19.66 180.28,19.8 180.07,19.8 179.92,19.66 179.92,19.44 179.77,19.29 177.21,19.29 176.76,19.75 170.79,19.75 170.69,19.64 162.81,19.64 162.05,20.4 160.72,20.4 158.58,22.53 155.72,22.53 155.53,22.72 155.53,23.14 155.4,23.27 155.15,23.27 155.03,23.14 155.03,22.72 154.9,22.6 154.58,22.6 154.45,22.72 154.45,23.6 154.33,23.73 134.67,23.73 130.21,28.18 v2(130.21,29.71)
  BOTTOM w0.076: v2(130.21,29.71) 130.21,29.9 129.31,30.8 129.03,30.8 128.27,31.55 128.05,31.55 127.97,31.47 127.69,31.47 127.38,31.78 UC1.AU58
  BOTTOM w0.102: v2(182.27,20.31) 182.61,20.65 JDIMM1.42
DDR_A_D22: length 67
  IN1 w0.076: 136.75,27.09 136.69,27.03 134.45,27.03 131.57,29.92 131.57,30.53 130.56,31.54 v2(130.56,32.34)
  IN1 w0.097: v2(180.75,23.36) 180.09,22.71 170.8,22.71 170.71,22.81 170.71,23.24 170.61,23.33 170.3,23.33 170.2,23.24 170.2,22.81 170.08,22.68 164.03,22.68 163.19,23.52 160.69,23.52 158.25,25.96 147,25.96 146.85,26.11 146.85,26.45 146.71,26.6 146.5,26.6 146.35,26.45 146.35,26.11 146.2,25.96 146,25.96 145.85,26.11 145.85,26.45 145.7,26.6 145.49,26.6 145.34,26.45 145.34,26.11 145.2,25.96 144.99,25.96 144.84,26.11 144.84,26.45 144.69,26.6 144.49,26.6 144.34,26.45 144.34,26.11 144.19,25.96 143.98,25.96 143.84,26.11 143.84,26.45 143.69,26.6 143.48,26.6 143.33,26.45 143.33,26.11 143.19,25.96 142.98,25.96 142.83,26.11 142.83,26.45 142.68,26.6 138.97,26.6 138.48,27.09 136.75,27.09
  BOTTOM w0.076: v2(130.56,32.34) 130.56,32.66 130.28,32.94 129.39,32.94 129.29,32.84 129.1,32.84 128.99,32.88 128.97,32.91 128.74,32.91 128.68,32.88 128.59,32.84 128.58,32.84 128.45,32.84 128.4,32.86 128.34,32.89 128.21,33.02 UC1.AV56
  BOTTOM w0.102: v2(180.75,23.36) 181.23,22.87 182.41,22.87 182.59,23.05 JDIMM1.50
