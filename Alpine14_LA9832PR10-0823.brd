# Allegro board Alpine14_LA9832PR10-0823.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PBAT_SMBCLK: length 120.6
  TOP w0.102: PR3.2 100.38,169.04 v2(100.43,169.09) ; RP15.1 133.81,108.14 133.94,108.28 134.11,108.28 134.24,108.15 134.24,107.53 134.82,106.95 135.29,106.95 135.79,106.44 136.09,106.44 v3(136.72,105.81) 137.32,105.21 137.83,105.21 v2(138.15,104.89) 138.15,104.26 138.34,104.06 U38.A56
  IN3 w0.102: v2(138.15,104.89) 137.82,105.22 137.32,105.22 136.97,105.58 136.97,106.32 136.27,107.02 136.27,121 133.04,124.22 131.2,124.22 128.34,127.07 128.34,132.6 126.18,134.77 126.18,136.23 121.54,140.87 121.54,142.33 120.21,143.65 117.42,143.65 117.23,143.84 113.54,143.84 112.97,143.27 104.78,143.27 103.63,144.42 103.63,147.41 102.5,148.54 97.67,148.54 96.27,149.95 96.27,151.51 92.82,154.96 91.51,154.96 89.79,156.68 89.79,168.11 92.61,170.93 99.29,170.93 100.23,170 100.23,169.29 v2(100.43,169.09)
PBAT_SMBDAT: length 121.5
  TOP w0.102: v2(99.8,169.09) 100.38,169.68 PR5.2 ; U38.B59 141.14,104.31 v2(141.2,104.38) ; v2(138.15,105.53) 138.06,105.44 137.41,105.44 136.88,105.97 136.56,106.29 136.18,106.67 135.89,106.67 135.38,107.18 134.91,107.18 134.47,107.62 134.47,108.24 134.2,108.51 133.94,108.51 133.81,108.64 RP15.2
  IN3 w0.102: v2(99.8,169.09) 100,169.29 100,169.9 99.2,170.7 92.71,170.7 90.02,168.01 90.02,156.77 91.6,155.19 92.91,155.19 96.49,151.61 96.49,150.04 97.76,148.77 102.59,148.77 103.86,147.5 103.86,144.52 104.88,143.5 112.87,143.5 113.44,144.07 117.32,144.07 117.51,143.88 120.31,143.88 121.77,142.42 121.77,140.96 126.41,136.32 126.41,134.86 128.57,132.69 128.57,127.17 131.29,124.45 133.14,124.45 136.5,121.09 136.5,107.12 137.2,106.42 137.2,105.67 137.42,105.45 138.07,105.45 v2(138.15,105.53)
  BOTTOM w0.102: v2(138.15,105.53) 138.24,105.44 140.14,105.44 v2(141.2,104.38)
PBATT+_C:
  vias: v1(105.23,169.46) v3(107.42,170.04) v3(107.42,169.28) v3(107.42,168.52) v3(108.18,170.04) v3(108.18,169.28) v3(108.18,168.52) v3(108.94,170.04) v3(108.94,169.28) v3(108.94,168.52)
PC_BEEP: length 171.6
  TOP w0.102: R353.1 151.05,112.78 151.68,113.4 v1(152.03,113.4) v2(152.88,113.4)
  IN2 w0.102: v2(152.88,113.4) 154.26,112.02 154.26,106.3 154.91,105.66 156.69,105.66 157.26,106.23 163.87,106.23 164.88,107.24 166.76,107.24 167.93,108.41 167.93,109.91 169.52,111.5 173.33,111.5 173.46,111.62 173.46,113.66 175.55,115.75 178.22,115.75 178.85,116.39 178.85,120.45 189.65,131.25 204.38,131.25 205.78,132.64 210.16,132.64 211.05,133.53 211.05,135.75 211.86,136.57 211.86,139.7 210.51,141.05 210.51,143.97 209.27,145.22 209.27,153.67 217.8,162.2 220.02,162.2 223.17,165.35 224.64,165.35 225.53,166.23 v2(225.53,167.44)
  BOTTOM w0.102: C143.1 R160.1 257.29,161.65 257.09,161.85 253.66,161.85 252.74,160.94 245.64,160.94 240.33,155.63 231.05,155.63 227.44,159.23 227.44,165.52 v2(225.53,167.44)
PC_SPKR: length 2.8
  BOTTOM w0.102: v1(257.29,164.09) R387.1 R167.1 C133.1
PCH_ALW_ON: length 97.2
  TOP w0.102: U38.A23 150.96,103.06 151.05,102.98 151.66,102.98 v2(151.84,103.16) 152.22,103.53 v1(152.22,103.8) 152.22,103.9 152.45,104.14 RP18.7 ; R416.1 86.46,73.9 84.3,76.06 84.3,79.87 84.9,80.47 v2(85.13,80.47)
  IN2 w0.102: v2(85.13,80.47) 85.13,86.03 89.83,90.73 92.18,90.73 94.59,93.15 105.7,93.15 106.4,92.45 110.91,92.45 111.42,92.96 113.45,92.96 115.61,95.11 123.08,95.11 125.05,97.08 127.09,97.08 127.9,97.9 128.38,97.9 129.13,97.15 132.18,97.15 133.51,98.48 136.05,98.48 136.5,98.04 136.5,96.83 136.88,96.45 141.32,96.45 141.58,96.7 142.91,96.7 144.06,95.56 144.5,95.56 144.84,95.9 145.42,95.9 145.75,96.23 146.43,96.23 147.04,96.84 147.04,97.96 147.86,98.78 148.68,98.78 150.79,100.89 150.79,101.53 151.84,102.58 v2(151.84,103.16)
PCH_AUDIO_EN: length 8.7
  BOTTOM w0.076: v1(114.59,69.84) 114.59,69.23 114.52,69.16 114.52,67.23 UC1.P1
  BOTTOM w0.102: RP11.8 116.64,73.51 117.13,73.01 117.13,72.72 116.76,72.36 116.36,72.36 114.59,70.59 v1(114.59,69.84)
PCH_AZ_BITCLK: length 5
  BOTTOM w0.076: UC1.AW8 128.51,62.33 128.78,62.06 129.54,62.06 129.7,62.22 130.35,62.22 v1(130.92,62.79) 131.81,63.68 RC26.2
PCH_AZ_CODEC_BITCLK: length 188.3
  IN1 w0.097: v2(141.15,67.86) 141.15,68.03 141.96,68.84 154.04,68.84 154.51,69.31 155.55,69.31 156.01,68.85 158.81,68.85 159.22,69.26 159.22,70.16 162.4,73.34 164.38,73.34 168.31,77.27 168.88,77.27 173.42,81.8 173.42,82.44 176.12,85.14 178.41,85.14 179.3,86.03 179.3,89.91 181.65,92.26 181.65,95.52 183.43,97.3 183.43,106.61 184.63,107.81 184.63,114.61 190.82,120.8 200.85,120.8 201.84,121.78 202.49,121.78 204.24,123.54 206.63,123.54 208.23,125.14 214.27,125.14 218.26,129.12 218.26,131.28 219.63,132.66 219.63,136.21 229.91,146.49 231.96,146.49 239.03,153.55 239.03,154.72 239.26,154.95 243.98,154.95 245.52,156.5 250.07,156.5 250.16,156.59 250.16,157.07 250.29,157.2 250.52,157.2 250.65,157.07 250.65,156.59 250.74,156.5 251.03,156.5 251.13,156.59 251.13,157.07 251.26,157.2 251.48,157.2 251.61,157.07 251.61,156.59 251.71,156.5 252,156.5 252.09,156.59 252.09,157.07 252.22,157.2 252.45,157.2 252.58,157.07 252.58,156.59 252.67,156.5 252.96,156.5 253.06,156.59 253.06,156.99 253.16,157.09 253.41,157.09 253.54,156.96 253.54,156.59 253.64,156.5 254.93,156.5 255.12,156.69 v2(255.12,157.41)
  BOTTOM w0.102: U17.6 255.18,157.34 v2(255.12,157.41) 255.12,158.35 R149.1 ; v2(141.15,67.86) 141.15,66.67 139.11,64.63 136.5,64.63 135.54,63.68 RC26.1 132.74,64.6 CC5.1
PCH_AZ_CODEC_RST#: length 186.8
  IN1 w0.097: v2(140.56,67.86) 140.56,67.94 141.81,69.19 153.88,69.19 154.51,69.82 158.37,69.82 162.19,73.64 164.17,73.64 168.22,77.68 168.85,77.68 173.06,81.89 173.06,82.53 176,85.46 178.28,85.46 178.98,86.16 178.98,90.1 180.32,91.44 180.32,93.14 180.42,93.23 181.17,93.23 181.27,93.33 181.27,93.64 181.17,93.74 180.42,93.74 180.32,93.83 180.32,94.32 180.42,94.42 181.16,94.42 181.29,94.55 181.29,95.66 183.11,97.48 183.11,102.43 182.53,103.01 182.53,106.22 184.25,107.94 184.25,114.8 190.55,121.1 200.52,121.1 201.59,122.17 202.31,122.17 204.01,123.87 206.47,123.87 208.04,125.44 214.15,125.44 216.76,128.06 216.76,130.29 219.25,132.78 219.25,136.34 229.8,146.88 231.87,146.88 238.68,153.7 238.68,154.86 239.12,155.3 243.04,155.3 v2(243.69,155.95) 245.24,157.5 253.63,157.5 253.87,157.26 254.4,157.26 255.43,158.3 255.77,158.3 256.51,157.56 257.44,157.56 v2(257.85,157.15)
  BOTTOM w0.102: U17.11 257.68,156.99 v2(257.85,157.15) ; R142.1 v2(243.69,155.95) ; RC25.1 134.34,65.52 135.03,66.21 136.13,66.21 136.88,65.46 138.78,65.46 140.56,67.24 v2(140.56,67.86)
PCH_AZ_CODEC_SDIN0: length 189.8
  IN1 w0.097: v2(255.67,157.83) 256.13,157.37 256.13,156.84 254.44,155.14 252.19,155.14 251.18,156.15 245.66,156.15 243.43,153.91 239.88,153.91 232.11,146.14 230.06,146.14 220.01,136.08 220.01,132.53 218.67,131.18 218.67,128.95 214.55,124.83 208.42,124.83 205,121.4 202.03,121.4 201.13,120.5 190.95,120.5 185.01,114.56 185.01,107.61 183.74,106.34 183.74,97.08 182.66,96 182.66,91.75 181.77,90.86 181.77,88.07 178.54,84.83 176.25,84.83 173.77,82.35 173.77,81.72 168.95,76.89 168.44,76.89 165.45,73.91 165.45,72.73 165.24,72.52 163.3,72.52 161.55,70.76 161.55,70.05 161.11,69.61 160.3,69.61 159.18,68.49 155.85,68.49 155.4,68.95 154.72,68.95 154.26,68.49 142.1,68.49 141.73,68.11 v2(141.73,67.86)
  BOTTOM w0.089: UC1.AY10 129.46,61.59 129.77,61.9 130.53,61.9 131.89,63.27 136.15,63.27 136.75,63.87
  BOTTOM w0.102: v2(141.73,67.86) 141.73,66.75 138.85,63.87 v1(137.51,63.87) 136.75,63.87 ; R136.1 255.67,158.8 v2(255.67,157.83)
PCH_AZ_CODEC_SDOUT: length 172.3
  IN1 w0.097: v2(143.89,69.65) 144,69.54 153.72,69.54 154.36,70.17 158.22,70.17 163.01,74.97 164.99,74.97 168.12,78.1 168.82,78.1 172.76,82.03 172.76,82.67 175.87,85.78 178.09,85.78 178.6,86.29 178.6,90.22 179.93,91.56 179.93,94.8 182.79,97.65 182.79,102.32 182.23,102.88 182.23,106.43 183.87,108.07 183.87,114.91 190.36,121.4 200.25,121.4 201.4,122.55 202.16,122.55 203.83,124.22 206.35,124.22 207.95,125.82 211.25,125.82 215.72,130.29 216.25,130.29 218.87,132.91 218.87,136.47 229.64,147.24 231.72,147.24 238.33,153.84 238.33,155.01 238.97,155.66 242.82,155.66 245.02,157.85 254.04,157.85 v2(254.23,157.66)
  BOTTOM w0.102: RC23.1 141.02,71.1 141.92,70.2 143.34,70.2 v2(143.89,69.65) ; U17.5 254.68,157.21 v2(254.23,157.66) 254.23,158.35 R148.1
PCH_AZ_CODEC_SYNC: length 183.8
  TOP w0.102: v2(134.63,62.68) 133.67,62.68 133.53,62.82 RC24.1
  IN1 w0.076: v2(134.63,62.68) 136.54,62.68 137.03,63.17
  IN1 w0.097: v2(257.18,157.15) 257.18,157 254.97,154.79 251.88,154.79 251.66,155.01 250.33,155.01 250.11,154.79 246.47,154.79 245.23,153.56 240.03,153.56 232.19,145.72 230.16,145.72 220.4,135.96 220.4,132.4 219.11,131.12 219.11,128.88 214.76,124.53 208.62,124.53 205.11,121.02 202.22,121.02 201.4,120.2 191.17,120.2 185.39,114.42 185.39,107.5 184.06,106.17 184.06,96.96 182.98,95.88 182.98,91.62 182.09,90.73 182.09,87.94 178.66,84.51 176.39,84.51 174.13,82.25 174.13,81.5 172.06,79.43 172.06,78.48 170.09,76.51 168.57,76.51 165.77,73.71 165.77,72.59 165.36,72.19 163.48,72.19 161.96,70.67 161.96,69.9 161.29,69.23 160.65,69.23 159.47,68.05 150.23,68.05 149.01,66.83 140.69,66.83 137.03,63.17
  BOTTOM w0.102: U17.10 v2(257.18,157.15)
PCH_AZ_RST#: length 7.2
  BOTTOM w0.076: UC1.AU8 127.56,62.73 127.95,62.73 128.04,62.64 130.34,62.64 v1(131.63,63.93) 132.24,64.55 132.24,65.03 RC25.2
PCH_AZ_SDIN0_R: length 2.2
  BOTTOM w0.102: R136.2 256.18,158.4 U17.8
PCH_AZ_SDOUT: length 27.2
  BOTTOM w0.076: UC1.AU11 127.6,61.27 128.11,61.27 128.16,61.31 129.56,61.31 129.89,61.65 130.67,61.65 132.12,63.1 137.03,63.1
  BOTTOM w0.102: 137.03,63.1 138.58,63.1 142.14,66.65 142.14,68.57 v1(141.1,69.61) 140.25,70.46 140.25,73.13 RC23.2 140.11,73.79 139.79,74.11 RC3.2 RC9.2
PCH_AZ_SYNC: length 8.5
  TOP w0.102: v2(128.23,60.47) 129.28,60.47 129.87,61.06 129.87,61.2 129.62,61.46 129.62,61.63 129.74,61.75 129.9,61.75 130.16,61.49 130.3,61.49 130.45,61.63 130.45,61.78 130.23,61.99 130.23,62.16 130.35,62.28 130.52,62.28 130.74,62.06 130.88,62.06 131.13,62.32 v1(131.13,62.34) 131.13,62.86 131.2,62.92 131.67,62.92 131.74,62.98 131.74,63.43 131.86,63.55 RC24.2
  BOTTOM w0.076: UC1.AV11 127.86,60.83 v2(128.23,60.47)
PCH_BATLOW#: length 15.6
  TOP w0.102: v2(124.62,65.6) 125.2,66.18 125.2,66.59 125.63,67.02 126.69,67.02 127.94,68.27 127.94,69.6 v1(127.22,70.32) 126.44,71.1 126.44,71.67 126.85,72.08 129.95,72.08 131.57,73.7 RP12.1
  BOTTOM w0.076: v2(124.62,65.6) 124.96,65.26 UC1.AN4
PCH_CL_CLK1: length 256.9
  IN1 w0.097: v2(119.95,70.37) 119.95,70.39 120.13,70.57 120.44,70.57 120.64,70.77 120.64,78.07 121.73,79.16 123.16,79.16 124.03,80.03 126.49,80.03 128.12,81.66 128.97,81.66 131.1,83.79 131.1,85.41 136.02,90.34 136.02,92.86 136.88,93.72 136.88,94.67 138.41,96.2 138.41,101.28 139.6,102.47 139.6,104.06 140.45,104.91 140.45,109.7 138.4,111.74 138.4,114.72 138.96,115.28 140.23,116.55 141.3,116.55 143.64,118.89 143.64,120.22 144.59,121.18 149.01,121.18 157.9,130.07 164.91,130.07 166.24,131.39 166.24,135.43 167.22,136.42 171.39,136.42 172.14,137.17 174.16,137.17 174.76,136.57 180.12,136.57 181.56,135.13 183.57,135.13 184.31,135.86 184.99,135.86 185.49,136.36 185.49,146.58 188.28,149.37 189.49,149.37 190.56,150.44 191.32,150.44 193.47,152.6 196.24,152.6 199.82,156.17 201.19,156.17 202.3,157.27 224.09,157.27 225.45,155.91 227.59,155.91 228.43,156.75 235.22,156.75 238.02,159.55 241.51,159.55 243.53,161.58 246.33,161.58 246.89,162.14 253.17,162.14 253.18,162.15 259.56,162.15 264.39,157.31 266.39,157.31 267.91,155.79 272.55,155.79 273.12,155.22 274.58,155.22 275.85,153.95 287.53,153.95 288.48,154.9 291.28,154.9 292.55,156.17 295.24,156.17 295.42,155.99 295.42,155.84 v2(295.17,155.59)
  BOTTOM w0.076: UC1.AF2 120.22,66.85 120.22,67.63 119.82,68.03 119.82,68.63 119.43,69.02 119.43,69.74 119.44,69.75 119.44,69.82 119.45,69.83 119.45,69.84
  BOTTOM w0.102: JMINI1.45 295.06,156.33 295.43,155.96 295.43,155.85 v2(295.17,155.59) ; 119.45,69.84 119.45,70.42 119.57,70.54 119.78,70.54 v2(119.95,70.37)
PCH_CL_DATA1: length 257.5
  IN1 w0.097: v2(119.95,70.95) 120.11,70.79 120.35,70.79 120.41,70.86 120.41,78.16 121.64,79.38 123.07,79.38 123.93,80.25 126.4,80.25 128.03,81.88 128.88,81.88 130.88,83.88 130.88,85.51 135.8,90.43 135.8,92.95 136.66,93.81 136.66,94.76 138.19,96.29 138.19,101.37 139.38,102.56 139.38,104.15 140.23,105 140.23,109.6 138.18,111.65 138.18,114.82 138.42,115.05 138.42,115.05 140.14,116.78 141.21,116.78 143.41,118.98 143.41,120.32 144.5,121.4 148.92,121.4 157.81,130.29 164.82,130.29 166.01,131.49 166.01,135.53 167.13,136.64 171.3,136.64 172.05,137.4 174.25,137.4 174.85,136.8 180.21,136.8 181.65,135.35 183.48,135.35 184.21,136.08 184.9,136.08 185.27,136.45 185.27,146.68 188.19,149.6 189.4,149.6 190.46,150.66 191.22,150.66 193.38,152.82 196.15,152.82 199.72,156.39 201.1,156.39 202.2,157.5 224.18,157.5 225.54,156.14 227.5,156.14 228.34,156.98 235.12,156.98 237.93,159.78 241.42,159.78 243.44,161.8 246.24,161.8 246.8,162.36 253.07,162.36 253.08,162.37 259.65,162.37 264.48,157.53 266.48,157.53 268.01,156.01 272.64,156.01 273.21,155.44 274.67,155.44 275.94,154.17 287.44,154.17 288.39,155.12 291.18,155.12 292.45,156.39 295.34,156.39 295.64,156.09 295.64,155.7 v2(295.75,155.59)
  BOTTOM w0.076: 119.22,69.84 119.22,68.93 119.61,68.55 119.61,67.95 120.04,67.52 120.04,66.85 UC1.AD2
  BOTTOM w0.102: 119.22,69.84 v3(119.22,70.05) 119.22,70.52 119.47,70.77 119.77,70.77 v2(119.95,70.95) ; JMINI1.47 295.86,156.33 295.66,156.12 295.66,155.69 v2(295.75,155.59)
PCH_CL_RST1#: length 256.6
  TOP w0.102: R223.1 298.06,154.93 v2(296.71,154.93)
  IN1 w0.097: v2(296.71,154.93) 295.19,153.41 275.56,153.41 274.17,154.8 272.96,154.8 272.39,155.38 267.56,155.38 267.25,155.69 265.51,155.69 259.41,161.8 253.53,161.8 252.93,161.19 246.57,161.19 246.54,161.23 243.68,161.23 241.9,159.45 241.65,159.2 238.16,159.2 234.72,155.76 228.13,155.76 227.81,155.44 221.92,155.44 220.52,156.84 202.56,156.84 201.55,155.82 199.97,155.82 196.37,152.21 193.7,152.21 191.57,150.08 190.75,150.08 189.69,149.01 188.44,149.01 185.88,146.45 185.88,136.24 185.14,135.5 184.48,135.5 183.76,134.78 181.27,134.78 179.82,136.22 174.84,136.22 174.69,136.07 167.81,136.07 166.68,134.93 166.68,131.31 164.95,129.59 158.03,129.59 149.27,120.83 144.74,120.83 143.99,120.08 143.99,118.48 140.52,115.01 139.57,115.01 138.78,114.23 138.78,111.89 140.8,109.88 140.8,104.52 140.01,103.73 140.01,102.37 138.76,101.12 138.76,94.9 138.34,94.48 138.34,93.88 137.14,92.68 137.14,90.96 131.48,85.3 131.48,83.6 130.76,82.87 130.76,82.52 129.18,80.94 128.09,80.94 126.68,79.53 124.29,79.53 123.57,78.81 122.46,78.81 121.49,77.84 121.49,75.52 121.58,75.43 121.58,74.35 121.32,74.1 121.32,70.73 121.64,70.41
  IN1 w0.102: 121.64,70.41 121.64,69.27 v2(121.26,68.89)
  BOTTOM w0.076: UC1.AF4 120.86,65.59 120.86,65.98 120.96,66.07 120.96,67.54 120.89,67.61 120.89,68.25 120.93,68.28 120.93,68.56 v2(121.26,68.89)
PCH_CL_RST1#_R: length 2.5
  TOP w0.102: v2(297.09,155.5) R223.2
  BOTTOM w0.102: v2(297.09,155.5) 296.66,155.93 JMINI1.49
PCH_DPWROK: length 95.8
  TOP w0.102: v2(157.83,104.16) 157.86,104.19 R319.1 ; v2(142.62,73.02) 142.21,72.61 138.38,72.61 136.93,71.16 v1(136.93,70.98) 136.93,70.62 136.18,69.87 136.18,68.89 135.36,68.06 134.2,68.06 RC79.1 133.08,67.94 132.7,67.94 132.45,68.19 131.8,68.19 130.91,67.3 v2(130.91,66.67)
  IN1 w0.097: v2(142.62,73.02) 143.03,73.42 144.73,73.42 145.44,72.71 153.54,72.71 153.92,73.09 155.92,73.09 156.93,74.11 156.93,81.07 159.93,84.06 162.21,84.06 163.49,85.34 167.89,85.34 168.61,86.06 168.61,88.75 169.39,89.53 170.11,89.53 171.11,90.52 171.11,92.03 172.36,93.28 172.36,101.48 171.83,102.01 v2(171.83,106.8)
  BOTTOM w0.076: v2(130.91,66.67) 130.56,66.31 130.56,65.18 129.95,64.57 129.58,64.57 129.3,64.3 128.12,64.3 UC1.AV5
  BOTTOM w0.102: v2(157.83,104.16) 158.91,105.24 162.98,105.24 163.63,105.88 169.44,105.88 169.91,106.35 170.85,106.35 171.3,106.8 v2(171.83,106.8)
PCH_GPIO0: length 7
  BOTTOM w0.076: UC1.K4 112.22,65.35 111.92,65.65 111.92,66.03 111.97,66.07 111.97,66.82 111.79,66.99 111.79,68.08 110.64,69.23 110.64,69.84
  BOTTOM w0.102: 110.64,69.84 110.64,69.98 111.3,70.64 111.62,70.64 v1(111.85,70.87)
PCH_GPIO9: length 24.3
  TOP w0.102: v2(124.62,66.21) 123.72,67.11 121.32,67.11 120.81,67.62 120.81,69.85 120.47,70.2 120.47,71.46 120.03,71.9 120.03,73.42 118.6,74.84 118.6,76.49 119.05,76.95 119.05,77.63 117.64,79.05 116.98,79.05 116.62,79.41 116.62,80.26 116.17,80.71 116.17,81.82 v1(115.79,82.19) 115.37,82.62 RP10.5
  BOTTOM w0.076: v2(124.62,66.21) 124.32,65.91 UC1.AM3
PCH_GPIO10: length 2.3
  BOTTOM w0.076: v2(124.47,68.21) 124.06,68.21 123.83,67.97 123.83,67.53 123.95,67.4 123.95,67.09 124.25,66.8 UC1.AM2
PCH_GPIO15: length 21.4
  TOP w0.102: v2(115.61,78.44) 115.61,78.86 114.65,79.81 RC190.2 115.16,81.19 v1(115.68,80.67)
  IN2 w0.076: 119.2,69.84 119.29,69.75 119.29,65.24 119.39,65.14 119.39,64.43 v2(119.06,64.11)
  IN2 w0.102: v2(115.61,78.44) 115.49,78.33 115.49,76.32 116.95,74.86 117.54,74.86 118.93,73.46 118.93,70.88 119.07,70.74 119.07,69.97 119.2,69.84
  BOTTOM w0.076: v2(119.06,64.11) 119.24,63.93 UC1.AD6
PCH_GPIO36: length 28.7
  TOP w0.102: RP3.7 114.14,84.76 114.34,84.95 114.34,85.78 v2(114.21,85.91) 114.21,85.97 v1(113.4,86.78)
  IN2 w0.076: 115.69,69.84 116.57,68.96 116.57,64.41 v2(116.2,64.04)
  IN2 w0.102: v2(114.21,85.91) 114.21,85.37 111.37,82.54 111.37,78.95 112.29,78.03 112.29,75.83 113.9,74.23 113.9,72.67 115.09,71.48 115.09,70.44 115.69,69.84
  BOTTOM w0.076: UC1.V6 116.31,63.93 v2(116.2,64.04)
PCH_GPIO44: length 23.4
  TOP w0.102: RP10.7 116.37,83.52 116.59,83.3 117.19,83.3 117.96,82.54 v1(117.96,82.15) 117.96,81.44 v2(118.27,81.13)
  IN2 w0.102: v2(118.27,81.13) 119.2,80.2 119.2,78.73 118.95,78.48 118.95,76.94 118.79,76.79 118.79,76.3 119.48,75.62 119.87,75.62 120.42,75.07 120.42,74.59 121.13,73.87 121.13,72.37 122.74,70.76 v2(123.05,70.76)
  BOTTOM w0.076: 123.56,69.84 123.56,69.59 122.36,68.39 122.36,67.63 122.47,67.52 122.47,66.09 122.42,66.03 122.42,65.56 UC1.AK4
  BOTTOM w0.102: v2(123.05,70.76) 123.56,70.25 123.56,69.84
PCH_GPIO46: length 18.7
  IN2 w0.076: 120.01,69.84 119.94,69.76 119.94,68.34 121.62,66.65 v2(121.62,66.21)
  IN2 w0.102: v2(117.06,79.72) 117.06,79.03 116.79,78.76 116.79,76.01 117.09,75.72 117.65,75.72 120.22,73.15 120.22,71.99 120.37,71.83 120.37,70.2 120.01,69.84
  BOTTOM w0.076: UC1.AG3 121.32,65.91 v2(121.62,66.21)
  BOTTOM w0.102: v1(116.64,79.3) 117.05,79.72 v2(117.06,79.72) 116.42,80.36 RC230.2
PCH_GPIO48: length 33.1
  TOP w0.102: v2(113.8,87.76) 113.8,88.06 v1(112.48,89.38) 111.97,89.89 RC292.2 R76.2
  IN2 w0.076: v2(115.28,64.78) 115.05,65.01 115.05,66.47 113.99,67.53 113.99,69.12 113.27,69.84
  IN2 w0.102: 113.27,69.84 112.86,70.25 112.86,71.21 112.04,72.03 112.04,72.76 111.06,73.74 111.06,75.36 109.85,76.57 109.85,77.59 110.44,78.17 110.44,84.73 111.33,85.62 112.01,85.62 112.3,85.92 112.3,86.26 v2(113.8,87.76)
  BOTTOM w0.076: v2(115.28,64.78) 115.49,65 115.78,65 UC1.U4
PCH_GPIO59: length 1
  BOTTOM w0.076: UC1.AT5 126.89,64.31 v2(127.4,64.82)
PCH_GPIO66: length 9.3
  BOTTOM w0.076: 107.26,68.22 108.07,67.41 108.07,67.07 108.27,66.87 108.7,66.87 108.9,66.67 108.9,66.24 UC1.D3
  BOTTOM w0.102: 107.26,68.22 105.71,69.76 103.88,69.76 RC283.2 RC288.1
PCH_GPIO73: length 11.6
  BOTTOM w0.076: UC1.AU4 127.38,65.24 127.67,65.52 128.07,65.52 128.19,65.64 128.19,66.04 128.37,66.22 128.97,66.22 129.03,66.28 129.37,66.28 129.64,66.55 129.64,69.02 130.47,69.84
  BOTTOM w0.102: RP13.2 128.43,70.98 128.69,71.24 129.13,71.24 129.7,71.81 130.37,71.81 130.59,71.59 130.59,69.97 130.53,69.9 130.47,69.84
PCH_GPIO83: length 32
  TOP w0.102: v2(102.17,79.43) 102.78,79.43 103.99,80.64 RC85.1 104.86,81.19 RC290.2 105.76,81.19 v1(105.89,81.06)
  IN2 w0.076: v2(114.33,63.56) 114.64,63.86 114.64,66.21 114.12,66.73
  IN2 w0.102: 114.12,66.73 112.15,68.69 111.01,68.69 108.7,71.01 102.08,71.01 101.17,71.92 101.17,78.43 v2(102.17,79.43)
  BOTTOM w0.076: UC1.R6 114.7,63.93 v2(114.33,63.56)
PCH_GPIO84: length 72.7
  IN2 w0.102: v2(123.49,89.07) 122.84,89.72 118.21,89.72 117.58,89.09 108.79,89.09 105.54,85.84 104.11,85.84 103.54,85.27 103.54,84.64 102.27,83.37 100.34,83.37 99.16,82.18 99.16,81.85 98.8,81.49 98.8,80.25 98.47,79.92 98.47,70.78 100.25,69 104.32,69 108.36,64.96 111.78,64.96 v2(112.38,64.36)
  BOTTOM w0.102: UC1.L6 112.44,64.36 v2(112.38,64.36) ; v2(123.49,89.07) 123.99,88.57 123.99,86.22 123.04,85.27 122.21,85.27 121.27,84.33 121.27,83.73 120.12,82.57 v1(120.12,78.92) 120.12,78.53 121.75,76.89 121.75,76.72 RC291.2
PCH_GPIO85: length 12.3
  IN1 w0.076: v2(114.24,64.19) 114.24,64.2 113.71,64.73 113.71,68.7 113.58,68.84 113.58,69.84
  IN1 w0.097: 113.58,69.84 113.58,72.25 114.25,72.93 v2(114.53,72.93)
  BOTTOM w0.076: UC1.N6 114.09,64.19 v2(114.24,64.19)
  BOTTOM w0.102: RP9.5 114.39,73.07 v2(114.53,72.93) 114.01,72.93 v1(113.88,72.8)
PCH_INTVRMEN: length 9.8
  BOTTOM w0.076: v1(134.57,67.61) 134.32,67.36 RC1.2 132.76,66.48 RC2.1 132.07,66.48 131.74,66.14 131.74,64.46 130.08,62.8 128.24,62.8 128,63.05 UC1.AV7
PCH_JTAG_JTAGX: length 35.3
  IN2 w0.102: v2(121.78,17.34) 121.02,16.58 115.76,16.58 114.69,17.64 110.4,17.64 109.51,16.76 106.04,16.76 105.71,17.09 104.28,17.09 104.05,16.86 v2(104.05,16.31)
  BOTTOM w0.076: 120.58,25.9 120.58,27.38 120.46,27.51 UC1.AE63
  BOTTOM w0.102: v2(121.78,17.34) 121.25,17.87 121.25,22.96 v1(120.74,23.47) 120.58,23.63 120.58,25.9 ; RC123.2 103.6,14.48 RC97.2 RC10.1 v2(104.05,16.31)
PCH_JTAG_TCK: length 49
  TOP w0.102: RC142.1 131.65,16.92 v5(131.33,16.92) 128.4,16.92 128.22,16.74 123,16.74 v2(122.44,17.3)
  IN2 w0.102: v2(101.13,14.79) 102.21,14.79 102.92,15.5 108.51,15.5 109.13,16.12 111.42,16.12 111.8,15.74 120.88,15.74 v2(122.44,17.3)
  BOTTOM w0.076: UC1.AE62 120.68,29.02 120.68,28.81 120.74,28.68 120.75,28.65 120.75,28.39 120.65,28.29 120.65,27.61 120.83,27.43 120.83,25.9
  BOTTOM w0.102: RC22.1 101.76,12.61 RC124.2 101.4,13.5 101.13,13.77 v2(101.13,14.79) ; 120.83,25.9 120.83,24.06 121.51,23.37 121.51,18.23 v2(122.44,17.3)
PCH_JTAG_TCK_R: length 6
  TOP w0.102: JXDP1.55 135.15,13.46 134.71,13.9 133.19,13.9 132.56,14.53 RC142.2 131.69,15.09 v1(131.47,14.88)
PCH_JTAG_TDI: length 37.4
  TOP w0.102: v2(120.33,17.43) v5(121,17.43)
  IN2 w0.102: v2(120.33,17.43) 120.33,17.42 119.72,16.81 115.96,16.81 114.87,17.9 110.27,17.9 109.38,17.01 106.16,17.01 105.13,18.04 103.71,18.04 103.51,18.24 102.99,18.24 101.81,19.42 v2(101.13,19.42)
  BOTTOM w0.076: UC1.AD61 119.42,29.63 119.42,29.12 119.66,28.88 119.83,28.88 120,28.71 120,28.4 120.1,28.3 120.1,27.35 119.75,27 119.75,25.9
  BOTTOM w0.102: RC96.1 RC17.1 101.75,19.12 101.45,19.42 v2(101.13,19.42) ; v2(120.33,17.43) 120.33,19.13 120.75,19.55 120.75,22.41 119.75,23.41 119.75,25.9
PCH_JTAG_TDO: length 29.8
  TOP w0.102: v2(109.13,18.53) v5(109.13,19.19)
  IN1 w0.097: v2(109.13,18.53) 108.81,18.85 108.81,21.26 110.46,22.91 110.46,24.76 v2(110.91,25.2)
  IN2 w0.102: v2(120.09,29.59) 119.19,28.69 113.26,28.69 110.91,26.34 v2(110.91,25.2)
  IN3 w0.102: v2(109.13,18.53) 109.13,18.08 108.44,17.39 105.51,17.39 v2(104.62,16.5)
  BOTTOM w0.076: v2(120.09,29.59) 120.12,29.62 120.39,29.89 UC1.AE61
  BOTTOM w0.102: RC95.1 103.92,15.42 104.49,15.99 104.49,16.37 v2(104.62,16.5) 103.93,17.2 RC104.2 RC18.1
PCH_JTAG_TMS: length 22.9
  TOP w0.076: v2(120.14,26.74) v5(120.74,26.74)
  BOTTOM w0.076: 119.98,25.9 119.98,26.58 v2(120.14,26.74) 120.26,26.87 120.26,28.37 120.17,28.46 120.17,28.78 120.16,28.79 120.16,28.79 UC1.AD62
  BOTTOM w0.102: RC101.1 113.12,16.5 RC20.1 113.77,15.85 119.33,15.85 121,17.52 121,22.48 119.98,23.51 119.98,25.9
PCH_JTAG_TRST#: length 30
  TOP w0.102: v5(123.53,18.01) 123.12,17.59 v2(123.12,17.27)
  BOTTOM w0.076: 127.21,28.01 126.88,28.34 126.88,28.72 127.2,29.04 UC1.AU62
  BOTTOM w0.102: 127.21,28.01 127.38,28.01 128.09,27.3 129.41,27.3 130.27,26.44 130.27,24.93 124.29,18.95 124.29,18.44 v2(123.12,17.27) 121.24,15.39 112.35,15.39 RC135.2
PCH_OPI_COMP: length 5.8
  TOP w0.076: v1(133.13,58.6) 132.74,59 RC168.1
  TOP w0.305: v2(131.65,59.68) 132.12,59.68 132.24,59.55 RC168.1
  BOTTOM w0.076: v2(131.65,59.68) 131.52,59.55 131.17,59.55 130.65,59.04 129.88,59.04 129.72,58.89 128.94,58.89 128.65,58.59 UC1.AW15
PCH_PCIE_IREF: length 7.7
  TOP w0.305: v2(104.06,51.85) 104.06,51.62 103.81,51.36 v1(102.77,51.36) RC163.2
  BOTTOM w0.102: 106.19,51.06 106.87,51.06 UC1.B27
  BOTTOM w0.305: v2(104.06,51.85) 104.06,51.59 104.42,51.24 104.94,51.24 105.12,51.06 106.19,51.06
PCH_PCIE_RCOMP: length 9
  TOP w0.102: v1(99.15,49.44) 99.52,49.81 100.11,49.81 100.44,50.14 RC161.2
  TOP w0.305: v2(104.7,51.85) 104.7,51.49 104.18,50.97 101.37,50.97 100.87,50.47 RC161.2
  BOTTOM w0.305: UC1.A27 106.38,51.53 105.22,51.53 104.9,51.85 v2(104.7,51.85)
PCH_PCIE_WAKE#: length 74.7
  TOP w0.076: v2(122.83,64.21) 123.06,64.43 126.39,64.43 126.72,64.76 126.72,65.93 129.83,69.04 129.83,69.84
  TOP w0.102: U38.A44 143.39,109.62 v2(142.98,110.04) ; RP12.2 132.27,73.2 132.46,73.02 132.46,72.05 131.62,71.21 130.91,71.21 129.83,70.13 129.83,69.84
  IN1 w0.097: v2(142.98,110.04) 142.98,108.6 143.15,108.42 143.15,106.68 144.12,105.72 144.12,99.47 144.78,98.81 144.78,95.81 143.73,94.77 142.65,94.77 141.9,94.02 141.9,93.8 139.04,90.94 138.96,90.94 132.88,84.85 132.88,83.49 131.99,82.6 131.99,81.66 131.27,80.94 131.27,80.23 129.56,78.53 129.56,78.15 129.26,77.84 129.26,74.41 128.88,74.03 128.88,73.13 129.18,72.83 129.18,72.09 128.21,71.11 127.48,71.11 126.75,70.37 126.75,68.52 125.01,66.78 124.32,66.78 123.98,66.44 123.98,65.73 123.24,64.99 123.24,64.61 v2(122.83,64.21)
  BOTTOM w0.076: UC1.AJ5 122.46,64.58 v2(122.83,64.21)
PCH_PLTRST#: length 65.3
  TOP w0.102: v2(125.52,82.52) v5(125.52,81.74)
  IN2 w0.076: v2(120.97,63.46) 121.16,63.46 121.73,64.02 122.05,64.02 122.59,64.57 122.59,66.96 121.83,67.72 121.83,69.33 121.64,69.52 121.64,69.84
  IN2 w0.102: v2(139.66,85.27) 137.6,85.27 136.74,84.41 132.68,84.41 131.9,85.18 128.71,85.18 127.99,85.91 126.79,85.91 126.12,85.24 126.12,83.12 v2(125.52,82.52) 124.76,83.27 122.01,83.27 120.54,84.74 119.63,84.74 118.66,83.76 118.66,82.85 117.58,81.77 117.58,80.7 118.02,80.26 118.35,80.26 118.67,79.93 118.67,79.14 117.26,77.73 117.26,77.03 117.88,76.41 117.88,76.14 120.67,73.34 120.67,72.18 121.64,71.21 121.64,69.84
  BOTTOM w0.076: v2(120.97,63.46) 121.15,63.28 UC1.AG7
  BOTTOM w0.102: v2(125.52,82.52) 125.67,82.36 125.67,80.6 RC91.2 RC92.2 RC180.2 RC90.2 ; UC3.1 UC3.2 135.99,80.19 136.32,80.52 136.32,81.26 139.66,84.6 v2(139.66,85.27)
PCH_PLTRST#_EC: length 425.9
  TOP w0.102: U38.B30 148.91,105.81 148.5,105.4 v2(148.5,105.4) ; U37.B22 163.72,99.59 v2(164.13,100) ; v2(164.73,117.67) 164.93,117.87 164.93,119.31 R2699.2 ; v2(137.22,2.78) RC109.1 ; v2(214.16,133.6) 214.92,132.83 v1(215.87,132.83) 218.02,132.83 218.27,133.09 U30.1 ; v2(160.55,112.87) 160.27,113.15 158.79,113.15 157.18,111.54 U25.16 157.18,109.26 v2(156.88,108.97) ; CE14.1 89.05,24.88 89.25,24.88 89.56,24.58 JEXP1.35 89.56,22.17 90.14,21.58 98.2,21.58 99.68,23.07 v2(99.68,23.21)
  IN1 w0.097: v2(142.04,73.02) 142.04,73.57 142.37,73.91 144.98,73.91 145.13,73.75 155.4,73.75 156.45,74.81 156.45,81.41 155.29,82.57 155.29,83 155.57,83.28 155.95,83.28 158.11,85.45 158.11,85.86 158.66,86.41 162.47,86.41 163.8,87.75 163.8,91.95 164.56,92.71 164.56,94.54 164.78,94.76 164.78,99.35 v2(164.13,100) ; v2(214.16,133.6) 214.16,131.75 210.49,128.08 203.62,128.08 201.45,125.91 195.55,125.91 195.05,125.4 192.89,125.4 191.33,123.85 188.17,123.85 186.61,122.29 185.75,122.29 184.36,120.91 178.43,120.91 177.06,119.54 170.26,119.54 168.63,117.91 167.49,117.91 166.98,117.4 165,117.4 v2(164.73,117.67) 164.73,116.54 165.4,115.86 165.4,114.43 164.52,113.55 161.72,113.55 161.03,112.87 v2(160.55,112.87) ; v2(99.68,23.21) 100.18,23.21 103.85,19.54 103.85,17.42 103.65,17.21 103.65,16.02 104.08,15.58 106.74,15.58 107.54,16.39 109.09,16.39 109.36,16.12 111.81,16.12 112.57,15.36 119.06,15.36 120.83,13.59 120.83,9.05 123.33,6.54 123.33,6.5 125.27,4.56 129.83,4.56 130.34,5.07 130.34,7.7 v2(130.49,7.85)
  IN3 w0.102: v2(137.22,2.78) 137.22,3.71 136.11,4.83 131.36,4.83 130.35,5.84 130.35,7.71 v2(130.49,7.85) 130.49,9.06 132.24,10.81 132.24,11.93 126.62,17.56 v2(126.62,18.36) ; v2(156.88,108.97) 156.89,108.97 157.77,109.85 163.52,109.85 164.08,109.29 164.08,107.8 163.32,107.04 163.32,106.59 162.88,106.15 162.01,106.15 161.3,105.44 161.3,103.33 162.31,102.32 162.31,100.67 162.91,100.06 162.91,99.76 163.12,99.56 163.69,99.56 v2(164.13,100) ; v2(214.16,133.6) 214.16,136.52 216,138.36 216,140.45 220,144.45 220,152.33 222.6,154.93 222.6,157.47 225.37,160.24 229.78,160.24 231.53,161.99 239.16,161.99 239.69,161.47 241.06,161.47 241.44,161.85 246.04,161.85 246.93,162.74 253.66,162.74 253.85,162.55 260.76,162.55 261.59,163.38 265.54,163.38 267.19,161.73 278.84,161.73 280.04,160.52 283.25,160.52 v2(283.76,161.03)
  BOTTOM w0.102: UC3.4 137.64,80.32 137.04,79.72 137.04,79.33 137.39,78.99 138.21,78.99 138.66,78.54 138.66,75.62 139.23,75.05 140.75,75.05 142.04,73.77 v2(142.04,73.02) 142.04,72.83 143.12,71.75 143.42,71.75 144.12,71.05 144.12,70.22 146.79,67.56 146.79,33.46 135.7,22.37 129.3,22.37 126.62,19.69 v2(126.62,18.36) ; v2(156.88,108.97) 156.78,108.87 150.91,108.87 150.08,108.03 148.6,108.03 147.99,107.42 147.99,105.8 148.39,105.4 v2(148.5,105.4) ; R241.1 v2(283.76,161.03)
PCH_PWROK: length 11.2
  BOTTOM w0.089: UC1.AY7 130.1,63.09 131.5,64.49 131.5,67.95 132.31,68.76 132.31,69.46
  BOTTOM w0.102: 132.31,69.46 132.5,69.65 133.08,69.65 RC88.2 134.02,70.08 134.47,69.64 v5(134.81,69.64)
PCH_RSMRST#: length 21.4
  TOP w0.102: v2(143.67,107.12) 143.25,107.54 143.25,108 143.14,108.11 U38.B47 ; v1(144.46,116.75) 144.59,116.88 144.59,117.82 144.52,117.9 U42.1 143.5,117.9 142.85,118.55 v2(142.85,119.56) 142.85,119.93 R414.1 ; v2(142.03,111.91) 141.5,112.44 RP16.8
  IN3 w0.102: v2(142.85,119.56) 142.03,118.74 v2(142.03,111.91) 142.17,111.76 142.17,109.89 144.12,107.94 144.12,107.56 v2(143.67,107.12)
PCH_RSMRST#_Q: length 112.8
  TOP w0.102: RC93.1 134.86,67.83 135.63,67.83 v1(136.5,68.7) 136.69,68.89 136.69,69.7 137.41,70.42 137.41,70.94 138.59,72.13 142.47,72.13 143.26,72.91 v2(143.26,73.02) ; v2(141.01,120.68) 141.56,121.23 R413.2 R414.2
  IN1 w0.097: v2(143.26,73.02) 143.26,72.79 143.81,72.23 153.77,72.23 154.15,72.61 156.13,72.61 157.42,73.89 157.42,80.85 160.15,83.58 162.43,83.58 163.68,84.83 168.05,84.83 169.09,85.86 169.09,88.4 169.71,89.02 170.41,89.02 171.59,90.2 171.59,91.75 172.85,93.01 172.85,101.66 172.48,102.04 172.48,107.14 171.25,108.37 171.25,109.59 171.11,109.73 v2(171.11,110.54)
  BOTTOM w0.102: v2(141.01,120.68) 141.46,120.22 145.81,120.22 146.38,119.65 150.63,119.65 152.94,117.34 158.6,117.34 160.05,115.89 165.32,115.89 167.45,113.76 167.45,112.56 168.96,111.05 170.6,111.05 v2(171.11,110.54)
PCH_RSMRST#_R: length 8.8
  TOP w0.102: RC93.2 RC79.2 v1(133.58,65.49) 133.58,65.19 133.34,64.95 132.94,64.95 RC136.2 132.46,64.58 131.96,64.09 131.29,64.09 130.91,64.47 v2(130.91,64.7)
  BOTTOM w0.076: v2(130.91,64.7) 130.91,64.58 129.88,63.55 128.8,63.55 UC1.AW6
PCH_RTCRST#: length 47.4
  TOP w0.102: v2(127.57,63.42) 127.57,63.69 127.97,64.08 127.97,65.94 130.99,68.95 132,68.95 134.92,71.87 136.24,71.87 137.29,72.91 137.29,73.8 137.59,74.11 146.14,74.11 148.12,72.13 v2(148.12,70.86) 148.63,71.37 v5(149.06,71.37) 150.6,71.37 152.17,69.79 154.84,69.79 156.19,68.44 JAPS1.9
  BOTTOM w0.076: v2(127.57,63.42) 127.21,63.06 UC1.AU7
  BOTTOM w0.102: v2(148.12,70.86) 147.31,70.04 145.57,70.04 144.75,70.86 144.75,71.64 CMOS1.2 144.46,72.8 CC4.2 RC6.2
PCH_RTCX1: length 11.1
  BOTTOM w0.076: UC1.AW5 128.51,64.65 128.81,64.95 129.78,64.95 130.15,65.32 130.15,66.48
  BOTTOM w0.102: 130.15,66.48 130.12,66.51 130.12,67.32 130.35,67.56 130.35,69.03 131.67,70.35 131.67,71.24 131.86,71.43 131.86,72.33 RC4.2 132.26,73.08 RC5.1
PCH_RTCX1_R: length 3.2
  BOTTOM w0.102: YC1.1 130.83,74.57 130.99,74.41 130.99,73.61 CC1.2 RC4.1
PCH_RTCX2: length 13.1
  BOTTOM w0.102: YC1.2 133.33,74.1 CC2.2 RC5.2 133.46,72.6 v1(133,72.13) 132.07,71.2 132.07,70.39 131.77,70.1 131.77,69.26 130.86,68.34 130.86,67.58 130.35,67.07 130.35,65.25 129.87,64.77 129.7,64.77 129.3,64.77 UC1.AY5
PCH_SMB_ALERT#: length 5.5
  BOTTOM w0.076: UC1.AN2 125,66.57 124.7,66.86 124.62,66.94 124.62,67.49 124.89,67.76 124.89,69.12 124.81,69.19 124.81,69.84
  BOTTOM w0.102: v1(125.82,70.78) RC27.2 124.81,69.84
PCH_SPI_CLK: length 140.5
  IN1 w0.097: v2(21.44,19.1) 21.44,20.12 24.45,23.14 26.42,23.14 29.25,25.96 29.25,40.82 38.48,50.05 40.08,50.05 41.43,51.4 41.43,58.36 43.67,60.6 45.4,60.6 50.52,65.72 68.82,65.72 70.59,67.49 73.82,67.49 74.78,68.44 v2(74.78,68.83)
  IN3 w0.102: v2(118.63,66.21) 118.43,66.21 117.42,67.22 115.26,67.22 114.86,67.63 114.86,68.18 113.7,69.33 113.02,69.33 112.18,70.17 110.91,70.17 110.32,69.58 103.21,69.58 102.69,70.1 101.8,70.1 100.78,71.12 98.69,71.12 98.1,71.71 93.72,71.71 92.73,70.72 86.32,70.72 85.65,70.06 79.6,70.06 77.34,67.8 75.68,67.8 74.78,68.7 v2(74.78,68.83)
  BOTTOM w0.076: v2(118.63,66.21) 118.33,65.91 UC1.AA3
  BOTTOM w0.102: R7.2 R18.1 R13.1 v2(21.44,19.1) R20.2
PCH_SPI_CS0#: length 139.8
  IN1 w0.097: v2(19.66,19.1) 20.1,19.1 24.36,23.36 26.33,23.36 29.02,26.05 29.02,40.92 38.39,50.28 39.99,50.28 41.2,51.5 41.2,58.45 44.24,61.48 45.06,61.48 45.38,61.8 45.38,62.77 45.69,63.08 47.51,63.08 50.37,65.94 68.73,65.94 70.74,67.96 v2(73.23,67.96)
  IN3 w0.076: 116.18,66.6 116.5,66.29 116.5,65.14 116.61,65.03 116.61,64.01 v2(117.16,63.46)
  IN3 w0.102: v2(73.23,67.96) 74.15,67.05 77.57,67.05 79.7,69.18 87.16,69.18 88.64,67.7 93.7,67.7 93.89,67.9 94.57,67.9 96.81,70.14 98.33,70.14 98.62,69.84 100,69.84 100.45,69.39 100.9,69.39 101.44,68.85 102.59,68.85 102.81,68.63 110.1,68.63 110.49,68.24 111.1,68.24 111.97,67.36 114.08,67.36 114.85,66.6 116.18,66.6
  BOTTOM w0.076: UC1.Y7 117.34,63.28 v2(117.16,63.46)
  BOTTOM w0.102: R3.1 v2(19.66,19.1) R10.1
PCH_SPI_CS1#: length 143.3
  IN1 w0.097: v2(18.77,19.1) 18.77,19.68 22.68,23.58 26.24,23.58 28.8,26.15 28.8,41.01 38.3,50.51 39.9,50.51 40.98,51.59 40.98,58.54 43.69,61.25 43.69,62.83 44.2,63.34 47.38,63.34 50.21,66.17 68.62,66.17 70.88,68.42 73.6,68.42 v2(73.89,68.13)
  IN3 w0.102: v2(73.89,68.13) 73.76,68.25 73.76,68.83 74.18,69.24 74.94,69.24 75.18,68.99 75.18,68.62 75.77,68.03 77.24,68.03 79.5,70.29 85.56,70.29 86.22,70.95 92.64,70.95 93.62,71.94 98.2,71.94 98.78,71.35 100.87,71.35 101.9,70.32 102.79,70.32 103.34,69.77 110.18,69.77 110.81,70.4 112.28,70.4 113.03,69.65 114.99,69.65 115.61,69.03 116.62,69.03 v2(117.12,68.53)
  BOTTOM w0.076: UC1.Y4 117.92,65.64 117.92,66.03 117.96,66.07 117.96,66.86 117.8,67.02 117.8,67.34 117.67,67.46 117.67,67.98 v2(117.12,68.53)
  BOTTOM w0.102: R14.1 v2(18.77,19.1) R17.1
PCH_SPI_DIN: length 143.1
  IN1 w0.097: v2(17.88,19.1) 22.58,23.81 26.14,23.81 28.58,26.24 28.58,41.1 38.21,50.74 39.81,50.74 40.75,51.68 40.75,58.63 43.46,61.34 43.46,62.93 44.12,63.59 47.26,63.59 50.05,66.39 68.09,66.39 70.52,68.82 74.02,68.82 v2(74.21,68.63)
  IN3 w0.102: v2(118.63,65.6) 117.21,67.02 115.12,67.02 114.35,67.8 113.22,67.8 112.64,68.38 111.5,68.38 111.26,68.62 110.65,68.62 110.26,69.01 102.97,69.01 102.75,69.23 101.61,69.23 100.94,69.9 100.71,69.9 99.72,70.89 93.22,70.89 92.83,70.5 86.41,70.5 85.75,69.83 79.69,69.83 77.43,67.57 75.53,67.57 75.13,67.96 74.88,67.96 v2(74.21,68.63)
  BOTTOM w0.076: v2(118.63,65.6) 118.29,65.26 UC1.AA4
  BOTTOM w0.102: R15.1 R41.1 R22.1 v2(17.88,19.1) R4.1
PCH_SPI_DO: length 144.8
  IN1 w0.097: v2(75.6,68.83) 75.16,68.38 75.03,68.38 73.89,67.24 70.65,67.24 68.91,65.49 50.68,65.49 45.55,60.37 43.82,60.37 41.65,58.2 41.65,51.31 40.17,49.83 38.57,49.83 29.5,40.76 29.5,25.9 26.55,22.95 26.55,22.34 23.37,19.17 v2(22.2,19.17)
  IN3 w0.102: v2(117.27,69.64) 117.07,69.84 114.53,69.84 114.49,69.88 113.13,69.88 112.37,70.63 110.72,70.63 110.05,69.96 103.47,69.96 102.88,70.55 102.02,70.55 101,71.58 98.88,71.58 98.29,72.17 93.53,72.17 92.54,71.18 86.13,71.18 85.46,70.51 79.41,70.51 77.15,68.25 75.92,68.25 75.6,68.57 v2(75.6,68.83)
  BOTTOM w0.076: UC1.AA2 118.25,66.8 117.96,67.09 117.96,67.4 117.84,67.53 117.84,69.08 v2(117.27,69.64)
  BOTTOM w0.102: R11.1 R12.1 R9.2 ; R11.1 R21.2 ; R11.1 25.37,18.33 25.37,19.93 25.12,20.18 23.66,20.18 22.64,19.17 v2(22.2,19.17)
PCH_SPI_DO2: length 145.3
  IN1 w0.097: 119.54,68.13 117.92,66.5 117.92,65.25 117.57,64.9 117.57,64.57 117.16,64.16 v2(117.16,64.11) ; v2(35.22,19.17) 35.22,19.74 29.98,24.98 29.98,40.61 38.74,49.37 40.35,49.37 42.1,51.12 42.1,58.01 43.99,59.91 45.86,59.91 51,65.05 69.1,65.05 70.78,66.73 74.01,66.73 74.74,67.45 v2(75.03,67.45)
  IN1 w0.102: v2(121.23,70.02) 120.88,69.66 120.88,68.32 120.69,68.13 119.54,68.13
  IN3 w0.076: v2(117.16,64.11) 116.8,64.46 116.8,65.15 116.69,65.27 116.69,66.41 116.31,66.79
  IN3 w0.102: 116.31,66.79 114.97,66.79 114.16,67.61 113.12,67.61 112.53,68.19 111.42,68.19 111.18,68.43 110.57,68.43 110.18,68.82 102.89,68.82 102.67,69.04 101.52,69.04 100.94,69.62 100.55,69.62 100.1,70.07 98.72,70.07 98.42,70.36 96.71,70.36 95.15,68.8 93.79,68.8 92.92,67.93 88.73,67.93 87.25,69.41 79.6,69.41 77.46,67.28 75.21,67.28 v2(75.03,67.45)
  BOTTOM w0.076: v2(117.16,64.11) 117.34,63.93 UC1.Y6
  BOTTOM w0.102: R19.1 v2(35.22,19.17) R58.2 R59.2 R6.1 ; v2(121.23,70.02) 121.23,70.25 R1.2
PCH_SPI_DO3: length 143.7
  IN1 w0.097: v2(33.31,19.17) 33.31,21.33 29.76,24.88 29.76,40.7 38.65,49.6 40.26,49.6 41.87,51.21 41.87,58.11 43.91,60.14 45.71,60.14 50.84,65.27 69,65.27 70.72,66.98 73.95,66.98 75.09,68.13 75.67,68.13 76.2,68.66 v2(76.2,68.83)
  IN3 w0.102: v2(76.2,68.83) 76.54,68.48 77.03,68.48 79.9,71.36 82.9,71.36 83.6,72.06 86.59,72.06 87.25,71.41 88.72,71.41 90.05,72.75 90.05,73.2 90.29,73.44 92.29,73.44 93.33,72.39 98.39,72.39 98.97,71.81 101.09,71.81 102.12,70.78 102.98,70.78 103.57,70.19 109.9,70.19 111.18,71.48 111.84,71.48 113.22,70.1 116.49,70.1 117.02,70.63 117.37,70.63 117.91,70.1 117.91,69.64 119.04,68.51 v2(120.41,68.51)
  BOTTOM w0.076: UC1.AF1 120.5,68.41 v2(120.41,68.51) 119.98,68.94 119.98,69.79 120.03,69.84
  BOTTOM w0.102: R2.2 120.75,70.57 120.03,69.84 ; R16.2 v2(33.31,19.17) R43.2 R48.2 R5.2
PCH_TXCLK+: length 15.9
  TOP w0.102: JLVDS1.26 96.7,127.92 96.81,127.81 97.63,127.81 99.41,126.02 v3(99.41,119.56) 99.41,117.21 100.05,116.58 101,116.58 101.36,116.22 U52.35
PCH_TXCLK-: length 15.4
  TOP w0.102: JLVDS1.27 96.7,127.42 96.81,127.54 97.52,127.54 97.66,127.4 99.15,125.91 v3(99.15,117.34) 99.15,117.1 99.94,116.31 100.89,116.31 100.96,116.24 U52.36
PCH_TXOUT0+: length 14
  TOP w0.102: JLVDS1.33 96.52,124.42 96.67,124.27 96.85,124.27 97.15,123.96 97.15,115.98 v3(97.7,115.43) 98.09,115.04 98.09,114.37 98.54,113.92 98.92,113.54 99.16,113.3 99.41,113.3 99.48,113.37 U52.41
PCH_TXOUT0-: length 14
  TOP w0.102: JLVDS1.34 96.54,123.92 96.62,124.01 96.74,124.01 96.89,123.85 96.89,115.87 97.51,115.24 97.83,114.93 97.83,114.26 v3(98.73,113.35) 99.05,113.03 99.41,113.03 99.48,112.97 U52.42
PCH_TXOUT1+: length 14.2
  TOP w0.102: JLVDS1.31 96.7,125.42 96.81,125.31 97.1,125.31 97.9,124.51 v3(97.9,120.76) 97.9,116.31 98.86,115.35 98.86,114.7 99.45,114.1 99.67,114.1 99.73,114.17 U52.39
PCH_TXOUT1-: length 14.2
  TOP w0.102: JLVDS1.32 96.7,124.92 96.81,125.04 96.99,125.04 97.64,124.4 v3(97.64,118.55) 97.64,116.2 98.59,115.24 98.59,114.59 99.34,113.83 99.67,113.83 99.73,113.77 U52.40
PCH_TXOUT2+: length 14.3
  TOP w0.102: U52.37 99.73,114.97 99.61,115.09 99.61,115.68 98.65,116.64 98.65,125.07 v3(97.66,126.06) 97.41,126.31 96.81,126.31 96.7,126.42 JLVDS1.29
PCH_TXOUT2-: length 14.4
  TOP w0.102: JLVDS1.30 96.7,125.92 96.81,126.04 97.3,126.04 98.39,124.96 v3(98.39,123.56) 98.39,116.53 99.34,115.57 99.34,114.98 99.75,114.57 U52.38
PCH_TZCLK+: length 22.6
  TOP w0.102: JLVDS1.16 96.62,132.92 96.74,132.81 v3(97.38,132.81) 97.98,132.81 99.6,131.18 102.41,128.37 102.41,119.61 102.97,119.05 103.6,119.05 105.29,117.36 105.29,116.51 105.36,116.45 U52.25
PCH_TZCLK-: length 22.2
  TOP w0.102: U52.26 104.96,116.45 105.03,116.51 105.03,117.25 103.49,118.79 102.86,118.79 102.15,119.5 102.15,128.26 v3(99.41,130.99) 97.87,132.54 96.73,132.54 96.62,132.42 JLVDS1.17
PCH_TZOUT0+: length 17.9
  TOP w0.102: U52.31 102.96,116.2 102.89,116.26 102.89,116.52 102.61,116.81 101.98,116.81 100.16,118.62 v3(100.16,121.4) 100.16,126.76 97.61,129.31 96.81,129.31 96.7,129.42 JLVDS1.23
PCH_TZOUT0-: length 17.5
  TOP w0.102: JLVDS1.24 96.7,128.92 96.81,129.04 97.5,129.04 99.9,126.65 v3(99.9,126.04) 99.9,118.51 101.87,116.54 102.5,116.54 102.63,116.41 102.63,116.26 102.56,116.19 U52.32
PCH_TZOUT1+: length 19.4
  TOP w0.102: U52.29 103.76,116.2 103.67,116.29 103.67,116.83 102.95,117.56 102.31,117.56 101.35,118.51 100.91,118.95 100.91,127.32 v3(98.83,129.39) 97.92,130.31 96.81,130.31 96.7,130.42 JLVDS1.21
PCH_TZOUT1-: length 19
  TOP w0.102: JLVDS1.22 96.7,129.92 96.81,130.04 97.81,130.04 98.65,129.21 100.65,127.2 100.65,118.84 v3(101.16,118.33) 102.2,117.29 102.83,117.29 103.4,116.72 103.4,116.26 103.36,116.22 U52.30
PCH_TZOUT2+: length 20.9
  TOP w0.102: JLVDS1.19 96.7,131.42 96.81,131.31 98.21,131.31 v3(101.03,128.48) 101.66,127.85 101.66,119.28 102.27,118.67 102.64,118.3 103.27,118.3 103.6,117.97 104.49,117.08 104.49,116.22 104.56,116.16 U52.27
PCH_TZOUT2-: length 20.5
  TOP w0.102: JLVDS1.20 96.7,130.92 96.81,131.04 98.1,131.04 100.85,128.29 101.4,127.74 101.4,119.17 102.53,118.04 103.16,118.04 v3(103.42,117.78) 104.23,116.97 104.23,116.26 104.16,116.19 U52.28
PCI_5048: length 6
  TOP w0.102: R53.2 127.36,84.64 UC5.3 124.83,84.64 CC57.2 RC61.1 124.64,83.51 v1(124.1,82.98)
PCI_CLK_LPC: length 88.3
  TOP w0.076: v2(134.66,65.21) 134.52,65.07 RC65.2
  TOP w0.102: R63.1 129.3,86.82 R38.1 127.83,87.18 UC5.1 ; R63.1 130.35,86.65 130.35,87.4 130.62,87.67 136.64,87.67 v1(136.82,87.49) 137.3,87.01 137.3,84.36 138.42,83.24 147.29,83.24 150.69,86.64 154.39,86.64 154.63,86.4 154.63,86.03 154.98,85.69 155.84,85.69 157.93,83.6 161.29,83.6 162.78,82.11 v2(162.78,80.74) ; R63.1 128.42,84.72 R53.1
  IN1 w0.097: v2(134.66,65.21) 134.66,65.21 134.66,65.14 135.42,64.38 137.38,64.38 139.94,66.94 139.94,68.17 142.04,70.27 145.36,70.27 145.49,70.4 153.69,70.4 154.08,70.78 157.96,70.78 159.89,72.71 159.89,78.25 162.38,80.74 v2(162.78,80.74)
PCI_CLK_LPC_0: length 14.8
  TOP w0.102: v2(125.26,58.7) 125.26,58.77 125.6,59.11 126.85,59.11 127.42,58.54 128.41,58.54 129.23,59.36 130,59.36 130.32,59.68 130.78,59.68 131.63,60.53 v1(131.84,60.53) 132.27,60.53 132.8,61.07 134.15,61.07 135.4,62.32 CC15.2 RC65.1
  BOTTOM w0.076: UC1.AN15 124.94,59.02 v2(125.26,58.7)
PCI_CLK_LPC_1: length 15.5
  TOP w0.102: v2(125.91,58.7) 126.33,58.28 128.56,58.28 129.45,59.17 130.08,59.17 130.4,59.49 130.91,59.49 131.48,60.06 132.12,60.06 132.87,60.81 134.26,60.81 v1(136.07,62.61) 136.29,62.84 CC14.2 RC64.1 RC66.1
  BOTTOM w0.076: UC1.AP15 125.59,59.02 v2(125.91,58.7)
PCI_FBIN: length 2.8
  TOP w0.102: CC80.2 134.44,86.15 RC100.1 133.27,85.91 UC5.7
PCI_MEC: length 6.2
  TOP w0.102: R63.2 130.57,84.64 UC5.6 132.5,84.64 133.01,85.14 RC63.1 133.52,85.14 133.98,84.68 v1(135.42,84.68)
PCI_TPM_TCM: length 5.9
  TOP w0.102: RC58.1 124.19,86.8 v1(125.03,86.8) 125.03,86.55 124.64,86.16 CC25.2 125.03,85.78 125.16,85.91 UC5.2 128.19,85.91 R38.2
PCIE_CLKRQ4#: length 35.8
  TOP w0.076: v2(115.33,64.18) 115.53,64.18 115.82,64.47 115.82,64.73 116.27,65.18 116.35,65.18 116.56,65.38 116.56,69.08 RC187.1
  TOP w0.102: RC162.1 110.54,86.47 111.91,86.47 112.19,86.19 112.19,85.56 111.84,85.21 v2(111.54,85.21) 111.29,84.95 RC166.2
  IN2 w0.076: v2(115.33,64.18) 115.64,64.49 115.64,64.99 115.21,65.42 115.21,66.67 114.22,67.67 114.22,69.26 113.64,69.84
  IN2 w0.102: 113.64,69.84 113.09,70.39 113.09,71.31 112.27,72.12 112.27,72.85 111.29,73.83 111.29,75.45 110.51,76.22 110.51,77.93 110.67,78.08 110.67,84.33 v2(111.54,85.21)
  BOTTOM w0.076: v2(115.33,64.18) 115.73,64.58 UC1.U5
PCIE_LAN: length 5.4
  BOTTOM w0.076: 105.75,42.68 105.76,42.67 105.78,42.67 105.84,42.61 106.13,42.61 106.19,42.55 106.19,42.3 106.31,42.18 106.64,42.18 106.69,42.23 106.69,42.4 106.62,42.47 UC1.A41
  BOTTOM w0.102: RC49.1 102.79,42.13 103.48,42.13 104.08,42.73 105.71,42.73 105.75,42.68
PCIE_LAN#: length 5.3
  BOTTOM w0.076: 105.94,42.87 106.7,42.87 107.1,42.47 UC1.B41
  BOTTOM w0.102: 105.94,42.87 105.82,42.99 103.96,42.99 v3(103.73,42.75) 103.37,42.4 102.76,42.4 RC48.1
PCIE_MCARD1_DET#: length 267.3
  TOP w0.102: RC185.2 111.29,71.01 v2(111.35,71.07)
  IN2 w0.102: v2(111.35,71.07) 110.73,71.7 102.41,71.7 101.86,72.25 101.86,77.37 109.29,84.81 109.29,86.17 110.49,87.37 111.25,87.37 112.52,88.64 117.77,88.64 118.4,89.26 121.67,89.26 122.59,88.33 123.93,88.33 125.25,89.65 132.51,89.65 133.27,88.89 134.66,88.89 135.19,89.42 147.58,89.42 151.65,93.49 151.65,94.13 151.92,94.4 155.94,94.4 156.55,93.79 157.39,93.79 157.96,94.36 157.96,96.87 159.65,98.56 169.43,98.56 170.27,97.72 170.67,97.72 172.78,99.84 172.78,101.62 173.52,102.35 174.96,102.35 177.08,104.46 177.08,108.25 184.31,115.49 184.31,120.9 191.4,127.98 196.86,127.98 197.46,127.38 210.47,127.38 215.82,132.73 215.82,133.66 218.2,136.03 220.12,136.03 226.49,142.41 226.49,144.01 232.6,150.12 232.6,152.08 238.07,157.55 238.07,158.53 241.52,161.98 246.35,161.98 246.99,162.61 253.53,162.61 254.74,161.41 260.81,161.41 262.91,159.31 265.47,159.31 266.55,158.23 274.67,158.23 275.31,157.6 287.5,157.6 v2(290.93,154.17)
  BOTTOM w0.076: UC1.J1 111.49,67.24 111.49,68.08 110.41,69.16 110.41,69.84
  BOTTOM w0.102: v2(111.35,71.07) 111.2,71.07 v1(110.5,70.37) 110.41,70.28 110.41,69.84 ; v2(290.93,154.17) 291.86,155.1 JMINI1.37
PCIE_MINI2: length 9.1
  BOTTOM w0.076: 103.99,44.95 104.01,44.95 104.02,44.94 104.15,44.94 104.24,44.84 104.66,44.84 104.69,44.87 105.21,44.87 105.23,44.84 106.18,44.84 106.21,44.87 106.21,45.14 106.27,45.2 106.46,45.2 106.54,45.13 UC1.A37
  BOTTOM w0.102: 103.99,44.95 103.17,44.95 v3(101.93,46.19) 101.66,46.46 99.03,46.46 RC60.1
PCIE_MINI2#: length 9.4
  BOTTOM w0.076: 103.99,44.68 v3(104.95,44.68) 106.64,44.68 106.94,44.98 UC1.B37
  BOTTOM w0.102: RC59.1 99,46.19 101.55,46.19 101.74,46.01 103.06,44.68 103.99,44.68
PCIE_MMI: length 8.7
  BOTTOM w0.076: UC1.B42 107.4,41.91 107.31,41.81 106.35,41.81 106.3,41.76 104.54,41.76 104.35,41.58
  BOTTOM w0.102: RC54.1 99.92,41.71 100.19,41.71 v3(100.57,41.34) 100.9,41 103.79,41 104.35,41.57 104.35,41.58
PCIE_MMI#: length 9.2
  BOTTOM w0.076: UC1.C41 107.59,42.22 107.38,42.22 107.16,42 104.44,42 104.27,41.83 104.25,41.83 104.18,41.77 104.18,41.77 104.16,41.75
  BOTTOM w0.102: 104.16,41.75 103.68,41.27 v3(103.44,41.27) 101.02,41.27 100.75,41.53 100.3,41.98 99.92,41.98 RC53.1
PCIE_PRX_EXPTX_N: length 34.8
  TOP w0.102: JEXP1.22 93.06,19.43 92.9,19.59 92.9,20.08 v2(93.09,20.27)
  IN1 w0.097: v2(118.21,11.1) 118.21,11.17 117.85,11.53 117.49,11.53 116.41,10.45 112.55,10.45 109.54,13.45 103.1,13.45 101.53,15.03 101.53,15.8 100.27,17.07 100.27,17.96 99.09,19.13 94.96,19.13 93.33,20.76 92.9,20.76 92.82,20.67 92.82,20.53 93.07,20.27 v2(93.09,20.27)
  BOTTOM w0.102: R94.1 118.71,11.1 v2(118.21,11.1) 117.72,11.1 R97.1
PCIE_PRX_EXPTX_N_M: length 184.3
  TOP w0.102: U91.21 164.55,136.06 164.69,136.2 169.27,136.2 170.9,134.57 170.9,130.95 172.22,129.63 174.51,129.63 175.21,128.93 175.96,128.93 v2(176.12,128.78)
  IN3 w0.102: v2(176.12,128.78) 176.32,128.97 176.43,128.97 176.57,128.83 176.57,126.35 179.09,123.82 179.09,119.77 183.78,115.09 183.78,113.03 184.61,112.2 184.61,94.56 182.6,92.56 181.79,92.56 179.64,90.41 178.2,90.41 175.93,88.14 174,88.14 172.48,86.61 172.48,85.85 170.7,84.07 170.7,82.21 169.2,80.71 165.85,80.71 165.46,80.32 161.19,80.32 160.36,79.49 160.36,76.22 160.67,75.91 160.67,75.36 v2(160.3,74.99)
  BOTTOM w0.102: v2(160.3,74.99) 160.65,75.34 160.65,75.46 160.54,75.58 159.71,75.58 159.32,75.18 156.16,75.18 153.41,72.44 153.41,66.29 155.12,64.59 155.12,39.69 136.26,20.83 129.86,20.83 128.24,19.21 128.24,16.46 127.66,15.88 126.82,15.88 126.81,15.87 126.28,15.87 126.26,15.88 125.07,15.88 120.6,11.41 119.71,11.41 119.63,11.33 119.63,11.09 R94.2
PCIE_PRX_EXPTX_P: length 34.8
  TOP w0.102: JEXP1.24 92.56,19.47 92.68,19.6 92.68,20.09 v2(92.51,20.27)
  IN1 w0.097: v2(92.51,20.27) 92.61,20.37 92.61,20.76 92.81,20.97 93.42,20.97 95.04,19.34 99.18,19.34 100.48,18.04 100.48,17.15 101.74,15.89 101.74,15.12 103.19,13.66 109.63,13.66 112.64,10.66 116.33,10.66 117.4,11.74 v2(118.21,11.74)
  BOTTOM w0.102: R95.1 118.71,11.74 v2(118.21,11.74) 117.72,11.74 R96.1
PCIE_PRX_EXPTX_P_M: length 184.2
  TOP w0.102: U91.22 164.55,136.56 164.69,136.42 169.36,136.42 171.12,134.66 171.12,131.04 172.31,129.85 174.6,129.85 175.3,129.15 175.91,129.15 v2(176.12,129.36)
  IN3 w0.102: v2(176.12,129.36) 176.12,129.36 176.3,129.18 176.52,129.18 176.78,128.92 176.78,126.44 179.31,123.91 179.31,119.86 184,115.18 184,113.12 184.82,112.29 184.82,94.47 182.69,92.34 181.88,92.34 179.73,90.2 178.29,90.2 176.02,87.92 174.09,87.92 172.69,86.52 172.69,85.76 170.91,83.99 170.91,82.12 169.29,80.5 165.94,80.5 165.55,80.1 161.28,80.1 160.58,79.4 160.58,76.31 160.89,76 v2(160.89,74.99)
  BOTTOM w0.102: R95.2 119.99,11.62 120.51,11.62 124.98,16.09 v3(126.54,16.09) 127.57,16.09 128.03,16.55 128.03,19.3 129.77,21.04 136.17,21.04 154.9,39.78 154.9,64.5 153.2,66.21 153.2,72.53 156.07,75.4 159.23,75.4 159.62,75.79 160.63,75.79 160.87,75.55 160.87,75.01 v2(160.89,74.99)
PCIE_PRX_GLANTX_N3: length 127.1
  TOP w0.102: C176.2 172.34,140.87 172.24,140.97 171.88,140.97 171.72,140.81 v2(171.72,140.65)
  IN1 w0.076: v2(110.18,60.4) 109.93,60.66 109.93,60.73 109.69,60.98 108.53,60.98 108.46,61.05 108.46,61.71 108.05,62.11 108.05,65.26 108.72,65.93
  IN1 w0.097: 108.72,65.93 108.75,65.93 109.7,66.88 109.7,71.94 112.32,74.55 112.32,75.35 112.02,75.65 112.02,79.93 112.56,80.47 113.32,80.47 114.23,81.38 117.87,81.38 119.84,83.35 123.44,83.35 124.65,84.55 125.29,84.55 132.58,91.85 132.58,98.06 133.67,99.15 134.75,99.15 136.29,100.69 136.29,103.48 136.56,103.75 136.56,106.38 137.13,106.95 137.13,109.6 136.46,110.28 136.46,116.49 137.09,117.13 138.19,117.13 138.85,117.78 138.85,118.32 140.59,120.06 141.39,120.06 143.89,122.57 145.96,122.57 146.99,123.59 146.99,124.15 147.7,124.85 148.18,124.85 157.73,134.4 157.73,138.28 159.51,140.05 160.72,140.05 162.81,142.15 168.9,142.15 170.4,140.65 v2(171.72,140.65)
  BOTTOM w0.089: v2(110.18,60.4) 110.18,60.53 UC1.G11
